# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ8: length 100.8
  TOP w0.102: JDIM1003.24 119.35,39.4 118.07,38.12 118.07,36.26 v1(118.68,35.65)
  IN1 w0.102: v1(118.68,35.65) 117.97,36.36 117.97,37.78 114.51,41.24 114.51,43.65 114.66,43.8 114.66,44.31 114.54,44.44 114.54,45.02 114.69,45.18 114.69,47.33 114.51,47.51 114.51,47.76 114.69,47.94 114.69,48.19 114.51,48.37 114.51,48.63 114.69,48.8 114.69,49.06 114.51,49.23 114.51,49.49 114.69,49.67 114.69,50.99 114.29,51.39 114.29,54.04 113.91,54.41 113.91,55.23 114.13,55.45 114.13,60.38 119.07,65.32 119.07,70.44 119.17,70.55 119.52,70.55 119.62,70.65 119.62,70.88 119.52,70.98 119.17,70.98 119.07,71.08 119.07,72.42 119.77,73.13 119.77,73.46 119.67,73.56 119.51,73.56 119.41,73.66 119.41,73.89 119.51,73.99 119.67,73.99 119.77,74.09 119.77,74.32 119.67,74.42 119.51,74.42 119.41,74.52 119.41,74.75 119.51,74.85 119.67,74.85 119.77,74.95 119.77,75.18 119.67,75.28 119.51,75.28 119.41,75.39 119.41,75.62 119.51,75.72 119.64,75.72 119.77,75.84 119.77,82.66 124.51,87.41 124.51,93.72 130.2,99.4 132.61,99.4 138.89,105.68 140.85,105.68 141.69,106.53 v1(141.69,107.23)
  BOTTOM w0.076: U9001.BL12 142.02,107.56 v1(141.69,107.23)
  BOTTOM w0.102: JDIM1002.24 119.35,33.23 119.51,33.38 119.67,33.38 119.79,33.51 119.79,33.76 119.11,34.45 119.11,35.23 v1(118.68,35.65)
M_B_DQ9: length 101.2
  TOP w0.102: v1(118.68,36.29) 118.5,36.29 118.28,36.52 118.28,37.94 118.62,38.28 118.76,38.28 118.88,38.16 119.03,38.16 119.17,38.31 119.17,38.45 119.05,38.57 119.05,38.72 119.54,39.21 120.17,39.21 120.35,39.39 JDIM1003.28
  IN1 w0.102: v1(142.49,107.22) 141.97,106.7 141.97,106.49 140.83,105.35 139.03,105.35 132.8,99.13 130.39,99.13 124.84,93.58 124.84,87.27 120.1,82.52 120.1,82.19 120.2,82.09 120.4,82.09 120.5,81.99 120.5,81.76 120.4,81.66 120.2,81.66 120.1,81.56 120.1,81.33 120.2,81.23 120.4,81.23 120.5,81.13 120.5,80.9 120.4,80.8 120.2,80.8 120.1,80.7 120.1,72.67 120,72.57 119.67,72.57 119.57,72.46 119.57,72.24 119.67,72.13 120,72.13 120.1,72.03 120.1,71.8 120,71.7 119.67,71.7 119.57,71.6 119.57,71.37 119.67,71.27 119.95,71.27 120.1,71.12 120.1,70.46 119.4,69.76 119.4,65.18 114.46,60.25 114.46,57.62 114.81,57.27 114.81,54.95 114.62,54.76 114.62,51.53 115.02,51.13 115.02,41.2 118.3,37.92 118.3,36.67 v1(118.68,36.29)
  BOTTOM w0.076: U9001.BL11 142.1,106.84 v1(142.49,107.22)
  BOTTOM w0.102: JDIM1002.28 120.35,33.57 119.41,34.51 119.41,35.56 v1(118.68,36.29)
M_B_DQ10: length 98.9
  TOP w0.102: JDIM1003.25 119.6,33.11 119.16,33.56 119.16,37.08 v1(118.68,37.56)
  IN1 w0.102: v1(118.68,37.56) 118.68,38.01 115.35,41.34 115.35,50.77 115.4,50.82 115.4,54.46 115.84,54.89 115.84,55.23 115.74,55.33 115.65,55.33 115.55,55.43 115.55,55.66 115.65,55.76 115.74,55.76 115.84,55.86 115.84,56.09 115.74,56.19 115.65,56.19 115.55,56.29 115.55,56.52 115.84,56.81 115.84,61.16 119.73,65.05 119.73,67.05 119.83,67.15 120.28,67.15 120.38,67.26 120.38,67.48 120.28,67.59 119.83,67.59 119.73,67.69 119.73,67.92 119.83,68.02 120.28,68.02 120.38,68.12 120.38,68.35 120.28,68.45 119.83,68.45 119.73,68.55 119.73,68.78 119.83,68.88 120.28,68.88 120.38,68.98 120.38,69.21 120.28,69.31 119.83,69.31 119.73,69.42 119.73,69.62 120.43,70.32 120.43,78.12 120.53,78.22 120.73,78.22 120.83,78.32 120.83,78.6 120.73,78.71 120.53,78.71 120.43,78.81 120.43,79.04 120.53,79.14 120.73,79.14 120.83,79.24 120.83,79.47 120.73,79.57 120.53,79.57 120.43,79.67 120.43,79.9 120.53,80 120.71,80 120.83,80.13 120.83,82.79 125.17,87.13 125.17,93.44 130.58,98.85 133.7,98.85 137.72,102.86 138.32,102.86 140.54,105.08 141.12,105.08 v1(141.69,105.66)
  BOTTOM w0.076: v1(141.69,105.66) 142.02,105.33 U9001.BL8
  BOTTOM w0.102: JDIM1002.25 119.6,39.33 119.2,38.92 118.57,38.92 118.14,38.5 118.14,37.4 118.24,37.3 118.43,37.3 v1(118.68,37.56)
M_B_DQ11: length 99.6
  TOP w0.102: v1(121.89,36.11) 121.06,36.94 121.06,38.06 122.21,39.21 122.71,39.21 122.85,39.35 JDIM1003.38
  IN1 w0.102: v1(143.36,105.27) 142.93,104.85 142.93,104.38 141.74,103.18 141.31,103.18 140.16,102.04 140.16,100.39 136.82,97.04 131.9,97.04 127.38,92.53 127.38,86.22 123.04,81.88 123.04,81.52 123.12,81.45 123.37,81.45 123.47,81.34 123.47,81.12 123.37,81.01 123.15,81.01 123.04,80.91 123.04,80.68 123.15,80.58 123.37,80.58 123.47,80.48 123.47,80.25 123.37,80.15 123.15,80.15 123.04,80.05 123.04,79.82 123.15,79.72 123.37,79.72 123.47,79.62 123.47,79.39 123.37,79.29 123.15,79.29 123.04,79.19 123.04,78.96 123.15,78.86 123.37,78.86 123.47,78.75 123.47,78.5 123.39,78.42 123.15,78.42 123.04,78.32 123.04,78.09 123.15,77.99 123.37,77.99 123.47,77.89 123.47,77.66 123.37,77.56 123.15,77.56 123.04,77.46 123.04,77.23 123.15,77.13 123.39,77.13 123.47,77.05 123.47,76.8 123.37,76.7 123.15,76.7 123.04,76.59 123.04,76.37 123.15,76.26 123.37,76.26 123.47,76.16 123.47,75.93 123.37,75.83 123.15,75.83 123.04,75.73 123.04,75.5 123.15,75.4 123.39,75.4 123.47,75.32 123.47,75.07 123.37,74.97 123.15,74.97 123.04,74.87 123.04,66.77 121.94,65.66 121.94,64.13 118.49,60.69 118.49,41.32 121.33,38.48 121.33,36.57 121.53,36.37 121.63,36.37 v1(121.89,36.11)
  BOTTOM w0.076: v1(143.36,105.27) 143.03,104.95 U9001.BJ8
  BOTTOM w0.102: v1(121.89,36.11) 122.31,35.69 122.31,33.78 122.85,33.23 JDIM1002.38
M_B_DQ12: length 102.1
  TOP w0.102: JDIM1003.37 122.6,33.06 120.77,34.9 120.77,37.26 v1(120.36,37.67)
  IN1 w0.102: v1(120.36,37.67) 120.64,37.95 120.64,38.23 117.22,41.66 117.22,47.69 117.4,47.87 117.4,48.12 117.22,48.3 117.22,48.55 117.4,48.74 117.4,48.99 117.22,49.17 117.22,49.5 117.4,49.68 117.4,60.53 121.27,64.4 121.27,65.96 121.98,66.66 121.98,70.07 122.08,70.17 122.31,70.17 122.38,70.25 122.38,70.53 122.31,70.6 122.08,70.6 121.98,70.71 121.98,70.93 122.08,71.04 122.31,71.04 122.38,71.11 122.38,71.39 122.31,71.47 122.08,71.47 121.98,71.57 121.98,71.8 122.08,71.9 122.28,71.9 122.38,72 122.38,72.23 122.28,72.33 122.08,72.33 121.98,72.43 121.98,72.66 122.08,72.76 122.28,72.76 122.38,72.86 122.38,73.09 122.28,73.19 122.05,73.19 121.98,73.27 121.98,73.52 122.08,73.63 122.28,73.63 122.38,73.73 122.38,73.96 122.28,74.06 122.08,74.06 121.98,74.16 121.98,74.39 122.08,74.49 122.28,74.49 122.38,74.59 122.38,74.82 122.28,74.92 122.08,74.92 121.98,75.02 121.98,75.25 122.08,75.35 122.28,75.35 122.38,75.46 122.38,75.68 122.28,75.79 122.08,75.79 121.98,75.89 121.98,76.12 122.08,76.22 122.28,76.22 122.38,76.32 122.38,76.57 122.31,76.65 122.08,76.65 121.98,76.75 121.98,76.98 122.08,77.08 122.28,77.08 122.38,77.18 122.38,82.15 126.72,86.49 126.72,92.8 131.52,97.6 136.7,97.6 139.48,100.38 139.48,101.99 141.17,103.68 141.67,103.68 142.54,104.54 142.54,105.37 142.95,105.78 142.95,106.38 143.14,106.57 v1(143.36,106.57)
  BOTTOM w0.076: U9001.BJ11 143.03,106.9 v1(143.36,106.57)
  BOTTOM w0.102: v1(120.36,37.67) 120.36,38.21 120.66,38.51 120.92,38.51 121.02,38.61 121.02,38.95 121.13,39.05 121.4,39.05 121.51,38.95 121.51,38.61 121.61,38.51 122.01,38.51 122.6,39.1 JDIM1002.37
M_B_DQ13: length 102.5
  TOP w0.102: JDIM1003.41 123.6,33.24 123.09,33.75 122.95,33.75 122.75,33.55 122.55,33.55 122.41,33.7 122.41,33.9 122.61,34.09 122.61,34.24 122.46,34.38 121.62,34.38 121.05,34.96 121.05,35.89 121.18,36.03 121.33,36.03 v1(121.89,35.47)
  IN1 w0.102: v1(143.36,105.92) 142.73,105.29 142.73,104.43 141.74,103.44 141.23,103.44 139.81,102.02 139.81,100.35 136.78,97.32 131.71,97.32 127.05,92.66 127.05,86.35 122.71,82.02 122.71,69.69 122.54,69.51 122.41,69.51 122.31,69.41 122.31,69.18 122.41,69.08 122.61,69.08 122.71,68.98 122.71,68.75 122.61,68.65 122.41,68.65 122.31,68.55 122.31,68.32 122.41,68.22 122.61,68.22 122.71,68.12 122.71,67.86 122.64,67.79 122.41,67.79 122.31,67.68 122.31,67.46 122.41,67.35 122.61,67.35 122.71,67.25 122.71,66.9 121.61,65.79 121.61,64.27 117.73,60.39 117.73,47.46 117.55,47.28 117.55,45.03 117.66,44.92 117.98,44.92 118.11,44.79 118.11,44.41 117.99,44.29 117.74,44.29 117.55,44.1 117.55,41.8 121,38.35 121,36.37 v1(121.89,35.47)
  BOTTOM w0.076: U9001.BJ10 143.03,106.25 v1(143.36,105.92)
  BOTTOM w0.102: v1(121.89,35.47) 121.49,35.88 121.49,37.55 122.13,38.19 122.29,38.19 123.6,39.51 JDIM1002.41
M_B_DQ14: length 100.5
  TOP w0.102: v1(120.36,34.49) 120.36,33.88 120.2,33.72 120,33.72 119.84,33.87 119.84,35.5 119.74,35.6 119.52,35.6 119.41,35.5 119.41,33.82 119.87,33.36 120.3,33.36 120.6,33.06 JDIM1003.29
  IN1 w0.102: v1(120.36,34.49) 119.06,35.79 119.06,38.09 115.68,41.48 115.68,50.64 115.73,50.69 115.73,54.32 116.17,54.76 116.17,61.02 120.06,64.91 120.06,66.47 120.76,67.17 120.76,77.65 121.16,78.06 121.16,82.66 125.5,87 125.5,93.31 130.76,98.57 134.48,98.57 136.43,100.52 136.64,100.52 138.07,101.95 138.33,101.95 138.63,102.25 138.63,102.67 140.8,104.84 v1(141.73,104.84)
  BOTTOM w0.076: U9001.BL7 142.01,104.56 v1(141.73,104.84)
  BOTTOM w0.102: v1(120.36,34.49) 119.92,34.94 119.92,38.7 120.6,39.38 JDIM1002.29
M_B_DQ15: length 101.1
  TOP w0.102: v1(121.89,37.38) 122.31,37.38 122.43,37.5 122.43,37.67 122.18,37.92 121.69,37.92 121.57,38.04 121.57,38.19 121.98,38.6 122.18,38.6 122.44,38.35 122.72,38.06 122.86,38.06 123.06,38.26 123.06,38.41 122.78,38.69 122.78,38.89 122.92,39.03 123.12,39.03 123.4,38.75 123.54,38.75 123.85,39.06 JDIM1003.42
  IN1 w0.102: v1(143.36,104.62) 143.36,104.47 141.83,102.94 141.35,102.94 140.52,102.12 140.52,100.43 136.86,96.76 132.09,96.76 127.71,92.39 127.71,86.08 125.79,84.16 125.79,84.02 125.85,83.96 125.85,83.82 125.67,83.64 125.53,83.64 125.47,83.69 125.33,83.69 125.15,83.51 125.15,83.37 125.2,83.32 125.2,83.17 125.02,82.99 124.88,82.99 124.82,83.05 124.68,83.05 124.5,82.87 124.5,82.72 124.56,82.67 124.56,82.52 124.38,82.35 124.23,82.35 124.18,82.4 124.03,82.4 123.8,82.17 123.8,74.07 123.67,73.94 123.48,73.94 123.37,73.84 123.37,73.61 123.48,73.51 123.7,73.51 123.8,73.41 123.8,73.18 123.7,73.08 123.48,73.08 123.37,72.98 123.37,72.75 123.48,72.65 123.7,72.65 123.8,72.55 123.8,72.32 123.7,72.22 123.48,72.22 123.37,72.12 123.37,71.89 123.48,71.79 123.7,71.79 123.8,71.68 123.8,71.46 123.7,71.35 123.48,71.35 123.37,71.25 123.37,71.02 123.48,70.92 123.7,70.92 123.8,70.82 123.8,70.59 123.7,70.49 123.48,70.49 123.37,70.39 123.37,70.16 123.48,70.06 123.7,70.06 123.8,69.96 123.8,69.73 123.7,69.63 123.48,69.63 123.37,69.53 123.37,69.3 123.48,69.2 123.7,69.2 123.8,69.09 123.8,68.86 123.7,68.76 123.48,68.76 123.37,68.66 123.37,68.43 123.48,68.33 123.7,68.33 123.8,68.23 123.8,67.98 123.6,67.78 123.6,67.47 123.8,67.27 123.8,67.04 122.27,65.5 122.27,63.99 118.82,60.55 118.82,47.75 119.29,47.29 119.29,41 121.89,38.39 v1(121.89,37.38)
  BOTTOM w0.076: v1(143.36,104.62) 143.03,104.3 U9001.BJ7
  BOTTOM w0.102: v1(121.89,37.38) 122.3,36.97 122.3,36.14 122.59,35.86 122.59,34.22 123.85,32.95 JDIM1002.42
M_B_DQ16: length 100.2
  TOP w0.102: JDIM1003.50 125.85,39.48 124.29,37.92 124.29,35.64 v1(123.42,34.77)
  IN1 w0.076: v1(145.19,107.21) 144.81,106.83 144.81,106.42 144.81,106.41 144.65,106.26 144.65,105.17 144.27,104.79
  IN1 w0.102: 144.27,104.79 143.48,104 143.19,104 141.99,102.8 141.99,102.35 140.8,101.15 140.8,100.3 136.91,96.41 132.41,96.41 128.79,92.78 128.79,86.07 124.28,81.57 124.28,66.84 122.75,65.3 122.75,63.79 119.31,60.35 119.31,47.95 120.26,47 120.26,40.71 122.38,38.59 122.38,35.81 v1(123.42,34.77)
  BOTTOM w0.076: v1(145.19,107.21) 144.88,106.9 U9001.BG11
  BOTTOM w0.102: JDIM1002.50 125.85,33.11 125.73,33.24 124.95,33.24 124.33,33.85 124.33,34 124.7,34.37 124.7,34.55 124.54,34.71 124.36,34.71 123.99,34.34 123.85,34.34 v1(123.42,34.77)
M_B_DQ17: length 99.4
  TOP w0.102: JDIM1003.46 124.85,39.45 124.58,39.17 124.58,39.03 124.75,38.85 124.75,38.71 124.56,38.51 124.41,38.51 124.21,38.71 124.04,38.71 123.84,38.51 123.84,38.08 124.01,37.91 124.01,37.58 123.82,37.39 123.82,36.98 124.01,36.79 124.01,36.16 123.89,36.04 v1(123.42,36.04)
  IN1 w0.076: v1(145.19,106.57) 144.81,106.19 144.81,105.07 144.39,104.65 144.39,104.41 144.3,104.33
  IN1 w0.102: v1(123.42,36.04) 123.17,36.28 123.09,36.28 122.71,36.67 122.71,38.73 120.59,40.84 120.59,49.64 120.14,50.09 120.14,54.29 119.74,54.69 119.74,57.19 120.14,57.58 120.14,60.71 123.08,63.66 123.08,65.16 124.61,66.7 124.61,77.56 124.82,77.77 124.82,78.5 124.61,78.71 124.61,79.36 124.74,79.48 124.92,79.48 125.03,79.59 125.03,79.84 124.92,79.94 124.71,79.94 124.61,80.04 124.61,80.3 124.71,80.4 124.92,80.4 125.03,80.5 125.03,80.75 124.92,80.86 124.74,80.86 124.61,80.98 124.61,81.43 129.12,85.94 129.12,92.65 132.58,96.1 136.79,96.1 137.09,95.8 137.48,95.8 142.6,100.92 143.29,100.92 143.57,101.2 143.57,103.59 144.3,104.33
  BOTTOM w0.076: v1(145.19,106.57) 144.86,106.25 U9001.BG10
  BOTTOM w0.102: v1(123.42,36.04) 123.01,35.63 123.01,34.6 123.74,33.87 123.93,33.87 124.85,32.95 JDIM1002.46
M_B_DQ18: length 98.2
  TOP w0.102: v1(123.42,36.67) 122.98,36.24 122.98,34.63 123.35,34.26 123.59,34.26 124.65,33.19 125.43,33.19 125.6,33.02 JDIM1003.49
  IN1 w0.102: v1(123.42,36.67) 123.16,36.67 123.04,36.8 123.04,38.14 123.09,38.19 123.09,38.81 120.92,40.98 120.92,50.07 120.47,50.52 120.47,50.89 120.61,51.03 120.61,51.37 120.47,51.51 120.47,51.82 120.61,51.96 120.61,52.18 120.47,52.32 120.47,54.43 120.07,54.82 120.07,56.2 120.15,56.28 120.35,56.28 120.48,56.4 120.48,56.58 120.35,56.71 120.17,56.71 120.07,56.81 120.07,57.04 120.47,57.43 120.47,60.58 123.41,63.52 123.41,65.03 124.94,66.56 124.94,76.72 125.64,77.42 125.64,77.7 125.49,77.85 125.36,77.85 125.25,77.95 125.25,78.21 125.36,78.31 125.54,78.31 125.64,78.41 125.64,78.66 125.54,78.76 125.36,78.76 125.25,78.87 125.25,79.12 125.36,79.22 125.54,79.22 125.64,79.32 125.64,81.99 129.45,85.8 129.45,92.51 132.81,95.87 136.56,95.87 136.84,95.59 137.61,95.59 142.7,100.69 143.34,100.69 143.77,101.11 143.77,103.39 144.66,104.28 144.66,104.66 145.19,105.19 v1(145.19,105.27)
  BOTTOM w0.076: U9001.BG8 144.86,104.95 v1(145.19,105.27)
  BOTTOM w0.102: JDIM1002.49 125.6,39.11 125.19,38.7 124.11,38.7 123.86,38.44 123.86,37.11 v1(123.42,36.67)
M_B_DQ19: length 99.8
  TOP w0.102: JDIM1003.62 128.85,39.41 128.28,38.83 127.08,38.83 126.96,38.7 126.96,38.34 127.08,38.21 127.58,38.21 127.68,38.11 127.68,37.85 127.56,37.73 127.18,37.73 127.03,37.57 127.03,36.54 v1(126.51,36.02)
  IN1 w0.076: 146.04,104.11 146.16,104.22 146.25,104.22 146.48,104.46 146.48,104.89 v1(146.1,105.27)
  IN1 w0.102: 146.04,104.11 144.86,102.93 144.86,99.64 144.7,99.48 140.37,95.14 140.37,93.78 138.3,91.71 138.3,91.14 134.91,87.75 134.05,87.75 127.54,81.23 127.54,70.61 126.82,69.89 126.82,65.78 125.29,64.25 125.29,62.74 123.44,60.89 123.44,58.02 123.01,57.59 123.01,48.27 123.23,48.05 123.23,41.33 125.56,39 125.56,38.59 125.66,38.49 125.97,38.49 126.07,38.39 126.07,38.13 125.97,38.03 125.66,38.03 125.56,37.93 125.56,37.68 125.66,37.58 125.97,37.58 126.07,37.47 126.07,37.22 125.97,37.12 125.66,37.12 125.56,37.02 125.56,36.76 125.66,36.66 125.97,36.66 126.07,36.56 126.07,36.31 125.97,36.2 125.66,36.2 125.56,36.1 125.56,34.81 125.66,34.71 125.94,34.71 126.05,34.83 126.05,35.57 v1(126.51,36.02)
  BOTTOM w0.076: v1(146.1,105.27) 145.78,104.95 U9001.BF8
  BOTTOM w0.102: JDIM1002.62 128.85,33 127.51,34.34 126.34,34.34 126.1,34.58 126.1,35.61 v1(126.51,36.02)
M_B_DQ20: length 102.2
  TOP w0.102: JDIM1003.63 129.1,33.71 128.81,34 128.56,34 128.43,33.87 128.43,33.62 128.3,33.49 128.05,33.49 127.41,34.13 127.41,35.93 127.31,36.03 127.03,36.03 126.93,35.93 126.93,34.91 126.77,34.75 v1(126.51,34.75)
  IN1 w0.076: v1(146.1,107.21) 146.57,106.74 146.57,106.48 146.63,106.41 146.63,105.2 146.64,105.19 146.64,105.16 146.79,105.02 146.79,104.3 145.31,102.82 145.31,102.42
  IN1 w0.102: 145.31,102.42 145.31,99.15 142.91,96.75 142.91,96.48 142.74,96.31 142.47,96.31 142.3,96.14 142.3,96 142.42,95.88 142.42,95.71 142.26,95.56 142.09,95.56 141.98,95.67 141.83,95.67 141.65,95.49 141.65,95.35 141.77,95.24 141.77,95.09 141.59,94.91 141.44,94.91 141.33,95.03 141.19,95.03 141.03,94.87 141.03,92.95 135.16,87.09 134.33,87.09 128.2,80.96 128.2,70.34 127.48,69.62 127.48,65.51 125.95,63.97 125.95,62.47 124.11,60.63 124.11,47.5 124.53,47.08 124.53,40.96 126.91,38.59 126.91,35.73 127.29,35.35 127.29,34.25 127.08,34.05 126.68,34.05 126.51,34.22 v1(126.51,34.75)
  BOTTOM w0.076: v1(146.1,107.21) 145.79,106.9 U9001.BF11
  BOTTOM w0.102: JDIM1002.63 129.1,39.48 127.16,37.54 127.16,35.4 126.51,34.75 v1(126.51,34.75)
M_B_DQ21: length 100.3
  TOP w0.102: JDIM1003.59 128.1,33.05 126.88,34.28 126.4,34.28 126.1,34.58 126.1,36.88 v1(126.51,37.29)
  IN1 w0.076: v1(146.1,106.57) 146.48,106.19 146.48,105.13 146.49,105.12 146.49,105.1 146.63,104.95 146.63,104.4 146.31,104.07
  IN1 w0.102: 146.31,104.07 145.09,102.85 145.09,99.4 140.7,95 140.7,93 140.41,92.72 140.27,92.72 140.09,92.89 139.95,92.89 139.77,92.71 139.77,92.57 139.94,92.39 139.94,92.25 139.76,92.07 139.62,92.07 139.45,92.24 139.3,92.24 139.12,92.06 139.12,91.92 139.3,91.75 139.3,91.6 139.12,91.42 138.97,91.42 138.8,91.6 138.66,91.6 138.48,91.42 138.48,91.27 138.65,91.1 138.65,90.96 135.11,87.42 134.19,87.42 127.87,81.1 127.87,70.47 127.15,69.76 127.15,65.65 125.62,64.11 125.62,62.6 123.77,60.75 123.77,57.45 123.67,57.35 123.41,57.35 123.34,57.27 123.34,56.99 123.44,56.89 123.67,56.89 123.77,56.79 123.77,56.53 123.67,56.43 123.44,56.43 123.34,56.33 123.34,56.08 123.44,55.97 123.67,55.97 123.77,55.87 123.77,55.62 123.67,55.52 123.44,55.52 123.34,55.41 123.34,55.16 123.44,55.06 123.67,55.06 123.77,54.96 123.77,50.53 123.34,50.1 123.34,49.84 123.44,49.74 123.67,49.74 123.77,49.64 123.77,49.39 123.67,49.29 123.44,49.29 123.34,49.18 123.34,48.93 123.77,48.5 123.77,47.5 123.6,47.34 123.6,47.05 123.77,46.88 123.77,46.59 123.6,46.43 123.6,46.13 123.77,45.97 123.77,45.64 123.56,45.43 123.56,45.12 123.66,45.02 124.1,45.02 124.2,44.91 124.2,44.66 124.1,44.56 123.64,44.56 123.56,44.48 123.56,44.18 123.64,44.1 124.1,44.1 124.2,44 124.2,43.75 124.1,43.64 123.66,43.64 123.56,43.54 123.56,41.46 126.51,38.52 v1(126.51,37.29)
  BOTTOM w0.076: v1(146.1,106.57) 145.78,106.25 U9001.BF10
  BOTTOM w0.102: JDIM1002.59 128.1,39.31 127.92,39.12 127.2,39.12 126.72,38.64 126.72,38.5 126.87,38.35 126.87,38.17 126.71,38.01 126.53,38.01 126.35,38.18 126.16,38.18 126,38.02 126,37.79 v1(126.51,37.29)
M_B_DQ22: length 98.3
  TOP w0.102: JDIM1003.45 124.6,32.95 123.55,34 123.32,34 122.78,34.54 122.78,37.31 v1(123.42,37.94)
  IN1 w0.102: v1(145.19,104.62) 144.96,104.4 144.96,104.2 144,103.25 144,101.08 143.39,100.47 142.86,100.47 137.71,95.32 136.71,95.32 136.43,95.59 133,95.59 129.78,92.37 129.78,85.66 125.97,81.86 125.97,77.28 125.27,76.58 125.27,66.42 123.74,64.89 123.74,63.38 120.8,60.44 120.8,59.08 121.32,58.55 121.32,58.3 121.22,58.2 120.9,58.2 120.8,58.09 120.8,57.84 120.9,57.74 121.22,57.74 121.32,57.64 121.32,57.38 121.22,57.28 120.9,57.28 120.8,57.18 120.8,56.93 120.9,56.82 121.22,56.82 121.32,56.72 121.32,56.47 121.22,56.37 120.9,56.37 120.8,56.27 120.8,56.01 120.9,55.91 121.22,55.91 121.32,55.81 121.32,55.55 121.22,55.45 120.83,55.45 120.71,55.33 120.71,55.12 120.83,55 121.15,55 121.3,54.84 121.3,54.54 120.94,54.18 120.94,50.79 121.25,50.48 121.25,41.12 123.42,38.95 v1(123.42,37.94)
  BOTTOM w0.076: v1(145.19,104.62) 144.86,104.3 U9001.BG7
  BOTTOM w0.102: v1(123.42,37.94) 123.23,37.94 123.01,37.73 123.01,37.25 122.91,37.15 122.64,37.15 122.54,37.25 122.54,37.89 123.86,39.21 124.36,39.21 124.6,39.45 JDIM1002.45
M_B_DQ23: length 100.2
  TOP w0.102: JDIM1003.58 127.85,39.39 127.67,39.21 125.89,39.21 125.45,38.76 125.45,38.62 125.94,38.12 125.94,37.94 125.78,37.77 125.61,37.77 125.1,38.28 124.96,38.28 124.54,37.86 124.54,37.15 124.64,37.05 124.77,37.05 v1(125.06,37.34)
  IN1 w0.102: v1(125.06,37.34) 125.06,39.03 122.9,41.19 122.9,47.91 122.54,48.27 122.54,60.46 124.96,62.88 124.96,64.38 126.49,65.92 126.49,70.03 127.19,70.73 127.19,70.98 127.09,71.09 126.7,71.09 126.59,71.19 126.59,71.44 126.7,71.54 127.09,71.54 127.19,71.64 127.19,71.9 127.09,72 126.7,72 126.59,72.1 126.59,72.36 126.7,72.46 127.09,72.46 127.19,72.56 127.19,72.81 127.09,72.91 126.7,72.91 126.59,73.02 126.59,73.27 126.7,73.37 127.09,73.37 127.19,73.47 127.19,73.73 127.09,73.83 126.7,73.83 126.59,73.93 126.59,74.18 126.7,74.29 127.09,74.29 127.19,74.39 127.19,74.64 127.09,74.74 126.7,74.74 126.59,74.85 126.59,75.1 126.7,75.2 127.09,75.2 127.19,75.3 127.19,75.56 127.09,75.66 126.75,75.66 126.62,75.78 126.62,76.04 127.19,76.61 127.19,81.35 133.92,88.08 134.79,88.08 137.8,91.09 137.8,91.71 138.12,92.03 138.12,92.27 138.03,92.36 138.03,92.5 138.21,92.68 138.36,92.68 138.49,92.54 138.64,92.54 138.82,92.72 138.82,92.87 138.68,93 138.68,93.15 138.86,93.33 139,93.33 139.12,93.22 139.31,93.22 139.99,93.89 139.99,95.23 144.63,99.88 144.63,102.97 146.1,104.44 v1(146.1,104.62)
  BOTTOM w0.076: v1(146.1,104.62) 145.78,104.3 U9001.BF7
  BOTTOM w0.102: v1(125.06,37.34) 125.53,36.87 125.53,34.86 127.03,33.36 127.54,33.36 127.85,33.05 JDIM1002.58
M_B_DQ24: length 100.1
  TOP w0.102: JDIM1003.83 134.1,33.12 134.47,33.49 134.47,35.68 134.37,35.78 134.07,35.78 133.97,35.68 133.97,33.75 133.69,33.47 133.41,33.47 133.13,33.75 133.13,34.04 v1(133.42,34.33)
  IN1 w0.076: 149,94.67 149.07,94.74 149.07,103.84 149.69,104.46 149.69,104.86 149.38,105.17 149.38,106.4 149.31,106.47 149.31,106.76 v1(148.84,107.22)
  IN1 w0.102: v1(133.42,34.33) 131.98,35.77 131.98,38.72 129.2,41.5 129.2,54.08 129.61,54.48 129.61,54.79 129.45,54.94 129.23,54.94 129.1,55.07 129.1,55.27 129.63,55.8 129.63,58.44 130.18,58.99 130.18,62.7 132.29,64.81 132.29,79.23 145.45,92.39 146.72,92.39 149,94.67
  BOTTOM w0.076: U9001.BB11 148.52,106.9 v1(148.84,107.22)
  BOTTOM w0.102: v1(133.42,34.33) 133.01,34.74 133.01,36.23 132.82,36.41 132.82,37.88 134.1,39.17 JDIM1002.83
M_B_DQ25: length 98.1
  TOP w0.102: JDIM1003.66 129.85,39.08 129.35,38.57 129.35,38.42 129.25,38.32 128.97,38.32 128.87,38.42 128.87,38.72 128.77,38.83 128.56,38.83 128.15,38.41 128.15,37.96 128.56,37.56 128.56,36.61 v1(128.04,36.09)
  IN1 w0.076: 147.02,104.45 147.02,104.77 147.4,105.15 147.4,106.38 147.48,106.46 147.48,106.76 v1(147.93,107.21)
  IN1 w0.102: v1(128.04,36.09) 127.73,35.78 127.54,35.78 127.41,35.9 127.41,36.29 127.59,36.46 127.59,36.74 127.41,36.92 127.41,38.76 125.01,41.16 125.01,47.3 124.59,47.72 124.59,60.43 126.43,62.27 126.43,63.77 127.97,65.31 127.97,69.42 128.68,70.14 128.68,80.76 134.53,86.6 135.14,86.6 141.96,93.42 141.96,93.57 141.51,94.02 141.51,94.19 141.67,94.36 141.85,94.36 142.3,93.91 142.44,93.91 142.65,94.12 142.65,94.32 142.32,94.66 142.32,94.93 142.99,95.59 143.39,95.59 143.95,96.16 143.95,96.46 146.11,98.61 146.11,102.32 146.92,103.14 146.92,104.08 147.02,104.17 147.02,104.45
  BOTTOM w0.076: v1(147.93,107.21) 147.62,106.9 U9001.BC11
  BOTTOM w0.102: JDIM1002.66 129.85,33.06 129.73,33.18 129.09,33.18 127.63,34.65 127.63,35.68 v1(128.04,36.09)
M_B_DQ26: length 96.2
  TOP w0.102: JDIM1003.80 133.35,39.33 131.2,37.17 131.2,35.88 v1(131.6,35.47)
  IN1 w0.076: v1(148.84,105.27) 148.84,105.19 149.28,104.75 149.28,104.53 148.77,104.02 148.77,95.13 148.62,94.98
  IN1 w0.102: v1(131.6,35.47) 131.22,35.85 131.22,37.26 130.84,37.64 130.84,37.94 131.22,38.32 131.22,38.55 130.99,38.78 130.64,38.78 130.44,38.97 130.44,39.33 128.32,41.45 128.32,47.87 128.01,48.18 128.01,48.51 128.11,48.61 128.33,48.61 128.43,48.71 128.43,48.94 128.33,49.04 128.11,49.04 128.01,49.15 128.01,49.38 128.11,49.48 128.33,49.48 128.43,49.58 128.43,49.81 128.33,49.91 128.11,49.91 128.01,50.01 128.01,50.24 128.11,50.34 128.33,50.34 128.43,50.44 128.43,50.67 128.33,50.77 128.11,50.77 128.01,50.87 128.01,54.76 128.11,54.86 128.34,54.86 128.44,54.96 128.44,55.19 128.34,55.29 128.11,55.29 128.01,55.39 128.01,55.69 128.11,55.8 128.7,55.8 128.95,56.05 128.95,56.2 128.73,56.41 128.73,56.66 128.97,56.89 128.97,60.03 128.61,60.4 128.61,60.85 128.97,61.21 128.97,62.72 131.22,64.97 131.22,79.1 145.18,93.05 146.69,93.05 148.62,94.98
  BOTTOM w0.076: U9001.BB8 148.52,104.95 v1(148.84,105.27)
  BOTTOM w0.102: v1(131.6,35.47) 131.74,35.61 132.02,35.61 132.24,35.4 132.24,34.15 132.77,33.62 133.13,33.62 133.35,33.39 JDIM1002.80
M_B_DQ27: length 96.5
  TOP w0.102: JDIM1003.70 130.85,39.25 128.94,37.33 128.94,35.72 v1(128.04,34.82)
  IN1 w0.076: v1(147.93,105.27) 147.93,105.16 147.77,105 147.77,105 147.55,104.78 147.55,104.78 147.51,104.73 147.51,104.01 147.3,103.81 147.3,102.83 147.25,102.78
  IN1 w0.102: v1(128.04,34.82) 128.04,34.49 128.18,34.36 128.4,34.36 128.56,34.51 128.56,38.55 126.1,41 126.1,47.43 125.25,48.28 125.25,60.15 127.09,61.99 127.09,63.5 128.63,65.03 128.63,69.15 129.34,69.86 129.34,79.88 130.75,81.28 130.75,81.84 130.95,82.04 131.1,82.04 131.21,81.93 131.4,81.93 131.56,82.09 131.56,82.23 131.45,82.34 131.45,82.59 131.58,82.72 132.18,82.72 133.3,83.83 133.3,84.44 134.8,85.94 135.41,85.94 146.64,97.17 146.64,102.17 147.25,102.78
  BOTTOM w0.076: v1(147.93,105.27) 147.6,104.95 U9001.BC8
  BOTTOM w0.102: JDIM1002.70 130.85,33.1 130.57,33.39 129.45,33.39 129.19,33.64 129.19,34.56 129.02,34.73 128.8,34.73 128.45,34.38 128.21,34.38 128.04,34.55 v1(128.04,34.82)
M_B_DQ28: length 97.6
  TOP w0.102: JDIM1003.67 130.1,32.99 128.72,34.38 127.9,34.38 127.63,34.65 127.63,36.97 v1(128.04,37.37)
  IN1 w0.076: 147.28,104.58 147.28,104.81 147.55,105.08 147.55,106.19 v1(147.93,106.57)
  IN1 w0.102: 147.28,104.58 147.28,104.09 147.12,103.93 147.12,102.96 146.36,102.19 146.36,98.4 144.53,96.57 144.53,96.26 144.71,96.08 144.71,95.71 144.34,95.34 144.2,95.34 144.01,95.53 143.86,95.53 143.66,95.34 143.66,95.19 143.86,95 143.86,94.86 143.66,94.66 143.52,94.66 143.32,94.85 143.18,94.85 142.98,94.65 142.98,94.51 143.17,94.32 143.17,94.17 135.27,86.27 134.66,86.27 132.88,84.49 132.88,84.17 132.74,84.03 132.42,84.03 132.25,83.86 132.25,83.72 132.41,83.56 132.41,83.41 132.23,83.23 132.09,83.23 131.93,83.39 131.79,83.39 130.41,82.02 130.41,81.8 130.16,81.55 129.95,81.55 129.8,81.41 129.8,81.27 129.96,81.11 129.96,80.96 129.79,80.78 129.64,80.78 129.51,80.92 129.31,80.92 129.01,80.62 129.01,70 128.3,69.28 128.3,65.17 126.76,63.64 126.76,62.13 124.92,60.29 124.92,48.14 125.77,47.29 125.77,40.87 127.74,38.9 127.74,38.47 127.84,38.36 128.12,38.36 128.23,38.26 128.23,38.03 128.12,37.93 127.84,37.93 127.74,37.83 127.74,37.43 127.8,37.37 v1(128.04,37.37)
  BOTTOM w0.076: U9001.BC10 147.6,106.25 v1(147.93,106.57)
  BOTTOM w0.102: JDIM1002.67 130.1,38.98 129.79,38.66 129.61,38.66 129.3,38.97 129.1,38.97 128.89,38.76 128.89,38.59 129.21,38.27 129.21,38.11 129.03,37.93 128.87,37.93 128.62,38.18 128.29,38.18 128.04,37.92 v1(128.04,37.37)
M_B_DQ29: length 99
  TOP w0.102: JDIM1003.84 134.35,39.04 134.14,38.83 133.26,38.83 132.36,37.93 132.36,37.78 132.54,37.6 132.54,36.83 132.42,36.71 132.26,36.71 132.13,36.84 132.13,37.32 132.01,37.44 131.82,37.44 131.6,37.22 v1(131.6,36.74)
  IN1 w0.076: v1(148.84,106.57) 149.22,106.19 149.22,105.11 149.5,104.84 149.5,104.52 148.92,103.94 148.92,94.97 148.79,94.84
  IN1 w0.102: 148.79,94.84 146.67,92.72 145.31,92.72 131.96,79.37 131.96,66.87 131.84,66.75 131.65,66.75 131.55,66.65 131.55,66.42 131.65,66.32 131.86,66.32 131.96,66.21 131.96,65.99 131.86,65.88 131.65,65.88 131.55,65.78 131.55,65.55 131.65,65.45 131.86,65.45 131.96,65.35 131.96,64.94 129.72,62.7 129.42,62.7 129.3,62.58 129.3,62.33 129.4,62.23 129.72,62.23 129.83,62.13 129.83,61.9 129.72,61.8 129.4,61.8 129.3,61.69 129.3,61.46 129.4,61.36 129.72,61.36 129.83,61.26 129.83,61.03 129.72,60.93 129.27,60.93 129.17,60.83 129.17,60.6 129.27,60.5 129.72,60.5 129.83,60.4 129.83,60.17 129.72,60.07 129.4,60.07 129.3,59.97 129.3,59.74 129.4,59.64 129.72,59.64 129.83,59.53 129.83,59.31 129.72,59.2 129.4,59.2 129.3,59.1 129.3,55.93 128.77,55.41 128.77,41.46 131.6,38.63 v1(131.6,36.74)
  BOTTOM w0.076: v1(148.84,106.57) 148.52,106.25 U9001.BB10
  BOTTOM w0.102: v1(131.6,36.74) 132.49,35.85 132.49,34.67 133.25,33.91 133.44,33.91 134.35,33 JDIM1002.84
M_B_DQ30: length 96.1
  TOP w0.102: JDIM1003.71 131.1,33.1 131.1,33.11 131.1,33.9 130.94,34.05 130.61,34.05 130.47,33.91 130.47,33.64 130.29,33.46 130.11,33.46 129.58,34 129.58,34.14 129.75,34.31 129.75,34.46 129.55,34.65 129.41,34.65 129.24,34.48 129.09,34.48 128.89,34.69 128.89,35.02 129.12,35.25 129.54,35.25 v1(130.25,34.53)
  IN1 w0.102: v1(130.25,34.53) 130.25,34.53 128.89,35.9 128.89,38.69 126.44,41.14 126.44,47.56 126.02,47.98 126.02,60.46 127.42,61.86 127.42,63.36 128.96,64.9 128.96,69.01 129.67,69.73 129.67,79.74 133.63,83.69 133.63,84.3 134.94,85.61 135.55,85.61 146.89,96.96 146.89,102.09 147.5,102.69 147.5,103.68 147.93,104.12 v1(147.93,104.62)
  BOTTOM w0.076: U9001.BC7 147.6,104.3 v1(147.93,104.62)
  BOTTOM w0.102: v1(130.25,34.53) 129.85,34.94 129.85,37.7 131.1,38.96 JDIM1002.71
M_B_DQ31: length 97.6
  TOP w0.102: JDIM1003.79 133.1,33.09 132.7,33.49 132.29,33.49 132.14,33.64 132.14,33.9 132.75,34.51 132.75,36.15 132.62,36.28 132.26,36.28 132.11,36.13 132.11,34.76 131.99,34.63 131.8,34.63 v1(131.6,34.84)
  IN1 w0.076: v1(148.84,104.62) 148.62,104.39 148.62,95.33 148.48,95.19
  IN1 w0.102: 148.48,95.19 146.67,93.38 145.04,93.38 130.89,79.23 130.89,65.11 128.64,62.86 128.64,61.35 127.68,60.39 127.68,59.78 127.9,59.56 127.9,58.87 127.68,58.65 127.68,57.49 127.78,57.39 128.49,57.39 128.59,57.29 128.59,57.06 128.49,56.96 127.78,56.96 127.68,56.86 127.68,48.04 127.99,47.73 127.99,41.31 130.11,39.19 130.11,37.91 130.89,37.13 130.89,35.55 v1(131.6,34.84)
  BOTTOM w0.076: U9001.BB7 148.52,104.3 v1(148.84,104.62)
  BOTTOM w0.102: v1(131.6,34.84) 131.2,35.24 131.2,37.19 133.1,39.09 JDIM1002.79
M_B_DQ32: length 93.2
  TOP w0.102: JDIM1003.187 162.1,33.22 161.96,33.36 161.58,33.36 161.45,33.49 161.45,33.94 161.58,34.07 162.48,34.07 162.59,34.18 162.59,34.91 162.47,35.04 162.21,35.04 162.06,34.89 162.06,34.64 161.96,34.54 161.58,34.54 161.45,34.66 161.45,34.94 v1(161.78,35.27)
  IN1 w0.076: v1(165.3,107.22) 165.77,106.76 165.77,106.42 165.84,106.35 165.84,105.08 166.2,104.72 166.2,104.14 166.56,103.78 166.56,98.64 168.63,96.56 168.63,96.32
  IN1 w0.102: v1(161.78,35.27) 161.78,34.46 161.98,34.25 162.31,34.25 162.49,34.43 162.49,38.15 168.54,44.19 168.54,70.68 168.82,70.96 168.82,75.66 171.2,78.05 171.2,89.68 168.63,92.24 168.63,96.32
  BOTTOM w0.076: U9001.AA11 164.98,106.9 v1(165.3,107.22)
  BOTTOM w0.102: v1(161.78,35.27) 162.19,35.68 162.19,36.59 162.39,36.8 162.39,38.4 162.1,38.68 JDIM1002.187
M_B_DQ33: length 91.5
  TOP w0.102: v1(161.78,36.54) 161.1,35.87 161.1,34.56 161,34.45 160.64,34.45 160.51,34.33 160.51,34.1 160.64,33.97 161,33.97 161.1,33.87 JDIM1003.183
  IN1 w0.076: 168.41,96.2 168.41,96.53 166.4,98.54 166.4,103.72 166,104.12 166,104.68 165.68,105 165.68,106.19 v1(165.3,106.57)
  IN1 w0.102: 168.41,96.2 168.41,92.07 170.87,89.6 170.87,78.18 167.95,75.27 167.95,75.05 168.11,74.9 168.38,74.9 168.48,74.8 168.48,74.57 168.38,74.47 168.03,74.47 167.93,74.37 167.93,74.14 168.03,74.04 168.38,74.04 168.48,73.94 168.48,73.71 168.38,73.61 168.03,73.61 167.93,73.5 167.93,73.28 168.03,73.17 168.38,73.17 168.48,73.07 168.48,72.84 168.38,72.74 168.03,72.74 167.93,72.64 167.93,72.41 168.03,72.31 168.38,72.31 168.48,72.21 168.48,71.98 168.38,71.88 168.03,71.88 167.93,71.78 167.93,71.55 168.03,71.45 168.38,71.45 168.48,71.35 168.48,71.12 168.38,71.02 168.08,71.02 167.95,70.89 167.95,70.7 168.18,70.47 168.18,70.24 167.95,70.02 167.95,69.73 168.21,69.48 168.21,44.33 162.16,38.28 162.16,36.72 161.98,36.54 v1(161.78,36.54)
  BOTTOM w0.076: v1(165.3,106.57) 164.98,106.25 U9001.AA10
  BOTTOM w0.102: v1(161.78,36.54) 162.19,36.95 162.19,37.98 161.1,39.06 JDIM1002.183
M_B_DQ34: length 92.1
  TOP w0.102: JDIM1003.170 157.85,39.45 156.7,38.29 156.7,37.4 156.8,37.3 157.28,37.3 157.39,37.4 157.39,38.32 157.87,38.8 158.27,38.8 158.74,38.33 v1(158.74,37.69)
  IN1 w0.076: 163.86,104.07 163.68,104.26 163.68,104.91 163.86,105.08 163.86,106.26 163.94,106.34 163.94,106.77 v1(164.39,107.22)
  IN1 w0.102: 163.86,104.07 164.17,103.77 164.17,97.44 165.08,96.52 165.08,91.89 168,88.97 168,79.4 164.24,75.65 164.24,71.85 163.96,71.57 163.96,71.26 164.07,71.16 164.17,71.16 164.27,71.05 164.27,70.77 164.17,70.67 164.07,70.67 163.96,70.57 163.96,70.29 164.07,70.19 164.17,70.19 164.27,70.09 164.27,69.81 164.17,69.71 164.07,69.71 163.96,69.61 163.96,69.33 164.07,69.22 164.17,69.22 164.27,69.12 164.27,68.84 164.17,68.74 164.07,68.74 163.96,68.64 163.96,68.36 164.07,68.26 164.17,68.26 164.27,68.16 164.27,67.88 164.17,67.78 164.04,67.78 163.94,67.68 163.94,67.4 164.04,67.29 164.14,67.29 164.27,67.17 164.27,66.91 163.96,66.61 163.96,62.6 164.52,62.04 164.52,51.3 164.06,50.84 164.06,45.73 162.79,44.45 162.79,43.45 158.74,39.41 v1(158.74,37.69)
  BOTTOM w0.076: v1(164.39,107.22) 164.06,106.9 U9001.AC11
  BOTTOM w0.102: v1(158.74,37.69) 159.15,37.28 159.15,34.88 157.85,33.58 JDIM1002.170
M_B_DQ35: length 89.1
  TOP w0.102: JDIM1003.173 158.6,33.16 158.32,33.44 158.32,34.58 158.45,34.71 159.04,34.71 159.15,34.83 159.15,36.29 159.02,36.42 v1(158.74,36.42)
  IN1 w0.076: v1(164.39,106.57) 164.01,106.19 164.01,105 163.86,104.84 163.86,104.4 164.37,103.89 164.37,103.69
  IN1 w0.102: 164.37,103.69 164.37,97.52 165.31,96.58 165.31,91.97 168.33,88.95 168.33,79.27 164.77,75.71 164.77,73.19 165,72.96 165.18,72.96 165.28,72.86 165.28,72.58 165.18,72.48 165,72.48 164.9,72.38 164.9,72.1 165,72 165.18,72 165.28,71.89 165.28,71.62 165.18,71.51 165,71.51 164.9,71.41 164.9,71.13 165,71.03 165.18,71.03 165.28,70.93 165.28,70.65 165.18,70.55 164.98,70.55 164.88,70.45 164.88,70.17 164.98,70.07 165.18,70.07 165.28,69.96 165.28,69.68 165.18,69.58 165,69.58 164.9,69.48 164.9,66.77 164.3,66.16 164.3,62.73 164.85,62.18 164.85,51.16 164.39,50.7 164.39,45.59 163.12,44.32 163.12,43.32 159.16,39.36 159.16,36.84 v1(158.74,36.42)
  BOTTOM w0.076: U9001.AC10 164.06,106.25 v1(164.39,106.57)
  BOTTOM w0.102: JDIM1002.173 158.6,38.98 158.32,38.7 158.32,36.84 v1(158.74,36.42)
M_B_DQ36: length 89.3
  TOP w0.102: v1(160.15,34.83) 160.65,35.33 160.65,38.88 160.85,39.08 JDIM1003.182
  IN1 w0.076: v1(165.3,104.62) 165.45,104.47 165.45,97.99 166.81,96.63
  IN1 w0.102: 166.81,96.63 166.81,92.9 170.21,89.5 170.21,78.46 167.26,75.51 167.26,60.67 167.55,60.38 167.55,57.88 167.26,57.59 167.26,55.59 167.36,55.48 167.44,55.48 167.55,55.38 167.55,55.15 167.44,55.05 167.36,55.05 167.26,54.95 167.26,54.72 167.36,54.62 167.44,54.62 167.55,54.52 167.55,44.6 167.18,44.24 167.04,44.24 166.94,44.34 166.8,44.34 166.64,44.17 166.64,44.03 166.73,43.93 166.73,43.79 161.4,38.45 161.4,36.07 161.02,35.7 161.02,34.56 160.84,34.38 160.6,34.38 v1(160.15,34.83)
  BOTTOM w0.076: v1(165.3,104.62) 164.98,104.3 U9001.AA7
  BOTTOM w0.102: JDIM1002.182 160.85,34.42 161.04,34.61 161.04,35.3 160.93,35.41 160.7,35.41 160.56,35.26 160.56,34.99 160.4,34.83 v1(160.15,34.83)
M_B_DQ37: length 91.3
  TOP w0.102: JDIM1003.186 161.85,39.21 161.73,39.08 161.2,39.08 160.92,38.8 160.92,38.57 161.02,38.47 161.17,38.47 161.27,38.37 161.27,38.09 161.17,37.99 161.02,37.99 160.89,37.86 160.89,36.39 161.02,36.26 161.2,36.26 161.36,36.43 161.36,37.39 v1(161.78,37.81)
  IN1 w0.076: v1(165.3,105.27) 165.51,105.07 165.51,104.96 165.79,104.67 165.79,103.97 166.22,103.54 166.22,98.48 168.15,96.55 168.15,96.15
  IN1 w0.102: 168.15,96.15 168.15,91.94 170.54,89.55 170.54,78.32 167.59,75.37 167.59,69.54 167.69,69.44 167.77,69.44 167.88,69.34 167.88,69.11 167.77,69.01 167.69,69.01 167.59,68.91 167.59,68.68 167.69,68.58 167.77,68.58 167.88,68.48 167.88,68.25 167.77,68.15 167.69,68.15 167.59,68.05 167.59,67.82 167.69,67.72 167.77,67.72 167.88,67.61 167.88,67.39 167.77,67.28 167.69,67.28 167.59,67.18 167.59,66.95 167.69,66.85 167.77,66.85 167.88,66.75 167.88,66.52 167.77,66.42 167.69,66.42 167.59,66.32 167.59,66.09 167.69,65.99 167.77,65.99 167.88,65.89 167.88,65.66 167.77,65.56 167.69,65.56 167.59,65.46 167.59,65.23 167.69,65.12 167.77,65.12 167.88,65.02 167.88,64.79 167.77,64.69 167.69,64.69 167.59,64.59 167.59,64.36 167.69,64.26 167.77,64.26 167.88,64.16 167.88,63.93 167.77,63.83 167.69,63.83 167.59,63.73 167.59,63.5 167.69,63.4 167.77,63.4 167.88,63.3 167.88,63.07 167.77,62.97 167.67,62.97 167.59,62.89 167.59,62.64 167.69,62.53 167.77,62.53 167.88,62.43 167.88,62.2 167.77,62.1 167.69,62.1 167.59,62 167.59,61.77 167.69,61.67 167.77,61.67 167.88,61.57 167.88,61.34 167.72,61.18 167.72,60.68 167.88,60.52 167.88,57.34 167.77,57.24 167.69,57.24 167.59,57.14 167.59,56.91 167.69,56.81 167.77,56.81 167.88,56.71 167.88,56.48 167.77,56.38 167.69,56.38 167.59,56.28 167.59,56.02 167.67,55.95 167.77,55.95 167.88,55.85 167.88,44.46 161.78,38.37 v1(161.78,37.81)
  BOTTOM w0.076: v1(165.3,105.27) 164.98,104.95 U9001.AA8
  BOTTOM w0.102: v1(161.78,37.81) 161.37,37.41 161.37,34.46 161.85,33.98 JDIM1002.186
M_B_DQ38: length 89.4
  TOP w0.102: v1(158.74,35.15) 158.4,35.15 158.15,35.4 158.15,36.36 158.05,36.46 157.74,36.46 157.64,36.36 157.64,35.08 158.08,34.63 158.08,33.56 157.6,33.08 JDIM1003.169
  IN1 w0.076: v1(164.39,105.27) 164.18,105.06 164.18,104.95 164.01,104.78 164.01,104.46 164.57,103.91 164.57,103.69
  IN1 w0.102: v1(158.74,35.15) 159.49,35.9 159.49,39.22 163.45,43.18 163.45,44.18 164.88,45.61 164.88,49.36 165.69,50.17 165.69,76.16 168.66,79.13 168.66,89.01 165.56,92.11 165.56,96.62 164.57,97.61 164.57,103.69
  BOTTOM w0.076: U9001.AC8 164.06,104.95 v1(164.39,105.27)
  BOTTOM w0.102: JDIM1002.169 157.6,37.79 157.77,37.63 157.77,36.12 v1(158.74,35.15)
M_B_DQ39: length 89.6
  TOP w0.102: JDIM1003.174 158.85,39.41 158.63,39.18 158.63,38.95 158.81,38.78 159.11,38.78 159.42,39.08 160.23,39.08 160.36,38.95 160.36,38.67 160.23,38.55 159.54,38.55 159.19,38.2 159.19,37.27 159.29,37.17 159.57,37.17 159.7,37.3 159.7,37.78 159.93,38 v1(160.15,38)
  IN1 w0.102: v1(164.39,104.62) 164.39,104.42 164.77,104.05 164.77,97.71 165.76,96.71 165.76,92.39 168.99,89.16 168.99,78.99 166.02,76.02 166.02,50.04 165.26,49.28 165.26,49.09 165.36,48.99 165.76,48.99 165.89,48.86 165.89,48.63 165.79,48.53 165.39,48.53 165.26,48.4 165.26,45.15 165.16,45.05 164.79,45.05 164.62,44.89 164.62,44.67 164.93,44.36 164.93,44.19 164.72,43.98 164.58,43.98 164.27,44.29 164.12,44.29 163.93,44.1 163.93,43.95 164.24,43.64 164.24,43.5 159.82,39.08 159.82,38.33 v1(160.15,38)
  BOTTOM w0.076: U9001.AC7 164.06,104.3 v1(164.39,104.62)
  BOTTOM w0.102: JDIM1002.174 158.85,34.07 159.42,34.63 159.42,37.27 v1(160.15,38)
M_B_DQ40: length 91.2
  TOP w0.102: JDIM1003.191 163.1,33.11 162.97,33.24 162.47,33.24 162.34,33.36 162.34,33.62 162.47,33.75 163.22,33.75 163.35,33.62 163.35,33.36 163.48,33.24 163.76,33.24 163.86,33.34 163.86,34 163.5,34.36 163.09,34.36 162.82,34.63 162.82,35 v1(163,35.18)
  IN1 w0.076: v1(167.13,105.27) 167.13,105.21 166.75,104.83 166.75,104.34 167.09,104.01 167.09,98.92 169.5,96.51 169.5,96.45
  IN1 w0.102: v1(163,35.18) 163.29,34.89 163.56,34.89 163.71,35.04 163.71,37.75 169.96,44 169.96,69.86 170.29,70.19 170.29,72.47 170.19,72.57 170.06,72.57 169.96,72.67 169.96,72.9 170.06,73 170.19,73 170.29,73.1 170.29,73.33 170.19,73.43 170.06,73.43 169.96,73.54 169.96,73.76 170.06,73.87 170.19,73.87 170.29,73.97 170.29,74.2 170.19,74.3 170.06,74.3 169.96,74.4 169.96,74.63 170.06,74.73 170.19,74.73 170.29,74.83 170.29,75.52 172.35,77.57 172.35,89.78 169.5,92.63 169.5,96.45
  BOTTOM w0.076: v1(167.13,105.27) 166.81,104.95 U9001.W8
  BOTTOM w0.102: JDIM1002.191 163.1,38.57 163.4,38.27 163.4,35.59 v1(163,35.18)
M_B_DQ41: length 89.6
  TOP w0.102: v1(164.31,37.56) 163.86,37.11 163.86,34.75 164.1,34.51 JDIM1003.195
  IN1 w0.076: v1(167.13,104.62) 167.24,104.52 167.24,99.05 169.7,96.58 169.7,96.45
  IN1 w0.102: 169.7,96.45 169.7,92.75 172.68,89.78 172.68,77.44 170.78,75.54 170.78,70 170.29,69.51 170.29,68.98 170.49,68.77 170.49,68.11 170.29,67.91 170.29,67.43 170.39,67.33 170.68,67.33 170.78,67.23 170.78,66.95 170.68,66.85 170.39,66.85 170.29,66.75 170.29,66.47 170.39,66.36 170.7,66.36 170.78,66.29 170.78,66.03 170.68,65.93 170.39,65.93 170.29,65.83 170.29,65.58 170.36,65.5 170.68,65.5 170.78,65.4 170.78,65.17 170.68,65.07 170.39,65.07 170.29,64.97 170.29,64.74 170.39,64.64 170.68,64.64 170.78,64.54 170.78,64.31 170.68,64.21 170.39,64.21 170.29,64.1 170.29,63.88 170.39,63.77 170.68,63.77 170.78,63.67 170.78,63.44 170.68,63.34 170.39,63.34 170.29,63.24 170.29,63.01 170.39,62.91 170.68,62.91 170.78,62.81 170.78,62.58 170.68,62.48 170.39,62.48 170.29,62.38 170.29,62.15 170.39,62.05 170.68,62.05 170.78,61.94 170.78,61.72 170.68,61.61 170.36,61.61 170.29,61.54 170.29,61.23 170.39,61.13 170.67,61.13 170.78,61.02 170.78,51.08 170.29,50.59 170.29,43.86 164.31,37.88 v1(164.31,37.56)
  BOTTOM w0.076: U9001.W7 166.81,104.3 v1(167.13,104.62)
  BOTTOM w0.102: JDIM1002.195 164.1,38.96 164.21,38.86 164.95,38.86 165.06,38.75 165.06,38.5 164.93,38.37 164.21,38.37 164.1,38.27 164.1,37.77 v1(164.31,37.56)
M_B_DQ42: length 91.9
  TOP w0.102: v1(166.02,35.65) 165.52,35.65 164.88,35.01 164.88,34.62 164.77,34.52 164.45,34.52 164.34,34.41 164.34,34.13 164.45,34.03 164.77,34.03 164.88,33.93 164.88,33.49 165.01,33.36 165.95,33.36 166.1,33.21 JDIM1003.203
  IN1 w0.076: 171.91,96.61 171.91,96.69 168.99,99.6 168.99,103.76 168.74,104.02 168.74,104.82 168.43,105.13 168.43,106.19 v1(168.05,106.57)
  IN1 w0.102: v1(166.02,35.65) 166.4,36.04 166.4,36.99 168.59,39.18 168.9,39.18 173.02,43.3 173.02,60.83 172.68,61.17 172.68,61.5 172.78,61.6 172.92,61.6 173.02,61.71 173.02,61.93 172.92,62.04 172.78,62.04 172.68,62.14 172.68,62.37 172.78,62.47 172.92,62.47 173.02,62.57 173.02,62.8 172.92,62.9 172.78,62.9 172.68,63 172.68,63.23 172.78,63.33 172.92,63.33 173.02,63.43 173.02,63.66 172.92,63.76 172.78,63.76 172.68,63.86 172.68,64.09 172.78,64.19 172.92,64.19 173.02,64.3 173.02,64.53 172.92,64.63 172.78,64.63 172.68,64.73 172.68,64.96 172.78,65.06 172.92,65.06 173.02,65.16 173.02,65.39 172.92,65.49 172.78,65.49 172.68,65.59 172.68,65.82 172.78,65.92 172.92,65.92 173.02,66.02 173.02,66.27 172.68,66.61 172.68,74.77 174.56,76.65 174.56,89.85 171.91,92.5 171.91,96.61
  BOTTOM w0.076: v1(168.05,106.57) 167.72,106.25 U9001.V10
  BOTTOM w0.102: v1(166.02,35.65) 166.43,36.06 166.43,37.92 166.1,38.24 JDIM1002.203
M_B_DQ43: length 92.9
  TOP w0.102: v1(166.73,34.38) 166.73,37 167.36,37.62 JDIM1003.208
  IN1 w0.076: 172.09,96.48 172.09,96.72 169.2,99.62 169.2,103.78 168.92,104.06 168.92,104.86 168.58,105.2 168.58,106.69 v1(168.05,107.22)
  IN1 w0.102: v1(166.73,34.38) 166.43,34.69 166.43,35.57 166.73,35.87 166.73,36.85 168.73,38.85 169.04,38.85 173.35,43.16 173.35,66.5 173.06,66.79 173.06,67.15 173.36,67.45 173.36,67.73 173.26,67.83 173.16,67.83 173.06,67.93 173.06,68.21 173.16,68.32 173.26,68.32 173.36,68.42 173.36,68.7 173.26,68.8 173.16,68.8 173.06,68.9 173.06,69.18 173.16,69.28 173.26,69.28 173.36,69.38 173.36,69.66 173.26,69.76 173.16,69.76 173.06,69.86 173.06,70.14 173.16,70.25 173.26,70.25 173.36,70.35 173.36,70.63 173.06,70.93 173.06,74.68 174.89,76.51 174.89,89.91 172.09,92.7 172.09,96.48
  BOTTOM w0.076: v1(168.05,107.22) 167.72,106.9 U9001.V11
  BOTTOM w0.102: v1(166.73,34.38) 167.01,34.38 167.11,34.28 167.11,34.1 166.81,33.8 166.66,33.8 166.43,34.03 166.26,34.03 166.08,33.84 166.08,33.69 166.53,33.24 166.68,33.24 166.99,33.54 167.19,33.54 167.36,33.38 JDIM1002.208
M_B_DQ44: length 93.9
  TOP w0.102: JDIM1003.190 162.85,39.33 162.85,39.33 162.59,39.08 162.11,39.08 161.96,38.93 161.96,38.75 162.08,38.62 162.77,38.62 162.97,38.83 163.23,38.83 163.44,38.61 163.44,38.24 163.34,38.14 162.34,38.14 162.21,38.01 162.21,37.4 162.31,37.3 162.58,37.3 v1(163,37.72)
  IN1 w0.076: v1(167.13,107.22) 166.61,106.7 166.61,106.26 166.6,106.26 166.6,105.11 166.43,104.94 166.43,104.23 166.73,103.93 166.73,98.71 169.02,96.42 169.02,96.32
  IN1 w0.102: 169.02,96.32 169.02,92.37 171.69,89.7 171.69,77.85 169.3,75.46 169.3,70.76 169.02,70.48 169.02,61.37 169.09,61.3 169.2,61.3 169.3,61.19 169.3,60.97 169.2,60.86 169.12,60.86 169.02,60.76 169.02,60.53 169.12,60.43 169.2,60.43 169.3,60.33 169.3,60.1 169.2,60 169.12,60 169.02,59.9 169.02,59.67 169.12,59.57 169.2,59.57 169.3,59.47 169.3,59.24 169.2,59.14 169.12,59.14 169.02,59.04 169.02,58.81 169.12,58.71 169.2,58.71 169.3,58.6 169.3,58.38 169.2,58.27 169.12,58.27 169.02,58.17 169.02,57.94 169.12,57.84 169.2,57.84 169.3,57.74 169.3,57.51 169.2,57.41 169.12,57.41 169.02,57.31 169.02,57.08 169.12,56.98 169.2,56.98 169.3,56.88 169.3,56.65 169.2,56.55 169.12,56.55 169.02,56.45 169.02,56.22 169.12,56.11 169.2,56.11 169.3,56.01 169.3,55.78 169.2,55.68 169.12,55.68 169.02,55.58 169.02,55.35 169.12,55.25 169.2,55.25 169.3,55.15 169.3,54.92 169.2,54.82 169.12,54.82 169.02,54.72 169.02,54.49 169.12,54.39 169.22,54.39 169.3,54.31 169.3,54.03 169.22,53.96 169.12,53.96 169.02,53.85 169.02,53.52 169.3,53.24 169.3,50.16 169.2,50.06 169.12,50.06 169.02,49.96 169.02,49.76 169.12,49.65 169.2,49.65 169.3,49.55 169.3,49.35 169.2,49.25 169.12,49.25 169.02,49.15 169.02,48.94 169.12,48.84 169.2,48.84 169.3,48.74 169.3,48.54 169.2,48.43 169.12,48.43 169.02,48.33 169.02,48.13 169.12,48.03 169.2,48.03 169.3,47.93 169.3,47.72 169.2,47.62 169.12,47.62 169.02,47.52 169.02,47.32 169.12,47.22 169.22,47.22 169.3,47.14 169.3,44.27 163,37.97 v1(163,37.72)
  BOTTOM w0.076: v1(167.13,107.22) 166.81,106.9 U9001.W11
  BOTTOM w0.102: v1(163,37.72) 162.59,37.31 162.59,36.49 162.39,36.29 162.39,34.2 162.85,33.74 JDIM1002.190
M_B_DQ45: length 92.3
  TOP w0.102: JDIM1003.194 163.85,38.96 163.96,38.86 164.52,38.86 164.62,38.76 164.62,38.48 164.52,38.37 163.96,38.37 163.85,38.27 163.85,37.72 163.61,37.47 163.61,36.29 163.48,36.16 163.29,36.16 v1(163,36.45)
  IN1 w0.076: 169.24,96.38 169.24,96.48 166.91,98.82 166.91,103.97 166.6,104.28 166.6,104.89 166.75,105.04 166.75,106.19 v1(167.13,106.57)
  IN1 w0.102: v1(163,36.45) 163.26,36.45 163.38,36.57 163.38,37.88 169.63,44.13 169.63,61.78 169.53,61.89 169.45,61.89 169.35,61.99 169.35,62.22 169.45,62.32 169.53,62.32 169.63,62.42 169.63,62.65 169.53,62.75 169.45,62.75 169.35,62.85 169.35,63.08 169.45,63.18 169.53,63.18 169.63,63.28 169.63,63.51 169.53,63.61 169.45,63.61 169.35,63.71 169.35,63.94 169.45,64.04 169.53,64.04 169.63,64.15 169.63,64.37 169.53,64.48 169.45,64.48 169.35,64.58 169.35,64.81 169.45,64.91 169.53,64.91 169.63,65.01 169.63,65.24 169.53,65.34 169.45,65.34 169.35,65.44 169.35,65.67 169.45,65.77 169.53,65.77 169.63,65.87 169.63,66.1 169.53,66.2 169.45,66.2 169.35,66.3 169.35,66.53 169.45,66.63 169.53,66.63 169.63,66.74 169.63,66.97 169.53,67.07 169.45,67.07 169.35,67.17 169.35,67.4 169.45,67.5 169.53,67.5 169.63,67.6 169.63,67.83 169.53,67.93 169.45,67.93 169.35,68.03 169.35,68.26 169.45,68.36 169.53,68.36 169.63,68.46 169.63,68.72 169.55,68.79 169.45,68.79 169.35,68.9 169.35,69.12 169.45,69.23 169.53,69.23 169.63,69.33 169.63,69.56 169.53,69.66 169.45,69.66 169.35,69.76 169.35,69.99 169.45,70.09 169.55,70.09 169.63,70.17 169.63,70.77 169.96,71.11 169.96,71.34 169.86,71.44 169.73,71.44 169.63,71.54 169.63,71.77 169.73,71.87 169.89,71.87 169.96,71.94 169.96,72.2 169.63,72.54 169.63,75.32 172.02,77.71 172.02,89.73 169.24,92.5 169.24,96.38
  BOTTOM w0.076: v1(167.13,106.57) 166.81,106.25 U9001.W10
  BOTTOM w0.102: v1(163,36.45) 162.59,36.04 162.59,34.51 163.85,33.25 JDIM1002.194
M_B_DQ46: length 90.6
  TOP w0.102: v1(166.02,35.02) 165.66,35.38 165.53,35.38 165.25,35.1 165.25,34.9 165.59,34.56 165.59,34.45 165.47,34.33 165.21,34.33 165.12,34.23 165.12,33.77 165.29,33.59 165.49,33.59 165.87,33.97 166.02,33.97 166.25,33.75 166.39,33.75 166.59,33.95 166.78,33.95 166.93,33.8 166.93,33.61 166.81,33.48 166.81,33.34 167.1,33.04 JDIM1003.207
  IN1 w0.102: v1(168.05,104.62) 167.89,104.47 167.89,99.25 170.64,96.51 170.64,93.11 173.9,89.85 173.9,76.92 172.02,75.05 172.02,60.9 172.36,60.56 172.36,50.86 172,50.49 172,43.37 168.46,39.84 168.32,39.84 165.58,37.11 165.58,35.66 165.13,35.21 165.13,34.99 165.32,34.8 165.56,34.8 165.77,35.02 v1(166.02,35.02)
  BOTTOM w0.076: U9001.V7 167.72,104.3 v1(168.05,104.62)
  BOTTOM w0.102: JDIM1002.207 167.1,36.1 v1(166.02,35.02)
M_B_DQ47: length 90.9
  TOP w0.102: JDIM1003.204 166.36,38.83 166.25,38.73 165.77,38.73 165.67,38.63 165.67,38.35 165.77,38.25 166.93,38.25 167.05,38.12 167.05,37.93 166.94,37.81 165.89,37.81 165.77,37.68 165.77,37.43 166.02,37.17 v1(166.02,36.92)
  IN1 w0.076: 171.71,96.64 168.76,99.59 168.76,103.7 168.54,103.93 168.54,104.77 168.05,105.26 v1(168.05,105.27)
  IN1 w0.102: v1(166.02,36.92) 166.02,37.08 168.45,39.51 168.6,39.51 172.49,43.4 172.58,43.4 172.69,43.51 172.69,43.79 172.6,43.88 172.4,43.88 172.33,43.95 172.33,44.21 172.43,44.31 172.59,44.31 172.69,44.41 172.69,44.64 172.59,44.74 172.43,44.74 172.33,44.84 172.33,45.07 172.43,45.17 172.59,45.17 172.69,45.27 172.69,45.5 172.59,45.61 172.43,45.61 172.33,45.71 172.33,45.94 172.43,46.04 172.59,46.04 172.69,46.14 172.69,46.37 172.59,46.47 172.43,46.47 172.33,46.57 172.33,46.8 172.43,46.9 172.59,46.9 172.69,47 172.69,47.23 172.59,47.33 172.43,47.33 172.33,47.43 172.33,47.66 172.43,47.76 172.59,47.76 172.69,47.87 172.69,48.09 172.59,48.2 172.43,48.2 172.33,48.3 172.33,48.53 172.43,48.63 172.59,48.63 172.69,48.73 172.69,48.96 172.59,49.06 172.43,49.06 172.33,49.16 172.33,49.39 172.43,49.49 172.59,49.49 172.69,49.59 172.69,49.82 172.59,49.92 172.43,49.92 172.33,50.02 172.33,50.35 172.69,50.72 172.69,60.7 172.35,61.04 172.35,74.91 174.23,76.78 174.23,89.83 171.71,92.34 171.71,96.64
  BOTTOM w0.076: v1(168.05,105.27) 167.72,104.95 U9001.V8
  BOTTOM w0.102: JDIM1002.204 166.36,33.03 165.61,33.77 165.61,36.52 v1(166.02,36.92)
M_B_DQ48: length 94.5
  TOP w0.102: v1(167.8,34.66) 167.65,34.66 167.39,34.41 167.39,33.86 167.76,33.48 168.11,33.48 168.31,33.68 168.31,33.92 168.38,34 168.62,34 168.69,33.93 168.69,33.6 168.51,33.43 168.51,33.3 168.6,33.21 168.92,33.21 169.04,33.34 169.04,33.57 169.17,33.69 169.76,33.69 169.9,33.55 169.9,33.36 169.75,33.21 169.3,33.21 169.1,33.02 JDIM1003.215
  IN1 w0.076: 172.53,96.48 172.53,96.59 169.4,99.72 169.4,103.9 169.15,104.15 169.15,104.99 169.34,105.18 169.34,106.39 169.44,106.49 169.44,106.79 v1(169.88,107.22)
  IN1 w0.102: 172.53,96.48 172.53,92.64 175.37,89.8 175.37,76.31 173.54,74.48 173.54,71.19 174.11,70.61 174.11,52.06 173.83,51.78 173.83,42.96 169.24,38.37 168.93,38.37 167.21,36.65 167.21,35.67 166.91,35.37 166.91,34.96 167.21,34.66 v1(167.8,34.66)
  BOTTOM w0.076: U9001.R11 169.55,106.9 v1(169.88,107.22)
  BOTTOM w0.102: v1(167.8,34.66) 168.31,35.17 168.31,37.94 169.1,38.73 JDIM1002.215
M_B_DQ49: length 95.4
  TOP w0.102: JDIM1003.229 172.6,33.07 173.01,33.47 173.01,33.87 172.63,34.25 172.63,35.49 172.5,35.63 172.24,35.63 172.12,35.5 172.12,34.79 172.02,34.69 171.85,34.69 171.74,34.58 171.74,34.3 171.85,34.2 172.02,34.2 172.37,33.85 172.37,33.57 172.17,33.36 171.87,33.36 v1(171.34,33.89)
  IN1 w0.076: 178.62,89.03 178.62,89.52 175.14,93 175.14,97 172.07,100.07 172.07,103.72 171.63,104.15 171.63,105.36 171.32,105.67 171.32,106.33 171.25,106.41 171.25,106.76 v1(170.79,107.22)
  IN1 w0.102: v1(171.34,33.89) 171.5,33.89 172.63,35.02 172.63,36.5 177.39,41.27 177.39,49.82 178.47,50.89 178.47,74.87 178.62,75.02 178.62,89.03
  BOTTOM w0.076: U9001.P11 170.46,106.9 v1(170.79,107.22)
  BOTTOM w0.102: v1(171.34,33.89) 171.84,34.4 171.84,36.54 172.6,37.3 JDIM1002.229

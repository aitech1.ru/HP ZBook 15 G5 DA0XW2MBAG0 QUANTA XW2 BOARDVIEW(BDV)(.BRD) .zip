# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CALL_ANSWER_LED_CNTR: length 4.6
  TOP w0.114: Q6801.3 239.92,57.36 v1(239.27,58) 238.94,58.33 238.22,58.33 R6804.2 R6812.1
CALL_DECLINE_END_LED: length 56
  TOP w0.114: Q6802.2 240.18,61.32 R6823.1 241.46,60.04 241.46,58.51 240.7,57.75 240.7,56.04 241.71,55.03 246.37,55.03 247.86,53.54 247.86,48.42 248.11,48.16 248.11,45.2 248.61,44.71 248.61,43.74 248.7,43.65 v1(248.7,42.51)
  IN1 w0.076: v3(271.49,29.87) 271.49,30 271.02,30.47 269.23,30.47 268.7,31 265.89,31 265.3,31.6 265.3,32.42 263.18,34.53 259.02,34.53 257.29,36.26 256.32,36.26 254.32,38.25 251.21,38.25 250.41,39.06 248.8,40.67 248.8,42.09 248.7,42.19 v1(248.7,42.51)
  BOTTOM w0.114: U6001.K10 v3(271.49,29.87)
CALL_DECLINE_END_LED_CNTR: length 4
  TOP w0.114: v1(237.4,60.92) 237.4,60.55 R6809.1 R6805.2 238.43,59.02 Q6802.3
CAMERA_ON: length 301.6
  TOP w0.114: v1(257.5,72.26) 257.5,72.57 256.7,73.37 256.7,74.03 257.28,74.61 257.28,75 256.89,75.39 256.89,75.87 258,76.98 258.78,76.98 261.38,79.57 R9225.1
  IN2 w0.089: v1(52.1,44.67) 53.37,45.94 56.67,45.94 57.18,46.45 61.67,46.45 66.42,51.2 67.89,51.2 68.5,51.81 82.9,51.81 83.98,50.73 89.7,50.73 96.55,43.88 96.55,42.35 100.56,38.35 100.56,30.15 102.03,28.67 102.03,24.06 103.73,22.37 105.29,22.37 105.57,22.09 115.28,22.09 116.32,21.04 163.91,21.04 164.65,21.78 180.21,21.78 180.81,22.38 189.42,22.38 190.36,23.31 191.23,23.31 191.44,23.1 194.82,23.1 195.48,23.76 199.15,23.76 200.01,22.9 205.89,22.9 206.26,23.27 214.52,23.27 215.23,23.97 217.6,23.97 222.25,28.63 231.26,28.63 233.39,30.75 235.69,30.75 236.99,32.06 239.76,32.06 244.35,36.66 245.81,36.66 247.18,38.03 247.18,38.52 248.76,40.09 248.76,41.43 250.04,42.71 250.84,42.71 252.43,44.31 252.43,46.73 254.41,48.7 254.41,50.92 254.9,51.42 256.46,51.42 264.92,59.87 264.92,64.41 265.94,65.44 265.94,65.88 266.57,66.5 266.57,67.64 264.01,70.19 263.83,70.19 260.57,73.45 258.88,73.45 258.58,73.75 258.1,73.75 257.5,73.16 v1(257.5,72.26)
  BOTTOM w0.114: U9002.AW26 257.13,72.64 v1(257.5,72.26) ; CON3000.29 51.43,53.08 50.98,52.62 50.98,52.33 50.83,52.19 50.35,52.19 50.07,51.9 50.07,49.49 51.09,48.48 51.09,45.68 v1(52.1,44.67)
CAPS_LED#: length 5.7
  TOP w0.114: R6184.1 264.52,13.82 U6003.4 265.66,14.38 v1(265.46,14.57) 266.09,15.2 R6185.2 265.09,15.46 R18103.1 264.84,15.45 264.45,15.84 Q9039.5
CAPS_LED#_R: length 73.6
  TOP w0.114: R18103.2 264.56,16.23 264.45,16.34 Q9039.6 263.9,16.34 262.8,17.44 258.96,17.44 257.46,18.94 257.46,23.08 255.33,25.21 v1(254.18,25.21)
  IN2 w0.089: v1(230.69,33.75) 231.5,34.56 231.5,35.84 233.51,37.84 233.51,54.73 v1(232.82,55.41)
  BOTTOM w0.114: v1(254.18,25.21) 252.97,25.21 251.85,26.33 251.85,27.05 250.99,27.9 250.99,28.37 246.78,32.58 245.98,32.58 245.62,32.22 245.4,32.22 245.02,32.6 245.02,32.84 244.37,33.49 243.99,33.49 241.68,31.17 236.73,31.17 235.76,32.15 233.21,32.15 231.61,33.75 v1(230.69,33.75) ; R6821.1 231.43,53.96 R17967.1 231.44,54.07 232.78,55.41 v1(232.82,55.41)
CARD_CLK_REQ4#: length 304.6
  TOP w0.114: R9187.1 263.92,76.14 263.3,76.14 263.04,75.88 262.52,75.88 261.57,74.94 261.57,74.32 258.69,71.44 v1(258.69,71.09)
  IN2 w0.089: v1(52.85,52.51) 55.31,52.51 56.24,51.58 67.77,51.58 68.36,52.17 76.44,52.17 77.96,53.68 82.38,53.68 84.8,51.27 89.96,51.27 90.72,50.51 91.98,50.51 102.02,40.47 102.02,30.41 103.67,28.76 103.67,26.26 105.89,24.04 153.3,24.04 153.4,24.15 170.31,24.15 170.47,24 187.06,24 187.66,24.6 189.82,24.6 190.37,25.14 205.07,25.14 206.06,24.14 213.82,24.14 214.51,24.83 217.07,24.83 221.61,29.38 230.76,29.38 233.27,31.89 234.87,31.89 236.82,33.84 240.39,33.84 243.03,36.49 243.03,37.73 245.55,40.24 245.55,41.68 247.83,43.96 247.83,45.81 248.6,46.58 248.6,47.92 249.71,49.04 249.71,50.48 251.69,52.45 251.97,52.45 262.81,63.3 262.81,63.61 263.28,64.08 263.28,65.89 261.98,67.19 261.98,68.49 262.46,68.98 262.46,69.72 262.12,70.07 261.91,70.07 261.09,70.88 258.9,70.88 v1(258.69,71.09)
  IN3 w0.089: v1(52.85,52.51) 50.16,55.21 47.92,55.21 45.55,57.58 43.86,57.58 38.99,62.45 35.99,62.45 34.58,63.87 34.58,68.28 32.65,70.21 v1(32.65,70.53)
  BOTTOM w0.114: U9002.BA30 258.69,71.66 v1(258.69,71.09) ; v1(32.65,70.53) 32.48,70.36 U7301.2
CATERR#: length 13.6
  TOP w0.114: v1(141.04,121.4) 140.38,120.74 138.45,120.74 135.97,118.27 135.97,117.41 135.52,116.96 135.05,116.96 134.65,116.56 134.65,115.91 R9000.1 133.64,114.65 TP9004.1 132.87,114.64 132.62,114.39 Q9001.5
  BOTTOM w0.114: U9001.BM30 141.37,121.73 v1(141.04,121.4)
CCG5_AR_RST#_DP: length 178.8
  TOP w0.114: R8680.1 345.91,100.96 344.96,100.01 344.96,99.36 345.11,99.22 345.11,98.83 v3(345.42,98.52)
  IN2 w0.089: v3(345.42,98.52) 345.42,98.34 344.58,97.5 341.15,97.5 340.34,96.69 340.34,95.27 339.54,94.47 338.68,94.47 338.26,94.05 338.26,91.25 337.16,90.16 337.16,85.12 333.74,81.7 333.74,81.19 332.6,80.06 332.6,79.67 329.55,76.61 329.55,75.35 327.89,73.69 326.62,73.69 325.47,72.54 325.47,71.86 321.52,67.91 321.52,64.98 322.76,63.74 323.69,63.74 324.2,63.23 324.2,62.52 325.82,60.9 326.91,60.9 330.4,57.41 330.4,57.33 330.49,57.25 330.49,56.48 331.39,55.57 332.07,55.57 332.58,55.06 332.58,54.85 333.84,53.58 333.84,52.63 333.85,52.62 333.85,51.87 333.43,51.45 333.43,49.7 334.07,49.06 334.07,47.16 334.72,46.5 334.72,44.5 337.09,42.13 337.67,42.13 338.49,41.31 338.49,33.18 338.31,33 338.31,30.39 337.03,29.12 337.03,28.34 v1(336.65,27.95)
  IN3 w0.089: v1(336.65,27.95) 336.65,27.78 336.32,27.45 334.73,27.45 333.92,26.64 331.58,26.64 329.18,24.24 325.17,24.24 324.92,23.99 321.64,23.99 318.83,21.17 317.91,21.17 317.51,20.77 313.49,20.77 310.92,23.34 307.87,23.34 302.78,28.43 295.64,28.43 294.7,27.49 290.23,27.49 288.8,26.06 284.13,26.06 282.55,24.47 281.25,24.47 280.61,25.11 278.67,25.11 277.78,24.22 276.34,24.22 275.44,23.32 274.48,23.32 273.6,22.44 273.6,20.67 273.15,20.22 273.15,18.3 v1(271.81,16.96)
  BOTTOM w0.076: v3(345.42,98.52) 345.42,98.44 344.68,97.7 344.68,97.33 U8500.B2
  BOTTOM w0.114: v1(271.81,16.96) 272.24,16.52 JCN9000.25
CCG5_I2C_INT_EC_DP: length 167.2
  TOP w0.114: v1(345.12,88.28) 345.73,87.67 TP8526.1
  IN3 w0.089: v1(362.56,83.46) 361.23,82.13 361.23,69.76 362.61,68.37 362.61,65.97 364.12,64.46 364.12,63.19 363.75,62.83 363.75,48.17 357.02,41.44 357.02,40.55 356.77,40.29 356.77,37.92 355.85,37 352.37,37 348.08,32.71 346.1,32.71 344.19,30.8 341.25,30.8 340.52,30.06 335.7,30.06 335.19,29.55 332.24,29.55 329.12,26.43 319.38,26.43 318.33,25.38 316.04,25.38 314.28,27.14 309.74,27.14 307.41,29.46 304.73,29.46 303.71,30.48 301.99,30.48 300.71,31.76 298.72,31.76 296.39,34.1 286.1,34.1 285.58,33.57 285.58,32.4 285.25,32.07 282.71,32.07 282.29,31.66 280.98,31.66 279.52,33.11 v1(278.15,33.11)
  BOTTOM w0.114: v1(362.56,83.46) 361.16,83.46 360.27,84.35 356.51,84.35 355.89,84.97 351.07,84.97 349.97,86.07 348.65,86.07 347,87.72 345.68,87.72 v1(345.12,88.28) 344.71,88.69 344.71,89.37 344.32,89.76 R8508.2 344.2,90.97 343.82,91.35 343.82,92.04 343.43,92.43 U8500.L5 ; v1(278.15,33.11) 278.15,32.95 277.93,32.73 D6001.1
CCG5_RST#: length 7.3
  TOP w0.076: v3(266.29,28.57) 266.22,28.5
  TOP w0.114: R6238.2 260.37,29.83 260.87,29.83 261.12,29.58 261.12,29.58 261.2,29.49 261.21,29.49 261.41,29.29 R106.2 262.39,28.43 265.02,28.43 265.17,28.28 265.44,28.28 v1(265.59,28.44) 266.16,28.44 266.22,28.5
  BOTTOM w0.114: U6001.H3 v3(266.29,28.57)
CCG5_SWD_CLK_DP: length 173.8
  TOP w0.114: v3(344.28,96.68) 344.08,96.87 R8571.2 343.69,97.64 R8570.1
  IN2 w0.089: v3(344.28,96.68) 343.76,97.2 341.47,97.2 340.52,96.24 340.52,95.19 339.62,94.29 338.75,94.29 338.51,94.05 338.51,91.26 337.34,90.08 337.34,85.05 333.92,81.62 333.92,81.12 332.86,80.06 332.86,79.67 329.72,76.54 329.72,75.27 327.96,73.51 326.69,73.51 325.65,72.46 325.65,71.68 321.7,67.73 321.7,65.06 322.83,63.92 323.77,63.92 324.38,63.31 324.38,62.59 325.89,61.08 326.99,61.08 330.58,57.48 330.58,57.41 330.66,57.32 330.66,56.55 331.47,55.75 332.24,55.75 334.02,53.97 334.02,52.71 334.03,52.7 334.03,51.72 333.66,51.35 333.66,49.72 334.25,49.14 334.25,47.23 334.9,46.58 334.9,45.77 338.66,42 338.66,33.11 338.49,32.93 338.49,30.19 337.42,29.12 337.42,28.67 v1(337.5,28.59)
  IN3 w0.089: v1(272.45,16.96) 273.33,17.84 273.33,20.05 273.77,20.49 273.77,22.37 274.55,23.14 277.59,23.14 278.16,23.71 279.85,23.71 280.22,24.08 282.41,24.08 284.21,25.88 288.87,25.88 290.26,27.27 294.82,27.27 295.81,28.25 302.7,28.25 307.8,23.16 309.32,23.16 311.89,20.6 318.26,20.6 318.75,20.11 319.74,20.11 323.44,23.81 324.99,23.81 325.25,24.06 329.25,24.06 331.65,26.46 333.99,26.46 334.8,27.28 336.96,27.28 337.42,27.73 337.42,28.51 v1(337.5,28.59)
  BOTTOM w0.114: v1(272.45,16.96) 272.74,16.66 JCN9000.26 ; v3(344.28,96.68) 344.3,96.68 344.39,96.59 U8500.C2
CCG5_VBUS_C_CTRL_P1: length 69.4
  IN1 w0.076: v1(345.21,90.72) 346.04,89.88 349.79,89.88 350.59,90.68 350.59,96 351.43,96.84 351.43,99.23 352.14,99.94 352.14,102.12 352.8,102.78 352.8,111.75 351.44,113.11 351.44,114.55 350.36,115.63 350.36,116.74 350.78,117.16 350.78,119.6 349.11,121.27 348.75,121.27 346.95,123.08 346.95,126.46 346.95,126.58 341.38,132.15 v1(341.38,136.34)
  BOTTOM w0.076: U8500.K4 343.68,92.83 343.68,92.43 344,92.12 344,91.48 344.46,91.02
  BOTTOM w0.114: R7199.2 345.22,90.71 v1(345.21,90.72) 344.76,90.72 344.46,91.02 ; PR26014.2 PR26013.1 343.19,135.52 342.9,135.81 342.76,135.81 342.55,136.01 342.23,136.34 341.44,136.34 ; 341.44,136.34 341.03,136.75 340.21,136.75 339.71,137.25 338.59,137.25 338.41,137.07 PQ10004.2 ; 341.44,136.34 v1(341.38,136.34)
CCG5_VBUS_C_CTRL_P2: length 53.4
  TOP w0.114: v1(343.21,99.53) 342.93,99.53 339.5,102.96 339.5,104.03 v1(339.3,104.23)
  IN1 w0.076: v1(335.62,129.61) 336.49,129.61 341.36,124.74 341.36,122.24 341.76,121.83 341.76,121.31 340.15,119.7 340.15,112.36 339.66,111.86 339.66,107.8 339.9,107.55 339.9,106.69 339.55,106.34 339.07,106.34 338.87,106.14 338.87,104.66 v1(339.3,104.23)
  BOTTOM w0.076: 343.21,99.15 343.21,99.05 342.98,98.82 342.98,97.93 343.19,97.73 343.19,97.33 U8500.B5
  BOTTOM w0.114: v1(335.62,129.61) v1(334.48,130.74) 332.7,132.53 332.7,136.16 331.54,137.32 331.54,137.96 PR26015.1 331.96,139.19 PR26016.2 332.18,139.53 332.7,140.04 PQ10005.2 ; R8551.2 343.21,99.93 v1(343.21,99.53) 343.21,99.15
CCG5_VBUS_CSN_P1_R: length 3.7
  TOP w0.114: R18021.1 344.46,99.55 344.88,99.12 344.88,98.48 v1(344.84,98.44) 344.47,98.07 v3(344.27,98.07)
  BOTTOM w0.076: v3(344.27,98.07) 344.19,97.99 344.19,97.33 U8500.B3
CCG5_VBUS_CSN_P2_R: length 1.5
  TOP w0.254: v3(342.2,93.66) 342.07,93.79 R18020.1
  BOTTOM w0.254: v3(342.2,93.66) 342.2,93.35 U8500.K8
CCG5_VBUS_P_CTRL_P1: length 64.1
  IN1 w0.076: v1(340.57,136.34) 340.57,132.49 340.85,132.21 341.1,132.21 346.79,126.52 346.79,123.01 348.69,121.12 349.04,121.12 350.63,119.54 350.63,117.26 350.21,116.84 350.21,115.57 350.47,115.3 350.47,113.86 352.58,111.75 352.58,110.08 352.39,109.89 352.39,105.37 352.65,105.12 352.65,102.85 350.44,100.64 350.44,90.74 349.73,90.03 346.53,90.03 v1(345.84,90.72)
  BOTTOM w0.076: 345.62,91.02 345.37,91.28 344.58,91.28 344.18,91.68 344.18,92.83 U8500.K3
  BOTTOM w0.114: v1(340.57,136.34) v1(340.57,135.65) 340.15,135.23 Q7120.2 ; R7140.2 346.23,90.32 v1(345.84,90.72) 345.84,90.81 345.62,91.02
CCG5_VBUS_P_CTRL_P2: length 41.5
  TOP w0.114: Q7146.2 339.24,132.29 v1(338.61,131.66) ; v1(339.3,104.87) 339.73,104.43 339.73,103.11 342.69,100.16 R7153.2 344.46,99.14 v1(344.46,98.95)
  IN1 w0.076: v1(339.3,104.87) 339.3,105.37 340.14,106.21 340.14,107.53 339.81,107.86 339.81,111.6 340.3,112.09 340.3,119.64 341.92,121.25 341.92,123.1 341.51,123.51 341.51,124.8 338.61,127.7 v1(338.61,131.66)
  BOTTOM w0.076: v1(344.46,98.95) 344.35,98.95 343.76,98.35 343.76,97.76 343.69,97.69 343.69,97.33 U8500.B4
CCG5_XRES_DP: length 193.7
  TOP w0.114: v1(339.12,90.18) 339.83,90.89 R8502.1 ; v1(260.25,30.39) 260.57,30.07 R106.1
  IN2 w0.089: v1(339.12,90.18) 338.94,90.01 338.94,85.51 334.11,80.68 334.11,78.9 328.55,73.33 326.77,73.33 325.84,72.4 325.84,71.54 321.88,67.58 321.88,65.13 322.91,64.1 323.84,64.1 324.56,63.38 324.56,62.67 325.97,61.25 327.06,61.25 330.76,57.56 330.76,57.48 330.87,57.37 330.87,56.6 331.54,55.93 332.31,55.93 334.2,54.04 334.2,52.78 334.24,52.73 334.24,51.63 333.89,51.27 333.89,49.74 334.42,49.21 334.42,47.3 335.08,46.65 335.08,45.84 338.84,42.07 338.84,33.03 338.66,32.86 338.66,28.82 338.5,28.65 v1(338.5,28.59)
  IN3 w0.089: v1(255.71,28.46) 255.56,28.03 255.56,27.4 256.07,26.88 256.73,26.88 256.74,26.89 258.66,26.89 260.76,24.79 260.76,23.33 261.7,22.39 261.7,20.64 262.31,20.03 264.24,20.03 265.64,18.63 266.73,18.63 267.57,17.79 270.85,17.79 v1(271.56,18.51) 272.19,18.51 272.7,19.01 272.7,20.54 273.24,21.08 273.24,22.59 274.33,23.67 275.02,23.67 275.95,24.6 277.53,24.6 278.67,25.74 283.03,25.74 283.72,26.44 288.68,26.44 290.17,27.93 294.6,27.93 295.46,28.79 302.94,28.79 307.95,23.77 311.39,23.77 313.96,21.2 317.28,21.2 317.62,21.55 318.68,21.55 321.47,24.34 324.77,24.34 325.15,24.72 325.91,24.72 325.91,24.75 326.68,25.52 329.95,25.52 331.43,27 333.51,27 334.17,27.65 334.17,28.1 334.52,28.44 335.52,28.44 336.26,29.19 337.73,29.19 338.32,28.59 v1(338.5,28.59)
  IN4 w0.076: v1(255.71,28.46) 257.51,28.46 258.86,29.81 259.67,29.81 v1(260.25,30.39)
  BOTTOM w0.114: JCN9000.27 273.24,16.82 v1(272.15,17.91) v1(271.56,18.51)
CCG5_XRES_DP_Q: length 6.1
  TOP w0.114: R8588.2 342.54,94.85 342.54,93.93 342.7,93.77 v3(342.7,93.54) 342.7,93.36 342.42,93.07 C8513.1 342.02,92.67 341.94,92.75 v1(341.51,92.75) 340.43,91.67 R8502.2
  BOTTOM w0.114: v3(342.7,93.54) 342.7,93.66 342.93,93.89 U8500.H6
CFG0: length 96.3
  IN1 w0.076: v1(88.39,60.55) 88.6,60.76 88.6,61.75 88.53,61.83 88.08,61.83 88,61.9 88,62.13 88.08,62.21 88.53,62.21 88.6,62.28 88.6,66.11 89.34,66.86 89.34,67.93 93.54,72.12 93.54,72.61 94.67,73.73 96.8,73.73 97.05,73.98 99.61,73.98 101.36,75.73 103.61,75.73 108.26,80.38 108.26,81.6 110,83.34 110,88.44 111.28,89.72 111.28,91.84 111.47,92.03 111.47,92.91 114.27,95.71 114.27,96.84 123.31,105.88 126.52,105.88 127.82,107.18 128.65,107.18 129.59,108.12 130.32,108.12 131.47,109.27 132.66,109.27 133.33,109.95 135.77,109.95 136.19,110.37 136.19,113.78 136.61,114.2 136.61,115.34 137.11,115.83 140.82,115.83 141.43,116.44 141.43,117.86 v1(141.04,118.25)
  BOTTOM w0.114: CON400.9 89.23,61.6 89.01,61.38 v1(89.01,60.9) 88.66,60.55 v1(88.39,60.55) 87.79,59.94 R400.1 ; v1(141.04,118.25) 141.04,118.24 140.72,117.92 U9001.BN25
CFG1: length 99.7
  IN1 w0.076: v1(87.76,60.57) 87.18,60.57 86.91,60.3 84.8,60.3 84.69,60.42 84.69,62.89 85.3,63.5 85.3,66.56 88.6,69.86 88.6,71.03 91.5,73.93 92.24,73.93 93.97,75.67 94.94,75.67 95.79,76.52 99.27,76.52 103.28,80.53 103.28,82.02 106.73,85.46 106.73,88.91 108.17,90.35 108.17,91.5 108.72,92.05 108.72,93.33 110.06,94.68 110.06,96.97 119.01,105.91 119.01,109.94 123.45,114.38 125.01,114.38 125.43,114.8 128.23,114.8 130.65,117.22 133.35,117.22 135.98,119.85 138.62,119.85 139,120.23 140.64,120.23 v1(141.04,119.83)
  BOTTOM w0.114: v1(87.76,60.57) 88.73,61.54 CON400.11 ; U9001.BN27 140.72,119.5 v1(141.04,119.83)
CFG2: length 108.1
  TOP w0.114: v1(140.39,118.25) 139.81,118.84 138.97,118.84 138.67,118.53 138.67,118.12 138.27,117.72 136.74,117.72 136.56,117.53 136.56,114.22 R9011.1
  IN1 w0.076: v1(140.39,118.25) 140.81,118.68 141.3,118.68 141.69,118.3 141.69,116.44 140.88,115.63 137.12,115.63 136.76,115.27 136.76,114.14 136.34,113.72 136.34,110.3 135.83,109.79 133.4,109.79 132.72,109.12 131.53,109.12 130.38,107.97 129.65,107.97 127.41,105.73 124.23,105.73 122.24,103.74 121.39,103.74 114.42,96.78 114.42,95.65 112.74,93.97 112.74,92.69 112.2,92.15 112.2,90.37 110.15,88.32 110.15,83.28 108.41,81.54 108.41,80.32 103.67,75.58 101.42,75.58 99.67,73.83 97.11,73.83 96.86,73.58 94.73,73.58 93.69,72.54 93.69,72.06 89.5,67.86 89.5,66.79 88.76,66.06 88.76,60.39 88.1,59.73 v1(87.15,59.73)
  BOTTOM w0.114: CON400.15 87.73,61.75 87.56,61.58 87.41,61.58 87.15,61.33 v1(87.15,60.8) v1(87.15,59.73) ; v1(140.39,118.25) 140.72,118.58 U9001.BN26
CFG3: length 99.3
  IN1 w0.076: v1(140.39,119.83) 139.55,118.99 139.36,118.99 139.29,119.06 139.29,119.39 139.21,119.47 138.98,119.47 138.91,119.39 138.91,119.06 138.83,118.99 138.6,118.99 138.53,119.06 138.53,119.39 138.45,119.47 138.22,119.47 138.14,119.39 138.14,119.06 138.07,118.99 137.84,118.99 137.76,119.06 137.76,119.39 137.69,119.47 137.46,119.47 137.38,119.39 137.38,119.06 137.31,118.99 137.08,118.99 137,119.06 137,119.39 136.93,119.47 136.7,119.47 136.62,119.39 136.62,119.06 136.54,118.99 136.39,118.99 136.02,118.63 136.02,118.3 134.91,117.18 134.07,117.18 133.66,116.77 130.84,116.77 128.42,114.34 125.69,114.34 125.28,113.93 125.28,110.1 125.74,109.64 125.74,108.05 124.95,107.27 121.01,107.27 113.58,99.84 113.58,98.12 111.83,96.36 111.83,95.79 109.18,93.14 109.18,91.86 108.63,91.31 108.63,90.16 107.19,88.72 107.19,85.27 104.43,82.51 104.43,80.74 99.73,76.05 96.97,76.05 95.87,74.95 93.9,74.95 92.42,73.47 91.69,73.47 89.68,71.47 89.68,69.75 87.92,67.99 87.92,65.01 87.54,64.63 87.54,63.04 86.65,62.16 v1(86.65,61.3)
  BOTTOM w0.114: R405.2 86.65,60.04 v1(86.65,61.3) 86.75,61.3 87.23,61.79 CON400.17 ; U9001.BN28 140.72,120.2 140.39,119.88 v1(140.39,119.83)
CFG4: length 98
  IN1 w0.076: v1(137.11,113.47) 137.11,112.54 136.8,112.23 136.8,110.08 136.06,109.34 133.59,109.34 132.91,108.66 131.72,108.66 130.57,107.51 129.84,107.51 127.6,105.27 125.43,105.27 119.84,99.69 119.73,99.69 119.44,99.98 119.33,99.98 119.17,99.82 119.17,99.71 119.46,99.42 119.46,99.31 119.3,99.15 119.2,99.15 118.9,99.44 118.79,99.44 118.63,99.28 118.63,99.18 118.93,98.88 118.93,98.77 115.85,95.69 115.11,95.69 113.2,93.78 113.2,90.72 110.61,88.13 110.61,81.12 103.6,74.11 100.59,74.11 99.86,73.37 97.3,73.37 96.7,72.77 95.2,72.77 94.22,71.79 93.64,71.79 89.65,67.8 89.65,66.73 88.91,66 88.91,60.33 87.3,58.71 86.01,58.71 v1(85.76,58.97)
  BOTTOM w0.114: CON400.27 84.73,61.73 84.66,61.67 84.66,60.72 v1(84.49,60.54) 84.49,60.42 85.33,59.57 85.33,59.39 v1(85.76,58.97) ; U9001.BR20 139.08,114.26 137.9,114.26 v1(137.11,113.47) 136.18,114.41 136.18,115.16 R9013.1
CFG5: length 108.4
  TOP w0.114: v1(141.04,113.53) 141.04,113.38 140.37,112.71 137.03,112.71 136.56,112.23 R9014.1
  IN1 w0.076: v1(141.04,113.53) 142.25,112.32 142.25,109.29 141.84,108.88 138.18,108.88 137.42,108.12 134.09,108.12 133.42,107.44 132.23,107.44 131.15,106.36 131.15,105.42 130.44,104.72 128.77,104.72 128.11,104.05 125.93,104.05 115.39,93.51 115.39,90.98 114.45,90.04 114.45,87.87 113.03,86.45 113.03,81.01 108.64,76.62 108.64,75.6 105.93,72.89 102.58,72.89 100.57,70.88 94.02,70.88 92.08,68.94 92.08,66.11 91.19,65.22 89.67,65.22 89.37,64.92 89.37,64.35 90.85,62.88 90.85,61.22 87.89,58.26 85.88,58.26 v1(85.5,57.88)
  BOTTOM w0.114: v1(141.04,113.53) 141.04,113.6 U9001.BM20 ; v1(85.5,57.88) 85.3,58.08 85.3,59.1 83.67,60.73 83.67,61.25 84.23,61.81 CON400.29
CFG6: length 100
  IN1 w0.076: v1(137.75,113.47) 137.75,112.96 136.95,112.16 136.95,110.01 136.13,109.18 133.65,109.18 132.98,108.51 131.78,108.51 130.63,107.36 129.91,107.36 127.67,105.12 125.49,105.12 115.91,95.54 115.17,95.54 113.35,93.72 113.35,90.66 110.76,88.07 110.76,87.38 110.84,87.3 111.38,87.3 111.46,87.23 111.46,87 111.38,86.92 110.84,86.92 110.76,86.84 110.76,86.62 110.84,86.54 111.38,86.54 111.46,86.46 111.46,86.24 111.38,86.16 110.84,86.16 110.76,86.08 110.76,85.85 110.84,85.78 111.38,85.78 111.46,85.7 111.46,85.47 111.38,85.4 110.84,85.4 110.76,85.32 110.76,81.05 103.66,73.95 100.66,73.95 99.33,72.62 95.27,72.62 94.29,71.64 93.7,71.64 89.8,67.74 89.8,66.67 89.07,65.93 89.07,60.27 87.36,58.56 85.24,58.56 v1(84.87,58.93)
  BOTTOM w0.114: v1(84.87,58.93) 84.61,59.19 84.61,59.34 83.23,60.73 v1(83.23,60.92) CON400.33 ; U9001.BT20 138.71,113.97 138.25,113.97 v1(137.75,113.47) 137.27,112.99 136.56,112.99 135.55,114 R9015.1
CFG7: length 103.4
  IN1 w0.076: v1(139.74,113.53) 140.33,112.94 141.41,112.94 142.1,112.26 142.1,109.39 141.74,109.03 138.12,109.03 137.36,108.27 134.03,108.27 133.36,107.6 132.16,107.6 130.99,106.43 130.99,105.49 130.37,104.87 128.71,104.87 128.05,104.21 125.87,104.21 115.23,93.57 115.23,91.04 114.3,90.11 114.3,87.93 112.88,86.52 112.88,81.07 108.49,76.68 108.49,75.67 105.86,73.04 102.52,73.04 100.51,71.03 93.96,71.03 91.93,69 91.93,66.17 91.13,65.37 89.57,65.37 89.22,65.02 89.22,64.29 90.7,62.81 90.7,61.28 87.83,58.41 85,58.41 v1(84.87,58.28)
  BOTTOM w0.114: v1(139.74,113.53) 139.74,113.6 U9001.BP20 ; v1(84.87,58.28) 84.36,58.79 84.36,59.27 83.6,60.03 83.22,60.03 82.73,60.52 CON400.35
CFG8: length 80.5
  IN1 w0.076: v1(137.62,117.28) 137.62,116.99 136.15,115.53 136.15,114.67 130.06,108.58 128.57,108.58 126.33,106.34 123.12,106.34 112.74,95.96 112.74,95.41 110.99,93.66 110.99,92.36 109.54,90.91 109.54,84.56 99.43,74.45 96.87,74.45 96.61,74.19 94.48,74.19 93.08,72.8 93.08,72.33 92.67,71.91 92.27,71.91 92.11,72.07 91.73,72.07 90.29,70.63 90.29,69.5 88.97,68.18 v1(88.97,67.07)
  BOTTOM w0.114: U9001.BR23 139.06,116.64 138.26,116.64 v1(137.62,117.28) ; v1(88.97,67.07) 89.23,67.32 CON400.10
CFG9: length 94.1
  IN1 w0.076: v1(94.51,72.61) 94.51,73.15 94.79,73.43 96.93,73.43 97.17,73.67 99.73,73.67 101.48,75.42 103.85,75.42 104.11,75.16 104.22,75.16 104.38,75.32 104.38,75.43 104.11,75.69 104.11,75.8 104.28,75.96 104.38,75.96 104.65,75.7 104.76,75.7 104.92,75.86 104.92,75.97 104.65,76.23 104.65,76.34 104.82,76.5 104.92,76.5 105.19,76.24 105.3,76.24 105.46,76.4 105.46,76.51 105.19,76.77 105.19,76.88 105.35,77.04 105.46,77.04 105.73,76.77 105.84,76.77 106,76.94 106,77.04 105.73,77.31 105.73,77.42 105.89,77.58 106,77.58 106.27,77.31 106.38,77.31 106.54,77.48 106.54,77.58 106.27,77.85 106.27,77.96 106.43,78.12 106.54,78.12 106.81,77.85 106.91,77.85 107.08,78.01 107.08,78.12 106.81,78.39 106.81,78.5 106.97,78.66 107.08,78.66 107.35,78.39 107.45,78.39 107.62,78.55 107.62,78.66 107.35,78.93 107.35,79.04 107.51,79.2 107.62,79.2 107.88,78.93 107.99,78.93 108.15,79.09 108.15,79.2 107.89,79.47 107.89,79.57 109.27,80.95 109.27,81.06 108.78,81.55 108.78,81.66 108.94,81.82 109.05,81.82 109.53,81.33 109.64,81.33 109.8,81.49 109.8,81.6 109.32,82.09 109.32,82.2 109.48,82.36 109.58,82.36 110.07,81.87 110.18,81.87 110.31,81.99 110.31,88.26 112.9,90.85 112.9,91.02 112.82,91.09 112.51,91.09 112.43,91.17 112.43,91.4 112.51,91.48 112.82,91.48 112.9,91.55 112.9,91.78 112.82,91.86 112.51,91.86 112.43,91.93 112.43,92.16 112.51,92.24 112.82,92.24 112.9,92.31 112.9,93.91 114.58,95.59 114.58,96.72 121.45,103.59 122.3,103.59 122.73,104.02 122.84,104.02 123.13,103.73 123.23,103.73 123.4,103.9 123.4,104 123.11,104.29 123.11,104.4 123.27,104.56 123.38,104.56 123.67,104.27 123.77,104.27 123.93,104.44 123.93,104.54 123.65,104.83 123.65,104.94 124.29,105.58 127.48,105.58 129.72,107.82 130.44,107.82 131.59,108.97 132.79,108.97 133.46,109.64 135.9,109.64 136.5,110.24 136.5,113.66 137.13,114.29 v1(137.13,115.12)
  BOTTOM w0.114: CON400.12 88.73,70.37 90.48,72.13 92.09,72.13 92.36,71.85 92.95,71.85 93.7,72.61 v1(94.51,72.61) ; v1(137.13,115.12) 137.89,115.88 139.03,115.88 U9001.BR22
CFG10: length 95.2
  IN1 w0.076: v1(136.99,117.28) 136.33,116.62 136.33,116.49 135.48,115.64 134.73,115.64 134.37,116 131.16,116 128.73,113.58 127.84,113.58 126.5,112.23 126.5,107.74 125.25,106.49 123.06,106.49 112.59,96.02 112.59,95.48 110.71,93.6 110.71,92.31 109.39,90.99 109.39,89.2 109.32,89.12 108.82,89.12 108.74,89.04 108.74,88.81 108.82,88.74 109.32,88.74 109.39,88.66 109.39,88.43 109.32,88.36 108.82,88.36 108.74,88.28 108.74,88.05 108.82,87.98 109.32,87.98 109.39,87.9 109.39,87.67 109.32,87.6 108.82,87.6 108.74,87.52 108.74,87.29 108.82,87.21 109.32,87.21 109.39,87.14 109.39,86.82 109.3,86.73 108.02,86.73 107.95,86.65 107.95,86.4 108.02,86.32 109.18,86.32 109.25,86.24 109.25,86.02 109.18,85.94 108.02,85.94 107.95,85.86 107.95,85.63 108.02,85.56 109.18,85.56 109.25,85.48 109.25,85.25 109.18,85.18 108.02,85.18 107.95,85.1 107.95,84.69 108.23,84.4 108.23,84.29 108.07,84.13 107.97,84.13 107.73,84.37 107.61,84.48 107.51,84.48 107.34,84.32 107.34,84.21 107.7,83.86 107.7,83.75 107.53,83.59 107.43,83.59 107.08,83.94 106.97,83.94 106.81,83.78 106.81,83.67 107.16,83.32 107.16,83.21 106.99,83.05 106.89,83.05 106.54,83.4 106.43,83.4 106.27,83.24 106.27,83.13 106.62,82.78 106.62,82.67 106.46,82.51 106.35,82.51 106,82.86 105.89,82.86 105.73,82.7 105.73,82.59 106.08,82.24 106.08,82.14 105.92,81.97 105.81,81.97 105.46,82.32 105.35,82.32 105.24,82.21 105.24,80.47 99.36,74.6 96.8,74.6 96.55,74.34 94.41,74.34 92.51,72.44 v1(92.51,72.3)
  BOTTOM w0.114: v1(92.51,72.3) 92.34,72.48 89.82,72.48 87.73,70.39 CON400.16 ; U9001.BT23 137.98,116.29 v1(136.99,117.28)
CFG11: length 95
  IN1 w0.076: v1(94.97,73.06) 96.77,73.06 97.24,73.52 99.8,73.52 101.41,75.14 101.67,75.14 101.75,75.06 101.75,74.46 101.82,74.39 102.05,74.39 102.13,74.46 102.13,75.06 102.2,75.14 103.55,75.14 103.79,74.89 104.17,74.89 108.48,79.2 108.48,79.31 108.22,79.58 108.22,79.69 108.38,79.85 108.49,79.85 108.75,79.58 108.86,79.58 109.02,79.74 109.02,79.85 108.75,80.12 108.75,80.23 108.92,80.39 109.02,80.39 109.29,80.12 109.4,80.12 109.56,80.28 109.56,80.39 109.29,80.66 109.29,80.76 109.46,80.93 109.56,80.93 109.83,80.66 109.94,80.66 110.46,81.18 110.46,88.2 113.05,90.79 113.05,93.84 114.73,95.52 114.73,96.65 115.5,97.42 115.61,97.42 116.34,96.69 116.44,96.69 116.61,96.85 116.61,96.96 115.87,97.69 115.87,97.8 116.04,97.96 116.14,97.96 116.87,97.23 116.98,97.23 117.14,97.39 117.14,97.5 116.41,98.23 116.41,98.34 119.05,100.97 119.16,100.97 119.5,100.62 119.61,100.62 119.77,100.78 119.77,100.89 119.42,101.24 119.42,101.35 119.63,101.55 119.73,101.55 120.46,100.82 120.57,100.82 120.73,100.98 120.73,101.09 120,101.82 120,101.93 120.17,102.09 120.27,102.09 121,101.36 121.11,101.36 121.27,101.52 121.27,101.63 120.54,102.36 120.54,102.47 121.51,103.44 123.32,103.44 125.3,105.42 127.54,105.42 129.78,107.67 130.51,107.67 131.66,108.82 132.85,108.82 133.52,109.49 136,109.49 136.65,110.14 136.65,113.59 137.77,114.71 v1(137.77,115.12)
  BOTTOM w0.114: CON400.18 87.23,70.4 89.89,73.06 v1(94.97,73.06) ; v1(137.77,115.12) 138.27,115.63 138.64,115.63 U9001.BT22
CFG12: length 99.1
  IN1 w0.076: v1(92.74,67.07) 92.62,67.2 92.62,69.26 94.08,70.73 100.63,70.73 102.48,72.57 105.83,72.57 109.29,76.03 109.29,76.14 108.9,76.53 108.9,76.64 109.06,76.8 109.17,76.8 109.56,76.41 109.67,76.41 109.83,76.57 109.83,76.68 109.44,77.07 109.44,77.17 109.6,77.34 109.71,77.34 110.1,76.95 110.21,76.95 110.37,77.11 110.37,77.22 109.98,77.61 109.98,77.71 110.14,77.87 110.25,77.87 110.64,77.49 110.74,77.49 110.91,77.65 110.91,77.76 110.52,78.14 110.52,78.25 110.68,78.41 110.79,78.41 111.18,78.03 111.28,78.03 111.45,78.19 111.45,78.3 111.06,78.68 111.06,78.79 111.22,78.95 111.33,78.95 111.71,78.57 111.82,78.57 111.98,78.73 111.98,78.84 111.6,79.22 111.6,79.33 111.76,79.49 111.87,79.49 112.25,79.11 112.36,79.11 112.52,79.27 112.52,79.38 112.14,79.76 112.14,79.87 112.3,80.03 112.41,80.03 112.79,79.64 112.9,79.64 113.32,80.06 113.32,86.46 114.6,87.75 114.6,89.98 115.54,90.92 115.54,93.44 126,103.9 128.17,103.9 128.83,104.56 130.54,104.56 131.3,105.32 131.3,106.3 132.29,107.29 133.48,107.29 134.16,107.96 137.48,107.96 138.25,108.73 141.9,108.73 142.41,109.23 142.41,112.81 v1(141.69,113.53)
  BOTTOM w0.114: CON400.28 84.73,67.46 85.12,67.07 88.07,67.07 88.51,66.64 89.19,66.64 89.62,67.07 v1(92.74,67.07) ; v1(141.69,113.53) 141.69,113.3 141.53,113.14 U9001.BM19
CFG13: length 96.6
  IN1 w0.076: v1(90.33,66.61) 90.33,68.05 93.77,71.49 94.35,71.49 95.33,72.47 99.39,72.47 100.72,73.8 103.73,73.8 104.17,74.25 104.28,74.25 104.57,73.95 104.68,73.95 104.84,74.11 104.84,74.22 104.55,74.52 104.55,74.62 104.71,74.79 104.82,74.79 105.11,74.49 105.22,74.49 105.38,74.65 105.38,74.76 105.09,75.05 105.09,75.16 105.25,75.32 105.36,75.32 105.65,75.03 105.76,75.03 105.92,75.19 105.92,75.3 105.63,75.59 105.63,75.7 105.79,75.86 105.9,75.86 106.19,75.57 106.3,75.57 106.46,75.73 106.46,75.84 106.17,76.13 106.17,76.24 106.33,76.4 106.43,76.4 106.73,76.11 106.84,76.11 107,76.27 107,76.38 106.7,76.67 106.7,76.78 106.87,76.94 106.97,76.94 107.27,76.65 107.38,76.65 107.54,76.81 107.54,76.92 107.24,77.21 107.24,77.32 107.41,77.48 107.51,77.48 107.81,77.19 107.92,77.19 108.08,77.35 108.08,77.45 107.78,77.75 107.78,77.86 110.92,80.99 110.92,81.89 110.99,81.97 111.53,81.97 111.61,82.05 111.61,82.27 111.53,82.35 110.99,82.35 110.92,82.43 110.92,82.65 110.99,82.73 111.53,82.73 111.61,82.81 111.61,83.04 111.53,83.11 110.99,83.11 110.92,83.19 110.92,83.42 110.99,83.49 111.53,83.49 111.61,83.57 111.61,83.8 111.53,83.87 110.99,83.87 110.92,83.95 110.92,84.18 110.99,84.26 111.53,84.26 111.61,84.33 111.61,84.56 111.53,84.64 110.99,84.64 110.92,84.71 110.92,84.94 110.99,85.02 111.53,85.02 111.61,85.09 111.61,88.5 113.51,90.39 113.51,93.65 115.24,95.39 115.97,95.39 125.55,104.97 127.73,104.97 129.97,107.21 130.7,107.21 131.85,108.36 133.04,108.36 133.71,109.03 136.19,109.03 137.11,109.95 137.11,112.1 138.38,113.38 v1(138.38,113.52)
  BOTTOM w0.114: U9001.BR19 139.03,113.52 v1(138.38,113.52) ; v1(90.33,66.61) 90.13,66.41 88.41,66.41 87.98,66.84 84.61,66.84 84.23,67.23 CON400.30
CFG14: length 95.1
  IN1 w0.076: v1(137.97,111.44) 137.97,110.34 136.35,108.73 133.84,108.73 133.17,108.05 131.97,108.05 130.82,106.9 130.1,106.9 127.86,104.66 125.68,104.66 116.1,95.08 115.36,95.08 113.81,93.53 113.81,90.27 111.92,88.37 111.92,88.2 111.99,88.13 112.35,88.13 112.42,88.05 112.42,87.82 112.35,87.75 111.99,87.75 111.92,87.67 111.92,87.44 111.99,87.36 112.35,87.36 112.42,87.29 112.42,87.06 112.35,86.98 111.99,86.98 111.92,86.91 111.92,86.68 111.99,86.6 112.35,86.6 112.42,86.53 112.42,86.3 112.35,86.22 111.99,86.22 111.92,86.15 111.92,85.92 111.99,85.84 112.35,85.84 112.42,85.76 112.42,85.54 112.35,85.46 111.99,85.46 111.92,85.38 111.92,85.15 111.99,85.08 112.35,85.08 112.42,85 112.42,84.77 112.35,84.7 111.99,84.7 111.92,84.62 111.92,80.75 111.78,80.62 111.67,80.62 111.38,80.91 111.27,80.91 111.11,80.75 111.11,80.64 111.4,80.35 111.4,80.24 111.24,80.08 111.13,80.08 110.84,80.37 110.73,80.37 110.57,80.21 110.57,80.1 110.86,79.81 110.86,79.7 104.66,73.5 100.87,73.5 99.54,72.16 95.46,72.16 94.48,71.18 93.89,71.18 90.86,68.15 90.86,67.6 90.94,67.53 91.65,67.53 91.73,67.45 91.73,67.22 91.65,67.14 90.94,67.14 90.86,67.07 90.86,65.85 v1(90.96,65.75)
  BOTTOM w0.114: U9001.BP19 139.71,112.78 138.62,112.78 137.97,112.13 v1(137.97,111.44) ; CON400.34 83.23,67.15 83.77,66.61 87.88,66.61 88.32,66.18 90.53,66.18 v1(90.96,65.75)
CFG15: length 92
  TOP w0.114: v1(88.93,65.75) v1(90.33,65.75)
  IN1 w0.076: v1(90.33,65.75) 90.71,66.13 90.71,68.22 93.83,71.34 94.42,71.34 95.4,72.32 99.45,72.32 100.78,73.65 104.59,73.65 108.41,77.46 108.41,77.57 108.11,77.86 108.11,77.97 108.28,78.13 108.38,78.13 108.68,77.84 108.78,77.84 108.95,78 108.95,78.11 108.65,78.4 108.65,78.51 108.81,78.67 108.92,78.67 109.22,78.38 109.32,78.38 109.49,78.54 109.49,78.65 109.19,78.94 109.19,79.05 109.35,79.21 109.46,79.21 109.76,78.92 109.86,78.92 110.02,79.08 110.02,79.19 109.73,79.48 109.73,79.59 109.89,79.75 110,79.75 110.29,79.46 110.4,79.46 110.56,79.62 110.56,79.73 110.27,80.02 110.27,80.13 111.07,80.93 111.07,81.61 111.21,81.75 111.67,81.75 111.76,81.85 111.76,88.43 113.66,90.33 113.66,93.59 115.3,95.23 116.04,95.23 125.62,104.82 127.79,104.82 130.03,107.06 130.76,107.06 131.91,108.21 133.1,108.21 133.78,108.88 136.25,108.88 137.47,110.1 v1(137.47,111.95)
  BOTTOM w0.114: v1(137.47,111.95) 138.54,113.01 138.64,113.01 U9001.BT19 ; v1(90.33,65.75) 90.15,65.93 88.25,65.93 87.79,66.38 83.67,66.38 82.73,67.33 CON400.36
CFG16: length 95.3
  IN1 w0.076: v1(139.74,116.68) 137.52,116.68 136.31,115.46 136.31,114.33 135.89,113.91 135.89,110.49 135.64,110.25 133.21,110.25 132.54,109.58 131.34,109.58 130.19,108.43 129.46,108.43 128.54,107.5 127.71,107.5 126.39,106.19 123.18,106.19 112.9,95.9 112.9,95.24 113.08,95.06 113.08,94.95 112.92,94.79 112.81,94.79 112.63,94.97 112.52,94.97 112.36,94.81 112.36,94.7 112.54,94.52 112.54,94.41 112.38,94.25 112.27,94.25 112.09,94.43 111.98,94.43 111.82,94.27 111.82,94.17 112,93.98 112,93.87 111.84,93.71 111.73,93.71 111.55,93.9 111.44,93.9 111.17,93.62 111.17,92.16 110.98,91.97 110.98,91.42 110.9,91.34 110.34,91.34 110.27,91.27 110.27,91.04 110.34,90.96 110.9,90.96 110.98,90.89 110.98,89.85 109.7,88.56 109.7,83.47 109.59,83.36 109.48,83.36 109.08,83.76 108.97,83.76 108.81,83.6 108.81,83.49 109.21,83.09 109.21,82.98 109.05,82.82 108.94,82.82 108.54,83.22 108.43,83.22 108.27,83.06 108.27,82.95 108.67,82.55 108.67,82.44 108.51,82.28 108.4,82.28 108,82.68 107.89,82.68 107.73,82.52 107.73,82.41 108.13,82.01 108.13,81.9 107.97,81.74 107.86,81.74 107.73,81.88 107.46,82.14 107.36,82.14 107.19,81.98 107.19,81.87 107.59,81.47 107.59,81.36 107.43,81.2 107.32,81.2 106.92,81.6 106.82,81.6 106.65,81.44 106.65,81.33 107.05,80.93 107.05,80.82 106.89,80.66 106.79,80.66 106.38,81.06 106.28,81.06 106.12,80.9 106.12,80.79 106.52,80.39 106.52,80.29 106.35,80.12 106.25,80.12 105.85,80.52 105.74,80.52 105.58,80.36 105.58,80.25 105.98,79.85 105.98,79.75 105.81,79.58 105.71,79.58 105.31,79.98 105.2,79.98 105.04,79.82 105.04,79.72 105.44,79.32 105.44,79.21 105.28,79.05 105.17,79.05 104.77,79.45 104.66,79.45 104.5,79.28 104.5,79.18 104.9,78.78 104.9,78.67 104.74,78.51 104.63,78.51 104.23,78.91 104.12,78.91 103.96,78.75 103.96,78.64 104.36,78.24 104.36,78.13 102.26,76.03 101.23,76.03 99.49,74.29 96.93,74.29 96.67,74.04 94.54,74.04 93.24,72.73 93.24,72.25 92.69,71.7 v1(91.89,71.7)
  BOTTOM w0.114: U9001.BP23 139.74,116.61 v1(139.74,116.68) ; v1(91.89,71.7) 91.2,71.7 90.23,70.73 CON400.6
CFG17: length 96
  IN1 w0.076: v1(140.39,116.68) 140.39,116.16 140.24,116.01 139.47,116.01 139.4,116.09 139.4,116.43 139.32,116.51 139.09,116.51 139.02,116.43 139.02,116.09 138.94,116.01 138.71,116.01 138.63,116.09 138.63,116.43 138.56,116.51 138.33,116.51 138.25,116.43 138.25,116.09 138.18,116.01 137.95,116.01 137.87,116.09 137.87,116.43 137.8,116.51 137.57,116.51 137.49,116.43 137.49,116.09 137.42,116.01 137.07,116.01 136.46,115.4 136.46,114.27 136.04,113.85 136.04,110.43 135.71,110.1 133.27,110.1 132.6,109.43 131.4,109.43 130.26,108.28 129.53,108.28 128.6,107.35 127.77,107.35 126.45,106.03 123.25,106.03 114.12,96.91 114.12,95.78 111.32,92.98 111.32,92.09 111.13,91.91 111.13,89.78 109.85,88.5 109.85,83.4 107.62,81.17 107.62,81.06 108.11,80.57 108.11,80.46 107.95,80.3 107.84,80.3 107.35,80.79 107.24,80.79 107.08,80.63 107.08,80.52 107.57,80.03 107.57,79.92 107.41,79.76 107.3,79.76 106.81,80.26 106.7,80.26 106.54,80.09 106.54,79.99 107.03,79.49 107.03,79.39 106.87,79.22 106.76,79.22 106.27,79.72 106.16,79.72 106,79.55 106,79.45 106.49,78.95 106.49,78.85 106.33,78.68 106.22,78.68 105.73,79.18 105.62,79.18 105.46,79.02 105.46,78.91 105.95,78.42 105.95,78.31 105.79,78.15 105.68,78.15 105.19,78.64 105.08,78.64 104.92,78.48 104.92,78.37 105.41,77.88 105.41,77.77 105.25,77.61 105.15,77.61 104.65,78.1 104.55,78.1 104.38,77.94 104.38,77.83 104.88,77.34 104.88,77.23 104.71,77.07 104.61,77.07 104.11,77.56 104.01,77.56 103.84,77.4 103.84,77.29 104.34,76.8 104.34,76.69 104.18,76.53 104.07,76.53 103.57,77.02 103.47,77.02 103.31,76.86 103.31,76.75 103.8,76.26 103.8,76.15 103.64,75.99 103.53,75.99 103.04,76.48 102.93,76.48 102.33,75.88 101.29,75.88 99.54,74.13 96.98,74.13 96.74,73.88 94.6,73.88 93.39,72.67 93.39,72.19 92,70.8 v1(90.99,70.8)
  BOTTOM w0.114: v1(90.99,70.8) 90.73,70.54 CON400.4 ; U9001.BN23 140.39,116.61 v1(140.39,116.68)
CFG18: length 95.4
  IN1 w0.076: v1(96.22,71.59) 96.63,71.18 99.09,71.18 99.72,71.81 99.83,71.81 100.35,71.29 100.45,71.29 100.61,71.45 100.61,71.56 100.1,72.08 100.1,72.19 100.26,72.35 100.37,72.35 100.88,71.83 100.99,71.83 101.15,71.99 101.15,72.1 100.64,72.62 100.64,72.73 101.1,73.19 104.78,73.19 105.28,73.69 105.39,73.69 105.78,73.3 105.89,73.3 106.05,73.46 106.05,73.57 105.66,73.96 105.66,74.07 105.82,74.23 105.93,74.23 106.32,73.84 106.43,73.84 106.59,74 106.59,74.11 106.2,74.5 106.2,74.61 106.36,74.77 106.47,74.77 106.86,74.38 106.97,74.38 107.13,74.54 107.13,74.65 106.74,75.04 106.74,75.15 106.9,75.31 107.01,75.31 107.4,74.92 107.51,74.92 107.67,75.08 107.67,75.19 107.28,75.58 107.28,75.69 107.44,75.85 107.55,75.85 107.94,75.45 108.05,75.45 108.21,75.62 108.21,75.72 107.82,76.12 107.82,76.22 112.73,81.13 112.73,88.75 115.08,91.11 115.08,93.63 125.81,104.36 127.98,104.36 130.22,106.6 130.95,106.6 132.1,107.75 133.29,107.75 133.97,108.42 136.52,108.42 139.26,111.16 139.26,113.98 v1(140.39,115.1)
  BOTTOM w0.114: U9001.BN22 140.72,115.43 v1(140.39,115.1) ; v1(96.22,71.59) 96.22,72.75 95.12,73.85 89.86,73.85 87.68,71.67 86.85,71.67 85.73,70.55 CON400.24
CFG19: length 94.3
  IN1 w0.076: v1(139.74,115.1) 139.11,114.48 139.11,113.01 139.04,112.93 138.41,112.93 138.34,112.85 138.34,112.63 138.41,112.55 139.04,112.55 139.11,112.47 139.11,111.23 136.46,108.57 133.9,108.57 133.23,107.9 132.04,107.9 130.89,106.75 130.16,106.75 127.92,104.51 125.74,104.51 116.16,94.93 115.43,94.93 115.05,94.55 115.05,94.44 115.31,94.18 115.31,94.07 115.14,93.91 115.04,93.91 114.78,94.17 114.67,94.17 113.96,93.46 113.96,90.2 112.58,88.82 112.58,84.38 112.5,84.31 112.14,84.31 112.07,84.23 112.07,84 112.14,83.93 112.5,83.93 112.58,83.85 112.58,83.62 112.5,83.54 112.14,83.54 112.07,83.47 112.07,83.24 112.14,83.16 112.5,83.16 112.58,83.09 112.58,82.86 112.5,82.78 112.14,82.78 112.07,82.71 112.07,82.48 112.14,82.4 112.5,82.4 112.58,82.33 112.58,82.1 112.5,82.02 112.14,82.02 112.07,81.94 112.07,81.72 112.14,81.64 112.5,81.64 112.58,81.56 112.58,81.2 104.72,73.34 101.04,73.34 99.71,72.01 98.81,72.01 98.73,71.93 98.73,71.41 98.66,71.34 98.43,71.34 98.35,71.41 98.35,71.93 98.28,72.01 98.05,72.01 97.97,71.93 97.97,71.41 97.9,71.34 97.67,71.34 97.59,71.41 97.59,71.93 97.51,72.01 97.29,72.01 97.21,71.93 97.21,71.41 97.13,71.34 96.91,71.34 96.83,71.41 96.83,71.93 96.75,72.01 96,72.01 v1(95.58,71.59)
  BOTTOM w0.114: U9001.BP22 140.07,115.43 v1(139.74,115.1) ; v1(95.58,71.59) 95.58,73.07 95.03,73.62 89.96,73.62 87.78,71.44 87.26,71.44 86.23,70.41 CON400.22
CFG_RCOMP: length 3.6
  BOTTOM w0.114: R9310.1 136.48,117.86 U9001.BT25
CFLH4_CFLH6: length 5.1
  TOP w0.114: v3(273.17,29.79) 273.44,30.06 R6001.2
  BOTTOM w0.114: U6001.K11 272.13,29.23 272.61,29.23 v3(273.17,29.79) 273.23,29.74 v1(273.97,29.74) 274.29,29.74 274.86,30.32 274.98,30.32 R6003.2
CHA_DIMM0_SA0: length 6.1
  BOTTOM w0.254: JDIM1001.256 v1(179.35,45.43) 179.05,45.13 177.93,45.13 177.68,44.87 R1024.1 R1021.2
CHA_DIMM0_SA1: length 6.6
  BOTTOM w0.203: JDIM1001.260 180.35,47.43 181.03,46.75 182.58,46.75 182.96,46.37 v1(182.96,46.06) 182.96,45.68 182.51,45.23 R1023.1 R1020.2
CHA_DIMM0_SA2: length 5.8
  BOTTOM w0.254: R1019.2 R1022.1 158.88,44.72 158.66,44.94 158.01,44.94 157.63,45.32 v1(157.63,45.99) 157.63,46.19 156.85,46.97 JDIM1001.166
CHA_DIMM1_SA0: length 52.5
  TOP w0.114: v1(183.98,57.62) 183.55,57.62 182.79,58.38 179.77,58.38 179.35,57.97 JDIM1000.256
  IN4 w0.076: v1(170.28,23.32) 170.47,23.51 170.47,26.63 173.99,30.16 179.58,30.16 180.16,30.74 180.16,30.9 185.33,36.06 185.33,49.11 184.82,49.62 184.82,56.78 v1(183.98,57.62)
  BOTTOM w0.114: R1006.2 170.28,23.28 v1(170.28,23.32) 170.28,23.34 R1010.1
CHA_DIMM1_SA1: length 50.5
  TOP w0.114: v1(183.98,56.73) 183.67,56.73 182.53,57.88 180.75,57.88 180.35,57.48 JDIM1000.260
  IN4 w0.076: v1(183.98,56.73) 184.56,56.15 184.56,49.52 185.17,48.91 185.17,36.12 180.01,30.96 180.01,30.83 179.5,30.31 173.91,30.31 170.09,26.49 170.09,24.45 v1(168.97,23.33)
  BOTTOM w0.114: R1005.2 168.66,23.03 v1(168.97,23.33) 168.66,23.64 R1009.1
CHA_DIMM1_SA2: length 49.9
  TOP w0.254: v1(158.33,59.87) 158.01,59.87 156.85,58.71 JDIM1000.166
  IN3 w0.508: v1(158.33,59.87) 157.85,59.87 154.72,56.73 154.72,47.46 153.13,45.87 153.13,40.67 150.9,38.43 150.9,32.21 150.15,31.46 150.15,30.06 149.51,29.43 142.5,29.43 v1(140.49,27.42)
  BOTTOM w0.508: R1004.2 R1008.1 v1(140.49,27.42)
CHB_DIMM0_SA0: length 12.4
  BOTTOM w0.254: JDIM1002.256 179.35,33.24 179.74,33.62
  BOTTOM w0.508: R1029.2 R1036.1 177.44,27.65 v1(178.09,27.65) 178.72,27.65 181.01,29.94 181.01,33.24 180.63,33.62 179.74,33.62
CHB_DIMM0_SA1: length 9.3
  BOTTOM w0.254: JDIM1002.260 180.35,30.43 180.25,30.32
  BOTTOM w0.508: 180.25,30.32 178.34,28.41 v1(176.17,28.41) R1035.1 R1028.2
CHB_DIMM0_SA2: length 5.8
  BOTTOM w0.254: v1(157.08,29.68) 157.08,30.88 156.85,31.1 JDIM1002.166
  BOTTOM w0.508: R1027.2 R1034.1 156.5,28.54 157.08,29.12 v1(157.08,29.68)
CHB_DIMM1_SA0: length 35.6
  TOP w0.114: v1(182.79,37.73) 180.58,37.73 179.35,38.95 JDIM1003.256
  IN4 w0.076: v1(166.38,23.31) 166.38,23.61 167.7,24.93 168.54,24.93 168.69,25.08 168.69,29.17 168.18,29.68 168.18,31.08 169.58,32.48 180.13,32.48 183.6,35.94 183.6,36.92 v1(182.79,37.73)
  BOTTOM w0.114: R1047.2 166.38,23.61 v1(166.38,23.31) 166.38,23.05 R1050.1
CHB_DIMM1_SA1: length 34.1
  TOP w0.114: v1(182.79,39.64) 182.07,39.64 181.77,39.33 180.63,39.33 180.35,39.6 JDIM1003.260
  IN4 w0.076: v1(167.65,23.31) 167.65,24.2 168.05,24.6 168.76,24.6 169.07,24.91 169.07,31.08 170.21,32.22 180.09,32.22 183.75,35.88 183.75,38.67 v1(182.79,39.64)
  BOTTOM w0.114: R1049.1 v1(167.65,23.31) R1046.2
CHB_DIMM1_SA2: length 4.9
  TOP w0.254: JDIM1003.166 156.85,42.87 v1(157.51,43.52) 157.53,43.55 R1048.1 R1045.2
CK_XDP_N: length 198.1
  IN3 w0.089: v1(240.44,75.48) 240.44,75.76 240.57,75.89 240.57,76.58 239.85,77.29 237.06,77.29 235.14,75.38 229.4,75.38 228.87,74.85 228.87,73.35 228.61,73.08 228.61,72.28 228.47,72.14 227.5,72.14 225.89,73.75 225.89,75.14 223.35,77.68 219.63,77.68 218.94,78.37 211.06,78.37 210.37,79.06 173.59,79.06 166.64,72.11 117.34,72.11 113.87,68.65 109.59,68.65 108.98,68.03 99.94,68.03 97.55,65.64 93.38,65.64 91.12,63.38 83.68,63.38 82.43,62.14 78.4,62.14 76.59,60.33 76.59,60.14 v1(76.36,59.91)
  BOTTOM w0.102: v1(240.44,75.48) 240.29,75.63 240.29,75.81 240.54,76.06 241.31,76.06 242.27,75.1 242.27,74.83 242.52,74.58 242.52,74.19 U9002.Y3 ; v1(76.36,59.91) 76.61,60.16 76.61,60.26 76.03,60.85 76.03,65.02 77.01,66 80.39,66 81.38,66.99 81.38,67.23 81.23,67.37 CON400.42
CK_XDP_P: length 198.1
  IN3 w0.089: v1(76.99,59.91) 76.78,60.12 76.78,60.25 78.48,61.95 82.51,61.95 83.76,63.19 91.2,63.19 93.46,65.45 97.63,65.45 100.02,67.84 109.06,67.84 109.67,68.46 113.95,68.46 117.42,71.92 166.72,71.92 173.67,78.87 210.29,78.87 210.98,78.18 218.86,78.18 219.56,77.49 223.27,77.49 225.7,75.06 225.7,73.67 227.42,71.95 228.55,71.95 228.8,72.2 228.8,73 229.06,73.27 229.06,74.77 229.48,75.19 235.22,75.19 237.14,77.1 239.78,77.1 240.38,76.5 240.38,76.02 240.27,75.91 240.09,75.91 239.94,76.06 v1(239.94,76.16)
  BOTTOM w0.102: CON400.40 81.73,67.35 81.58,67.2 81.58,66.91 80.47,65.8 77.1,65.8 76.23,64.94 76.23,60.93 76.82,60.35 76.82,60.09 v1(76.99,59.91) ; U9002.Y4 242.94,74.2 242.73,74.41 242.73,74.66 242.47,74.92 242.47,75.19 241.39,76.27 240.46,76.27 240.36,76.16 v1(239.94,76.16)
CL_CLK: length 154.2
  TOP w0.114: v1(244.35,83.38) 244.56,83.58 v1(244.56,84.27)
  IN1 w0.076: v1(321.58,47.77) 322.09,47.26 326.98,47.26 328.94,45.3 330.89,45.3 332.16,46.57 335.44,46.57 337.34,48.48 337.34,49.37 339.32,51.34 340.98,51.34 341.23,51.59 341.41,51.59 344.34,54.52 346.12,54.52 347.17,55.57 347.17,57.25 347.54,57.62 347.54,58.26 348.04,58.75 348.04,62.15 349.54,63.65 349.54,65.5 v1(349.16,65.88)
  IN2 w0.089: v1(321.58,47.77) 321.85,48.03 321.85,48.55 323.25,49.95 323.25,50.89 322.61,51.53 322.61,53.18 322.28,53.51 321.34,53.51 321.06,53.79 320.22,53.79 319.01,55 318.46,55 317.23,56.23 313.72,56.23 312.71,57.24 308.79,57.24 308.24,56.68 304.91,56.68 304.55,56.33 300.03,56.33 298.66,57.7 294.73,57.7 293.87,58.55 293.8,58.55 292.67,59.68 291.19,59.68 289.51,61.36 289.51,61.73 285.64,65.6 283.21,65.6 281.77,67.04 281.77,67.59 277.64,71.72 276.84,71.72 275.72,72.85 275,72.85 273.31,74.54 271.62,74.54 271.18,74.98 271.18,75.64 267.69,79.13 267.69,79.48 262.88,84.28 262.53,84.28 261.96,84.86 260.71,84.86 260.37,84.51 259.9,84.51 258.57,85.84 258.29,85.84 257.69,86.43 255.28,86.43 254.42,85.57 248.89,85.57 248.5,85.96 247.89,85.96 247.52,85.59 245.94,85.59 244.61,84.27 v1(244.56,84.27)
  BOTTOM w0.114: v1(349.16,65.88) 349.03,66 349.03,67.15 348.49,67.68 U4100.42 ; v1(244.56,84.27) 244.68,84.27 245.45,83.5 245.45,81.96 246.08,81.32 246.08,80.97 247.32,79.74 U9002.AR2
CL_DATA: length 143.5
  IN1 w0.076: v1(349.16,65.24) 348.56,64.65 348.56,63.1 347.12,61.66 347.12,58.93 347.24,58.82 347.24,57.75 346.87,57.38 346.87,55.7 346,54.83 344.77,54.83 342.49,57.11 338.77,57.11 336.9,55.23 333.85,55.23 333.39,55.69 330.37,55.69 329.66,54.98 320.78,54.98 319.79,55.97 317.28,55.97 316.9,55.59 v1(316.39,55.59)
  IN2 w0.089: v1(316.39,55.59) 316.08,55.89 313.67,55.89 312.58,56.99 310.81,56.99 308.16,54.33 301.61,54.33 298.49,57.44 294.34,57.44 293.12,58.66 291.07,58.66 290.61,59.12 290.61,60.01 289.23,61.39 289.23,61.73 285.58,65.38 283.14,65.38 281.59,66.93 281.59,67.48 277.56,71.51 276.64,71.51 275.7,72.46 275.14,72.46 273.23,74.36 271.5,74.36 271,74.86 271,75.56 267.56,79 267.56,79 267.51,79.05 267.51,79.4 262.81,84.1 262.46,84.1 261.88,84.68 260.79,84.68 260.44,84.33 259.83,84.33 258.5,85.66 258.21,85.66 257.62,86.25 255.35,86.25 254.49,85.39 248.82,85.39 248.42,85.78 247.96,85.78 247.59,85.42 246.04,85.42 245.24,84.62 v1(245.24,84.29)
  BOTTOM w0.102: U9002.AT5 248.7,79.08 248.06,79.72 247.9,79.72 247.6,80.03 247.33,80.03
  BOTTOM w0.114: U4100.43 348.48,67.18 348.73,66.94 348.73,65.67 v1(349.16,65.24) ; 247.33,80.03 246.3,81.06 246.3,81.43 245.68,82.06 245.68,83.58 245.24,84.01 v1(245.24,84.29)
CL_RST: length 140.6
  IN1 w0.076: v1(316.77,53.91) 316.77,54.62 317.3,55.16 320.39,55.16 320.72,54.83 329.72,54.83 330.44,55.54 333.33,55.54 333.79,55.08 336.96,55.08 338.84,56.96 342.43,56.96 344.71,54.68 346.06,54.68 347.02,55.64 347.02,57.31 347.39,57.69 347.39,58.32 347.89,58.81 347.89,62.21 348.71,63.04 348.71,64.16 v1(349.16,64.61)
  IN2 w0.089: v1(316.77,53.91) 316.24,54.45 315.37,54.45 315.12,54.19 310.08,54.19 309.69,53.81 301.63,53.81 298.2,57.24 292.21,57.24 290.35,59.1 290.35,59.35 285.58,64.12 282.73,64.12 282.47,63.86 281.76,63.86 281.16,64.47 281.16,65.17 280.5,65.83 280.5,67.32 277.19,70.63 276.24,70.63 275.2,71.67 274.53,71.67 272.88,73.32 271.2,73.32 267.25,77.27 266.62,77.27 263.56,80.33 263.56,80.82 260.9,83.48 259.58,83.48 258.59,84.47 258.2,84.47 257.19,85.48 254.91,85.48 254.59,85.16 249.63,85.16 249.57,85.21 248.74,85.21 248.35,85.61 248.03,85.61 247.67,85.24 246.14,85.24 245.88,84.98 245.88,84.7 247.3,83.27 247.3,82.3 v1(247.09,82.09)
  BOTTOM w0.102: U9002.AU4 248.62,80.01 248.48,80.15 248.48,80.32 247.83,80.96 247.83,81.26 247.09,82.01 v1(247.09,82.09)
  BOTTOM w0.114: U4100.44 348.37,66.68 348.5,66.56 348.5,65.26 v1(349.16,64.61)
CLICKPAD_INT#: length 304.2
  TOP w0.114: v1(311.56,49.24) 311.56,48.01 310.86,47.3 310.86,44.2 306.36,39.69 306.36,36.13 305.45,35.23 305.45,32.99 v1(304.63,32.17) 302.29,29.83 302.29,28.52 v1(301.55,27.78)
  IN1 w0.076: v1(216.69,8.9) 217.86,7.74 225.47,7.74 226.05,8.32 233.66,8.32 234.42,9.08 236.71,9.08 237.22,9.59 237.98,9.59 238.61,8.96 240.28,8.96 241.01,8.23 243.81,8.23 244.56,7.48 246.46,7.48 247.31,6.64 247.32,6.64 247.35,6.61 249.23,6.61 249.45,6.82 249.45,7.19 250.98,8.73 254.31,8.73 255.2,7.84 257.32,7.84 258.6,9.12 260.1,9.12 261.11,8.12 262.52,8.12 263.25,8.85 272.05,8.85 279.85,16.66 279.85,18.55 286.16,24.86 286.16,25.36 286.72,25.92 289.19,25.92 290.3,27.04 300.81,27.04 v1(301.55,27.78)
  IN3 w0.089: v1(216.69,8.9) 216.52,8.73 204.79,8.73 197.14,16.37 184.52,16.37 184.31,16.16 184.3,16.16 177.12,8.98 v1(106.46,8.98)
  IN4 w0.076: v1(264.95,54.57) 265.34,54.19 267.6,54.19 267.85,53.94 271.52,53.94 271.84,53.61 275.98,53.61 277.34,52.26 277.69,52.26 277.87,52.07 279.33,52.07 279.72,51.68 280.1,51.68 284.28,51.68 284.55,51.41 285.04,50.92 290.2,50.92 291.24,49.87 292.37,49.87 292.59,49.66 294.04,49.66 294.97,50.59 298.48,50.59 298.91,51.02 300.92,51.02 301.81,50.13 303.54,50.13 303.54,50.13 303.71,50.13 303.71,50.13 304.04,50.13 304.68,49.49 306.37,49.49 307.05,48.82 307.26,48.6 310.93,48.6 v1(311.56,49.24)
  BOTTOM w0.102: 262.22,58.96 262.06,59.12 262.06,60.32 261.31,61.07 261.31,61.42 261.03,61.71 U9002.AK47
  BOTTOM w0.114: 262.22,58.96 262.22,58.19 263.86,56.56 263.86,56.12 264.74,55.24 264.74,54.79 v1(264.95,54.57) 265.29,54.24 R9208.2 ; v1(106.46,8.98) 106.48,8.96 CON6351.5
CLK_CPU_BCLKN: length 105.5
  IN1 w0.076: v1(235.24,64.43) 234.58,65.09 234.58,68.32 234.89,68.64 234.89,71.26 234.78,71.38 234.78,72.81 231.97,75.62 231.97,79.18 228.55,82.6 226.99,82.6 225.08,84.51 221.09,84.51 220.71,84.89 212.03,84.89 211.44,85.48 207.43,85.48 205.7,87.21 202.98,87.21 201.16,89.04 199.23,89.04 198.47,89.79 198.47,90.18 195.99,92.66 195.99,93.58 193.99,95.59 193.99,96.61 188.38,102.21 186.48,102.21 185.67,103.02 185.67,104.8 184.56,105.9 184.56,122.14 182.63,124.07 182.63,124.34 v1(182.45,124.52)
  BOTTOM w0.079: v1(182.45,124.52) 182.68,124.29 182.68,124.03 181.76,123.1 179.55,123.1 U9001.A32
  BOTTOM w0.102: U9002.C8 238.22,66.13 238.13,66.04 238.13,65.57 237.14,64.58 235.41,64.58 235.25,64.43 v1(235.24,64.43)
CLK_CPU_BCLKP: length 105.5
  IN1 w0.076: v1(235.21,65.09) 235.11,64.99 234.91,64.99 234.74,65.16 234.74,68.25 235.06,68.57 235.06,71.33 234.94,71.45 234.94,72.88 232.14,75.69 232.14,79.25 228.62,82.77 227.06,82.77 225.15,84.67 221.16,84.67 220.78,85.05 212.1,85.05 211.51,85.64 207.5,85.64 205.76,87.38 203.05,87.38 201.22,89.2 199.3,89.2 198.64,89.86 198.64,90.25 196.16,92.73 196.16,93.65 194.15,95.66 194.15,96.67 188.45,102.38 186.54,102.38 185.83,103.09 185.83,104.87 184.73,105.97 184.73,122.21 182.8,124.14 182.8,124.36 182.96,124.52 v1(183.09,124.52)
  BOTTOM w0.079: U9001.B31 178.88,122.95 179.48,122.95 179.48,122.95 181.82,122.95 182.84,123.96 182.84,124.27 v1(183.09,124.52)
  BOTTOM w0.102: U9002.B8 237.93,66.17 237.93,65.65 237.06,64.78 235.49,64.78 235.21,65.06 v1(235.21,65.09)
CLK_DEBUG_KBC: length 4.8
  TOP w0.114: TP9009.1 261.4,72.55 260.83,71.98 260.52,71.98 259.89,71.35 259.26,71.35 v3(259.21,71.4)
  BOTTOM w0.114: U9002.BB34 260.5,71.34 259.28,71.34 v3(259.21,71.4)
CLK_DPLL_NSCCLKN: length 107
  IN1 w0.076: v1(184.37,124.52) 184.48,124.52 184.7,124.3 184.7,123.74 185.13,123.31 185.13,106.27 194.89,96.52 194.89,95.7 196.56,94.03 197.19,94.03 203.42,87.81 205.89,87.81 207.65,86.04 218.88,86.04 219.48,85.44 221.01,85.44 221.39,85.05 225.58,85.05 226.64,84 228.04,84 228.66,83.38 231.07,83.38 231.43,83.02 231.43,82.41 232.82,81.01 232.82,77.43 234.22,76.04 234.22,75.02 235.32,73.92 235.32,71.6 236.09,70.84 236.09,66.32 236.34,66.06 236.34,65.76 235.95,65.37 v1(235.87,65.37)
  BOTTOM w0.079: 183.6,123.41 183.59,123.41 183.56,123.39 183.33,123.39 182.61,122.67 179.14,122.67 178.97,122.5 177.19,122.5 177.09,122.59 177.09,122.73 177.18,122.81 U9001.D31
  BOTTOM w0.102: v1(184.37,124.52) 184.63,124.26 184.63,123.94 184.1,123.41 183.6,123.41 ; U9002.C6 237.77,66.83 237.14,66.2 236.76,66.2 235.93,65.37 v1(235.87,65.37)

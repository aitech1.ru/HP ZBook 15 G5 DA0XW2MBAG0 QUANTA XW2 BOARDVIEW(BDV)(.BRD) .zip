# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PP_DETECT#_R: length 2
  BOTTOM w0.114: Q3006.3 v1(52.1,47.21) 52.1,46.96 R3079.1
PP_HVA: length 309
  TOP w0.114: v3(268.24,28.57) 268.89,29.22 268.89,31.82 269.13,32.06 269.13,33.61 269.39,33.86 R3002.2 270.54,33.86 270.8,34.13 271.46,34.13 v1(272.6,35.27)
  IN2 w0.089: v1(209.56,11.01) 209.87,11.01 210.95,9.94 225.19,9.94 226.87,8.26 235.66,8.26 237.77,6.16 238.9,6.16 239.7,6.96 242.44,6.96 244,5.39 246.33,5.39 246.99,6.06 249.08,6.06 249.75,5.39 250.54,5.39 251.82,6.66 261.7,6.66 262.27,6.09 266.73,6.09 267.65,7.01 267.65,8.73 267.32,9.06 267.32,13.12 268.54,14.34 268.54,14.67 267.88,15.33 267.88,18.13 268.94,19.2 268.94,19.89 268.43,20.39 268.43,21.04 269.4,22 269.4,23.2 270.42,24.23 271.94,24.23 272.45,24.74 272.45,30.19 272.17,30.47 272.17,33.34 272.6,33.77 v1(272.6,35.27)
  IN4 w0.076: v1(209.56,11.01) 209.18,10.63 208.31,10.63 207.78,11.17 207.11,11.17 205.77,12.5 205.77,14.7 203.13,17.34 187.23,17.34 176.28,6.39 114.82,6.39 112.15,9.05 109.02,9.05 99.98,18.09 99.98,19.52 97.67,21.83 97.67,38.13 91.33,44.47 91.33,46.77 89.05,49.05 76.32,49.05 73.16,45.89 73.16,45.07 71.36,43.27 70.89,43.27 68.73,45.43 60.36,45.43 59.09,46.7 58.83,46.7 57.18,48.35 57.18,48.6 56.17,49.62 52,49.62 v1(50.95,50.68)
  BOTTOM w0.114: R3081.1 51.14,50.87 v1(50.95,50.68) ; U6001.H6 v3(268.24,28.57)
PP_HVA_R: length 2.4
  BOTTOM w0.114: CON3000.28 51.93,52.91 v1(51.47,52.44) 51.14,52.11 R3081.2
PRIVACY_LED#: length 54.3
  TOP w0.114: v1(243.11,42.89) 242.86,43.14 241.71,43.14 240.95,43.91 R18075.1 240.76,43.52 240.44,43.21 Q9038.5
  IN1 w0.076: v1(270.54,21.12) 270.54,20.13 269.44,19.03 267.48,19.03 267.07,18.62 265.63,18.62 264.29,19.95 262.4,19.95 261.45,20.9 261.45,23.07 260.61,23.91 260.61,24.67 258.07,27.22 257.47,27.22 255.47,29.22 254.07,29.22 252.38,30.91 250.3,30.91 v1(249.94,31.27)
  BOTTOM w0.114: U6001.A9 270.52,21.15 v1(270.54,21.12) 270.99,20.67 R6230.2 ; v1(243.11,42.89) 243.62,42.38 243.87,42.38 244.25,42 244.25,41.68 242.54,39.97 242.54,38.81 243.49,37.86 243.49,36.26 244.57,35.18 247.66,35.18 248.48,34.37 248.48,32.94 249.94,31.48 v1(249.94,31.27)
PRIVACY_LED#_R: length 8.4
  TOP w0.114: R6819.1 237.01,49.24 237.65,48.6 237.65,48.22 237.85,48.02 R17966.1 238.15,47.84 238.48,47.51 239.2,47.51 239.94,46.78 v1(239.94,44.92) 239.98,44.88 R18075.2 239.94,43.87 Q9038.6
PROC_SEL#: length 9.2
  BOTTOM w0.114: R9317.1 v1(132.49,98.22)
  BOTTOM w0.254: 139.63,99.5 140.01,99.88 140.16,99.88 140.67,100.39 U9001.BN1
  BOTTOM w0.508: R9317.1 R9319.2 138.35,98.22 139.63,99.5
PROCPWRGD: length 364.8
  TOP w0.114: v1(242.27,76.93) 242.27,76.27 245.14,73.4 245.14,72.31 244.11,71.28 244.11,70.62 244.25,70.48 244.25,69.69 243.36,68.8 243.36,66.38 242.6,65.62 238.41,65.62 237.65,64.86 236.76,64.86 236.41,64.51 236.41,63.9 236.44,63.87 236.44,61.74 236.42,61.72 236.42,60.48 235.11,59.17 232.76,59.17 231.49,57.9 231.49,37.95 232.62,36.82 232.62,32.28 226.84,26.51 221.06,26.51 220.87,26.51 212.33,17.97 206.41,17.97 204.06,15.63 204.06,14.26 v1(203.87,14.06) ; v1(136.94,121.75) 136.53,121.75 TP9002.1
  IN1 w0.076: v1(80.17,59.91) 80.8,59.91 82.11,58.6 82.11,58.43 82.09,58.41 82.09,58.1 82.4,57.79 83.85,57.79 84.39,58.32 84.39,60.15 83.67,60.86 83.67,62.55 85,63.87 85,67.17 87.61,69.78 87.61,70.48 91.37,74.23 92.11,74.23 93.85,75.97 94.42,75.97 96.34,77.89 99.78,77.89 102.67,80.78 102.67,82.27 105.37,84.97 105.37,89.07 106.61,90.32 106.61,90.8 108.11,92.3 108.11,93.58 109.46,94.93 109.46,97.22 118.4,106.16 118.4,110.19 123.2,114.99 123.97,114.99 124.28,115.29 124.28,116.09 125.25,117.07 129.19,117.07 129.97,117.85 133.11,117.85 136.94,121.67 v1(136.94,121.75) ; v1(100.21,28.53) 99.35,27.67 99.35,20.13 100.55,18.92 101.09,18.92 102.7,17.31 103.66,17.31 104.93,16.04 106.78,16.04 112.42,10.4 177.25,10.4 183.06,16.21 197.14,16.21 201.03,12.31 204.12,12.31 204.5,12.69 204.5,12.79 204.25,13.04 204.25,13.68 v1(203.87,14.06)
  BOTTOM w0.102: U9002.AE3 243.89,75.83 242.81,76.91 242.28,76.91 v1(242.27,76.93)
  BOTTOM w0.114: v1(136.94,121.75) 136.94,122.19 137.31,122.56 U9001.BT31 ; v1(100.21,28.53) 99.57,29.18 99.57,37.2 94.65,42.12 94.65,43.89 93.71,44.82 93.71,47.03 89.2,51.54 88.16,51.54 87.03,52.67 87.03,53.18 86.2,54 83.41,54 80.17,57.24 v1(80.17,59.91)
PS8331_1P5V_3V: length 41
  TOP w0.178: v1(61.37,67.53) 61.97,66.93 U3007.35
  TOP w0.196: 66.96,60.16 66.83,60.16 U3007.60
  TOP w0.254: v1(69.12,59.88) 68.84,59.88 68.56,60.16 66.96,60.16
  TOP w0.508: C3046.1 58.2,60.68 57.56,60.04 v1(57.56,59.7)
  IN3 w0.508: v1(66.45,70.32) 66.45,69.97 65.44,68.95 63.15,68.95 61.73,67.53 v1(61.37,67.53)
  IN4 w0.508: v1(66.45,70.32) 67.33,69.45 67.33,66.25 66.33,65.24 66.33,60.92 67.37,59.88 v1(69.12,59.88) ; v1(57.56,59.7) 57.56,62.83 56.62,63.77 56.62,65.57 58.58,67.53 v1(61.37,67.53)
  BOTTOM w0.381: R3052.1 66.97,69.93 66.63,70.27 66.5,70.27 v1(66.45,70.32)
  BOTTOM w0.508: C3044.1 C3045.1 R3053.1 68.63,59.88 v1(69.12,59.88)
PS8331_CEXT_1P5V:
  vias: v1(60.23,61.94)
PS8331_PC0__EDP: length 3.8
  TOP w0.114: U3007.38 61.88,65.73 61.79,65.83 61.04,65.83 60.62,66.25 R3066.2 60.61,66.64 59.77,65.8 v1(59.65,65.8)
PS8331_PC1__EDP: length 3.8
  TOP w0.114: R3065.2 64.93,57.25 v1(64.93,57.88) 64.93,58.26 64.58,58.61 64.58,59.55 64.73,59.7 U3007.55
PS8331_PD: length 12
  TOP w0.114: Q3004.2 56.9,60.87 56.98,60.8 56.98,59.1 v1(57.31,58.76) 57.44,58.64 Q3005.3 58.19,58.45 R3059.1 58.61,59.32 61.05,59.32 61.06,59.31 61.54,59.31 61.91,59.68 61.91,60.82 62.02,60.93 U3007.50
PS8331_PI0_EDP: length 3.1
  TOP w0.114: U3007.56 65.13,59.53 65.01,59.4 v1(65.01,59.15) 65.25,58.9 R3064.2 R3077.2
PS8331_REXT: length 4.7
  TOP w0.114: U3007.34 62.01,67.33 61.85,67.49 61.85,67.69 61.5,68.04 60.87,68.04 60.62,67.78 R3057.2 59.68,67.27 58.83,67.27 v1(58.58,67.53)
PS8409_DCIN_ENB: length 5.2
  BOTTOM w0.114: U12006.3 354.37,57.36 353.73,58 351.07,58 R18068.1
PS8409_EQ: length 3.3
  BOTTOM w0.114: U12006.5 354.91,58.16 354.74,58 354.24,58 353.74,58.5 R18070.1 352.35,58.5 R18069.1
PS8409_HDMI_HPD_R: length 35.5
  TOP w0.114: v1(358.55,85.18) VC3200.1 C3207.1
  IN3 w0.089: v3(359.3,62.57) 360.84,62.57 361.69,63.43 361.69,64.45 361.2,64.94 360.34,65.8 360.34,67.69 359.56,68.46 359.56,84.17 v1(358.55,85.18) 358.3,85.43 358.3,90.17 CON3200.19
  BOTTOM w0.114: U12006.21 v3(359.3,62.57)
PS8409_HDMI_ID: length 2.1
  BOTTOM w0.114: R18073.1 362.87,57.75 362.45,58.16 U12006.32
PS8409_I2C_ADDR: length 2.1
  BOTTOM w0.114: U12006.31 362.49,58.57 362.69,58.76 R18072.1
PS8409_PRE: length 2.1
  BOTTOM w0.114: U12006.27 362.36,60.16 362.74,59.78 R18071.1
PS8409_RST#: length 3.5
  BOTTOM w0.114: U12006.35 361.75,56.96 363,55.72 C12064.1 R18079.1
PS8461_1_CFG0: length 7.4
  BOTTOM w0.114: U500.28 318.76,56.66 v1(318.68,56.74) 318.17,57.25 318.17,57.37 R519.1 317.29,58.26 316.16,58.26 314.99,59.43 R518.1
PS8461_1_CFG1: length 2.8
  BOTTOM w0.114: R514.1 318.29,56.26 U500.27
PS8461_1_CFG2: length 4.1
  BOTTOM w0.114: R516.1 317.02,54.99 R515.1 318.04,56.01 319.74,56.01 319.89,55.86 U500.26
PS8461_1_CFG3: length 11.8
  BOTTOM w0.114: R513.1 313.24,59.61 314.81,58.04 314.81,57.01 315.88,55.93 315.88,54.95 316.49,54.35 317.13,54.35 317.41,54.07 318.04,54.07 v1(319.14,55.16) 319.43,55.46 U500.25
PS8461_1_CFG4: length 11.3
  BOTTOM w0.114: R524.1 R525.1 322.99,68.16 323.88,67.27 v1(323.88,65.39) 323.88,63.59 324.09,63.39 324.09,62.5 325.81,60.78 U500.46
PS8461_1_DP_CADET: length 1.5
  BOTTOM w0.114: R501.2 328.2,60.17 328.21,60.16 U500.52
PS8461_1_I2C_ADDR: length 12.8
  IN3 w0.089: v1(327.81,53.43) 327.81,52.85 329.69,50.97 334.3,50.97 v1(334.52,50.74)
  BOTTOM w0.114: TP512.1 333.96,49.48 R511.1 334.68,50.05 334.52,50.21 v1(334.52,50.74) 335.18,51.39 R512.1 ; U500.6 v1(327.81,53.43)
PS8461_1_IN1_EQ0: length 11
  BOTTOM w0.114: U500.40 323.41,59.88 323.37,59.91 323.37,60.07 320.96,62.49 319.73,62.49 319.18,63.03 319.18,63.39 318.36,64.22 R509.2 318.8,64.73 v1(318.8,66) 318.29,66.5 R508.2
PS8461_1_IN1_EQ1: length 10.5
  BOTTOM w0.114: U500.41 323.81,59.96 321.05,62.71 320.19,62.71 v1(319.63,63.27) 319.31,63.59 R507.2 319.82,64.73 319.82,66 319.31,66.5 R506.2
PS8461_1_IN2_EQ0: length 12.6
  BOTTOM w0.114: R503.2 v1(316.26,66.13) 316.26,65.88 315.84,65.45 315.84,64.64 R505.2 316.89,63.59 317.84,63.59 317.92,63.51 318.42,63.51 318.73,63.21 318.73,62.78 319.51,61.99 320.73,61.99 321.07,61.65 321.07,60.78 321.66,60.19 322.33,60.19 322.61,59.91 U500.38
PS8461_1_IN2_EQ1: length 12
  BOTTOM w0.114: R502.2 317.28,66.38 v1(317.53,66.13) 317.74,65.93 317.74,64.67 R504.2 317.68,63.82 317.94,63.82 318.01,63.74 318.51,63.74 318.95,63.3 318.95,62.87 319.61,62.22 320.83,62.22 321.3,61.76 321.3,60.87 321.76,60.42 322.49,60.42 323.01,59.89 U500.39
PS8461_1_SW: length 14.4
  IN3 w0.089: v1(326.61,53.43) 326.83,53.43 329.47,50.79 332.29,50.79 332.82,50.26 334.85,50.26 v1(335.16,50.56)
  BOTTOM w0.114: v1(326.61,53.43) U500.9 ; R510.1 336.25,48.74 336.52,49.01 R517.1 336.52,50.19 v1(336.35,50.36) 336.15,50.56 v1(335.16,50.56)
PS8461_2_CFG0: length 5.7
  BOTTOM w0.114: R546.1 340.55,49.49 340.17,49.11 v1(339.76,49.11) 339.76,48.6 339.88,48.48 339.88,47.83 R547.1 340.39,46.29 340.57,46.11 U501.28
PS8461_2_CFG1: length 2.8
  BOTTOM w0.114: R540.1 340.12,46.58 340.12,45.45 340.17,45.39 U501.27
PS8461_2_CFG2: length 5.4
  BOTTOM w0.114: R541.1 337.61,48.36 337.85,48.12 337.85,46.67 337.94,46.59 R543.1 339.1,46.59 v1(339.17,46.52) 339.17,45.92 339.77,45.31 U501.26
PS8461_2_CFG3: length 6
  BOTTOM w0.114: U501.25 339.37,45.36 338.56,46.17 337.52,46.17 v1(337.22,46.47) 336.95,46.74 336.92,46.74 336.6,47.05 335.98,47.05 335.74,47.29 334.96,47.29 R539.1
PS8461_2_CFG4: length 7.8
  BOTTOM w0.114: R549.1 R550.1 349.18,40.36 349.1,40.27 348.55,40.27 348.37,40.1 347.96,40.1 347.5,39.64 345.68,39.64 345.37,39.33 v1(345.12,39.33) 345.07,39.33 344.96,39.44 U501.46
PS8461_2_DP_CADET: length 3
  BOTTOM w0.114: R526.2 v1(345.22,36.79) 344.97,37.04 U501.52
PS8461_2_I2C_ADDR: length 7.1
  BOTTOM w0.114: U501.6 337.08,37.44 336.3,36.67 TP513.1 335.7,36.67 R538.1 334.76,36.59 332.52,36.59 332.33,36.4 R537.1
PS8461_2_IN1_EQ0: length 12.7
  BOTTOM w0.114: U501.40 343.66,41.84 344.46,42.64 344.46,43.59 345.47,44.61 345.47,44.85 345.6,44.97 349.55,44.97 R534.2 349.98,44.46 R535.2 350.46,44.84 351.13,44.84 351.31,44.65 351.31,43.63 v1(351.16,43.47)
PS8461_2_IN1_EQ1: length 7
  BOTTOM w0.114: R532.2 347.52,44.06 346.45,44.06 R533.2 345.73,44.54 344.89,43.7 v1(344.89,43.02) 344.89,42.66 343.67,41.44 U501.41
PS8461_2_IN2_EQ0: length 5.9
  BOTTOM w0.114: U501.38 343.7,42.64 343.95,42.89 343.95,44.46 344.41,44.92 344.69,44.92 345.45,45.68 R530.2 345.97,46.68 R529.2
PS8461_2_IN2_EQ1: length 9.8
  BOTTOM w0.114: R527.2 348.77,47.08 349.03,46.83 349.03,46.18 R528.2 348.05,45.2 345.29,45.2 v1(344.58,44.49) 344.2,44.11 344.2,42.76 343.68,42.24 U501.39
PS8461_2_SW: length 5.9
  BOTTOM w0.114: U501.9 v1(337.09,38.64) 337.05,38.68 335.72,38.68 R536.1 334.69,38.7 333.64,38.7 333.23,38.29 R545.1
PS_FBVDD_PGOOD: length 138.2
  IN3 w0.089: v1(234.39,147.63) 232.65,149.38 232.65,151.96 231.78,152.82 231.6,152.82 229.68,154.74 203.48,154.74 202.5,153.76 198.98,153.76 196.8,151.58 194.06,151.58 193.47,150.99 191.9,150.99 190.75,149.84 190.75,140.97 190.54,140.76 190.54,140 190.89,139.65 190.89,137.39 189.39,135.89 189.39,130.55 188.93,130.09 188.93,125.87 189.65,125.16 189.65,124.39 187.53,122.27 186.26,122.27 185.44,121.45 185.44,105.26 186.37,104.33 186.5,104.33 189.16,101.67 189.16,98.02 191.93,95.25 191.93,92.55 194.85,89.63 196.36,89.63 v1(196.49,89.76)
  BOTTOM w0.114: U2004.1 199.36,91.62 D2008.2 v1(196.49,89.76) 196.3,89.57 196.3,89.45 195.99,89.14 195.99,88.07 197.74,86.32 199.04,86.32 199.68,86.96 200.52,86.96 200.84,86.64 200.84,86.5 201.18,86.16 202.31,86.16 202.6,86.45 202.6,86.96 203.07,87.43 U2007.2
  BOTTOM w0.254: v1(234.39,147.63) 234.59,147.63 PR8003.1
PS_PEXVDD_PGOOD: length 32.1
  TOP w0.114: PR9506.1 204.64,80.32 PR9505.2 205.47,81.15 205.47,84.88 v1(206.41,85.82)
  IN4 w0.076: v1(206.41,85.82) 207.12,85.1 209.01,85.1 209.67,84.44 219.61,84.44 220.1,83.96 222.66,83.96 v1(222.71,83.9)
  BOTTOM w0.114: v1(222.71,83.9) 222.71,84.15 222.16,84.7 222.03,84.7 221.99,84.74 221.95,84.74 221.85,84.84 221.85,86.48 221.52,86.81 U2005.2 221.52,88.24 R2093.1 ; U2006.2 206.76,87.31 206.53,87.09 206.53,85.94 v1(206.41,85.82)
PSI: length 133.8
  TOP w0.114: v1(218.37,102.94) 218.75,102.56 218.75,100.74 218.6,100.59 218.6,99.63 219.72,98.51 219.72,97.02 220.25,96.48 R2043.2
  IN1 w0.076: v1(227.01,31.43) 227.06,31.49 227.06,32.53 228.62,34.09 228.62,50.93 227.61,51.93 222.73,51.93 220.31,49.51 215.24,49.51 v1(214.79,49.97)
  IN2 w0.089: v1(227.01,31.43) 228.86,31.43 229.62,32.2 230.84,32.2 232.44,33.8 232.44,35.35 233.08,35.98 233.97,35.98 234.47,36.49 234.47,37.74 234.4,37.81 234.4,59.63 234.15,59.87 234.15,60.47 234.29,60.61 234.29,63.14 233.57,63.86 233.57,67.64 232.52,68.69 232.52,70.49 230.7,72.31 230.7,74.92 230.14,75.48 229.48,75.48 228.65,76.31 228.65,78.88 227.6,79.93 226.61,79.93 226.33,80.2 226.33,82.17 224.94,83.57 224.53,83.57 223.37,84.73 221.95,84.73 220.96,85.71 220.96,87.79 220.96,87.79 220.96,87.89 220.03,88.81 219.94,88.81 219.94,88.81 219.03,88.81 217.56,90.29 217.56,94.37 216.44,95.49 216.44,96.67 217.33,97.56 217.33,98.77 217.94,99.38 217.94,102.51 v1(218.37,102.94)
  BOTTOM w0.102: v1(218.37,102.94) 218.78,103.35 U2000.M7
  BOTTOM w0.254: PR9013.1 214.29,50.47 v1(214.79,49.97)
PSR_OFF#: length 314.2
  TOP w0.114: v1(52.25,58.64) 51.72,59.17 51.72,60.03 51.87,60.19 R18005.1 51.02,60.38 50.62,60.78 50.62,61.19 50.2,61.61 50.2,62.57 50.32,62.7 51.75,62.7 52.1,63.05 52.1,63.69 R18024.1 52.17,64.22 52.75,64.79 52.75,65.23 52.15,65.83 v1(51.44,65.83) 51.11,65.83 50.76,65.47 R18004.1
  IN2 w0.089: v1(52.25,58.64) 52.71,59.09 53.81,59.09 55.23,57.67 60.2,57.67 60.97,58.43 67.07,58.43 68.91,60.27 69.93,60.27 71.05,59.15 72.75,59.15 73.7,58.2 78.03,58.2 80.34,55.89 83.43,55.89 84.4,54.92 86.39,54.92 87.22,54.08 88.66,54.08 90.9,51.84 93.77,51.84 96.33,49.29 96.33,47.17 102.75,40.75 102.75,31.1 104.6,29.25 104.6,26.84 106.08,25.36 115.6,25.36 116.12,25.88 169.08,25.88 169.82,26.62 178.73,26.62 179.53,25.82 189.54,25.82 190.09,26.37 205.59,26.37 206.08,25.89 212.89,25.89 213.87,26.88 217.3,26.88 221.05,30.62 230.49,30.62 232.83,32.96 233.94,32.96 235.92,34.93 235.92,37.7 236.38,38.16 236.38,57.65 236.99,58.27 236.99,60.75 236.41,61.32 236.41,63.29 236.7,63.58 237.19,63.58 238.06,64.46 238.06,65.97 237.27,66.77 236.66,66.77 236.38,67.05 236.38,70.45 235.74,71.09 235.74,73.73 234.65,74.82 233.61,74.82 232.43,76 231.84,76 230.84,77 230.84,80.74 229.09,82.49 229.09,84.11 228.35,84.85 228.35,85.31 228.91,85.87 230.82,85.87 232.59,84.09 236.3,84.09 237.65,82.74 242.33,82.74 242.94,82.13 243.67,82.13 244.05,82.51 245.27,82.51 246.16,83.4 246.67,83.4 247.05,83.02 247.05,82.6 246.61,82.16 246.61,80.81 247.17,80.25 247.92,80.25 248.83,79.33 248.83,79.08 249.14,78.77 249.14,78.41 249.36,78.2 249.71,78.2 250.66,79.14 v1(250.67,79.14)
  BOTTOM w0.102: U9002.AV7 250.26,78.74 v1(250.67,79.14)
PSR_OFF#_R: length 17.1
  TOP w0.114: Q9046.6 54.89,59.78 54.63,60.03 53.78,60.03 53.43,60.38 R18002.1 52.89,60.06 52.61,59.78 v1(52.15,59.78)
  IN2 w0.089: v1(52.15,59.78) 52.15,59.64 50.96,58.44 48.01,58.44 46.72,59.73 v1(46.72,59.81)
  BOTTOM w0.114: CON3000.35 48.43,54.86 46.92,56.37 46.92,56.78 46.72,56.98 v1(46.72,59.81)
PVADPTR: length 58.7
  TOP w0.508: v1(255.18,15.2) 254.96,14.98 PC11000.1 254.16,14.31 253.99,14.15 PD11001.2 ; PR12034.2 224.19,12.6 224.19,7.84 224.95,7.08 v1(226.47,7.08) ; PR11035.1 244.18,6.62 v1(244,6.44) 244,5.81 244.9,4.9 250,4.9 252.41,7.3 252.41,10.71 252.36,10.76 ; v1(254.41,13.53) 254.66,13.28 PC11001.2 254.66,12.27 253.6,11.22 253.14,10.76 252.36,10.76 ; 252.36,10.76 251.56,10.76 PR11009.2
  IN1 w0.508: v1(244,6.44) 244.01,6.45 244.01,7.06 243.49,7.58 240.57,7.58 239.81,8.35 236.25,8.35 235.62,7.71 227.11,7.71 v1(226.47,7.08)
  IN3 w0.508: v1(335.24,145.56) 335.24,146.17 336.61,147.54 v1(337.7,147.54)
  BOTTOM w0.356: v1(337.7,147.54) 338.18,148.02 PQ10017.1 ; v1(335.24,145.56) 335.24,145.94 335.4,146.1 335.61,146.1 335.96,146.45 PQ10018.1
  BOTTOM w0.508: PR12000.1 258.39,23.25 v1(258.63,23.48)
  vias: v1(304.65,26.48) v1(332.52,139.54) v4(254.03,22.57) v4(254.03,21.3) v4(254.41,21.93) v4(254.79,22.57) v4(254.79,21.3) v4(255.18,21.93) v4(255.56,22.57) v4(255.56,21.3) v4(255.94,21.93) v4(304.32,20.92) v4(304.32,19.65) v4(304.71,20.28) v4(305.09,20.92) v4(305.09,19.65) v4(305.47,20.28) v4(305.85,20.92) v4(305.85,19.65) v4(306.23,20.28) v4(306.61,20.92) v4(306.61,19.65) v4(306.99,20.28) v4(328.94,85.31) v4(329.32,85.94) v4(329.7,86.58) v4(329.7,85.31) v4(330.11,87.21) v4(330.08,85.94) v4(330.49,143.73) v4(330.49,142.97) v4(330.49,142.2) v4(330.49,141.44) v4(330.49,140.68) v4(330.49,139.92) v4(330.49,87.85) v4(330.49,86.58) v4(330.92,88.56) v4(330.87,87.21) v4(331.12,143.35) v4(331.12,142.58) v4(331.12,141.82) v4(331.12,141.06) v4(331.12,140.3) v4(331.12,139.54)
PVCORE_PG: length 446.3
  TOP w0.127: PR20060.1 183.67,158.56 183.96,158.84 v1(184.31,158.84) ; v1(188.37,158.33) 188.4,158.36 PR20062.1 ; v1(124.47,153) 125.14,152.33 PR19017.2 PR19021.2 ; PR20063.1 185.99,158.86 v1(186.01,158.84) ; v1(276.4,63.08) 276.4,64.04 277.18,64.82 277.18,66.1 277.51,66.42 277.51,67.04 U9000.2 275.37,69.18 274.54,69.18 R9129.1 ; PR20061.1 181.64,155.03 v1(181.39,154.78)
  IN1 w0.127: v1(124.47,153) 124.97,153.51 132.99,153.51 133.41,153.93 135.03,153.93 139.06,157.95 139.06,160.37 140.06,161.37 174.17,161.37 180.77,154.78 v1(181.39,154.78) 181.82,155.21 181.82,155.62 180.85,156.58 180.85,157.67 182.02,158.84 v1(184.31,158.84) 184.82,159.35 185.5,159.35 v1(186.01,158.84) 186.77,159.6 187.33,159.6 188.37,158.56 v1(188.37,158.33)
  IN2 w0.127: v1(276.4,63.08) 276.4,63.06 275.27,61.93 275.27,61.64 275.13,61.5 275.13,61.01 272.91,58.8 272.91,55.73 273.46,55.18 273.46,54.78 269.02,50.34 269.02,49.14 267.88,48 267.88,46.57 266.78,45.48 266.78,41.55 266.14,40.91 265.61,40.91 264.88,40.18 264.38,40.18 263.01,38.8 263.01,38.5 261.23,36.73 261.23,36.6 260.82,36.19 259.47,36.19 258.98,35.7 255.84,35.7 252,31.87 252,31.46 247.68,27.14 239.39,27.14 237.78,25.53 235.38,25.53 233.06,23.2 223.55,23.2 219.36,19.01 217.08,19.01 213.39,15.33 207.04,15.33 204.26,18.11 196.62,18.11 196.05,17.54 183.03,17.54 180.18,14.7 164.12,14.7 162.47,16.35 108.62,16.35 107.87,15.6 106.08,15.6 105.99,15.69 104.65,15.69 v1(104.34,15.38)
  IN3 w0.127: v1(104.17,88.13) 104.17,89.63 104.8,90.26 104.8,90.95 106.72,92.87 106.72,93.57 108.24,95.09 108.24,96.37 107.83,96.78 107.83,98.24 109.04,99.45 110.49,99.45 115.51,104.47 115.51,108.83 112.86,111.48 112.86,117.16 114.12,118.42 114.12,121.99 115.09,122.96 115.09,128.43 118.75,132.08 118.75,138.74 119.57,139.57 119.57,143.76 124.47,148.66 v1(124.47,153)
  BOTTOM w0.127: v1(104.34,15.38) 104.34,16.21 105.21,17.08 105.21,18.16 105.93,18.88 105.93,24.55 105.09,25.39 105.09,46.21 105.84,46.96 105.84,86.18 104.17,87.85 v1(104.17,88.13)
PVT_CS#: length 50.2
  TOP w0.114: v1(300.01,42.51) 300.01,42.53 299.6,42.94 298.8,42.94 298.4,42.55 296.6,42.55 296.49,42.44 292.89,42.44 292.59,42.74 291.78,42.74 291.16,43.35 288.29,43.35 286.85,44.79 280.7,44.79 279.81,43.91 279.81,42 278.07,40.26 278.07,34.42 277.78,34.13 276.96,34.13 276.59,33.76 275.74,33.76 274.58,32.6 274.1,32.6 273.67,32.17 272.27,32.17 v1(271.69,31.59)
  BOTTOM w0.114: v1(271.69,31.59) 271.5,31.4 271.5,30.52 271.17,30.19 U6001.L10 ; U6203.1 297.03,48.66 298.15,47.54 298.41,47.54 298.85,47.09 R6205.2 298.85,46.78 298.51,46.43 298.51,45.84 TP6207.1 298.91,45.38 299.9,44.39 299.9,42.61 v1(300.01,42.51)
PVT_HOLD: length 3.1
  BOTTOM w0.114: U6203.7 295.76,58.33 295.94,58.51 296.45,58.51 v1(296.78,58.84) 296.95,59.01 R6222.2
PVT_MOSI: length 44.3
  TOP w0.114: v1(294.84,59.2) 294.6,59.2 293.29,57.88 291.99,56.58 291.98,56.57 291.77,56.37 291.77,56.36 291.29,55.88 291.29,53.07 290.07,51.85 290.07,50.83 287.76,48.53 282.85,48.53 278.29,43.98 278.29,42.56 277.08,41.34 277.08,37.68 276.96,37.56 276.38,37.56 276.3,37.47 276.3,37.14 276.38,37.05 277.02,37.05 277.08,36.98 277.08,36.67 276.96,36.54 276.38,36.54 276.3,36.45 276.3,36.12 276.38,36.03 276.96,36.03 277.08,35.9 277.08,35.66 v1(276.69,35.27)
  BOTTOM w0.114: U6203.5 293.22,58.16 293.86,58.8 TP6205.1 294.14,59.2 v1(294.84,59.2) ; R6015.2 276.77,32.34 276.77,33.8 277.2,34.23 277.2,35.14 277.07,35.27 v1(276.69,35.27)
PVT_MOSI_L: length 4.1
  BOTTOM w0.114: R6015.1 274.81,31.84 v1(274,31.03) 273.54,30.57 273.34,30.57 272.47,29.7 U6001.K12
PVT_SCLK: length 41.3
  TOP w0.114: v1(295.5,59.2) 295.5,59.12 293.77,57.38 293.49,57.38 292.31,56.2 292.3,56.19 292.16,56.05 292.15,56.04 291.78,55.67 291.78,52.52 291.14,51.88 291.14,50.28 289.69,48.83 288.8,48.83 287.99,48.02 284.51,48.02 284.39,47.89 284.39,47.27 284.27,47.16 284,47.16 283.89,47.27 283.89,47.88 283.75,48.02 283.04,48.02 278.8,43.78 278.8,42.36 277.58,41.14 277.58,35.46 276.75,34.63 v1(276.69,34.63)
  BOTTOM w0.114: R6014.2 276.27,34.01 276.69,34.43 v1(276.69,34.63) ; U6203.6 294.49,58.16 295.5,59.17 v1(295.5,59.2)
PVT_SCLK_L: length 4.4
  BOTTOM w0.114: R6014.1 275.11,33.11 v1(274.35,32.35) 273.64,31.64 273.64,31.39 272.47,30.22 U6001.L12
PVT_SPI_MISO: length 42.7
  TOP w0.114: v1(299.37,42.51) 299.24,42.38 298.83,42.38 298.58,42.13 296.78,42.13 296.67,42.02 292.71,42.02 292.43,42.31 291.57,42.31 290.94,42.93 288.12,42.93 286.71,44.34 280.88,44.34 280.23,43.69 280.23,41.53 278.49,39.79 278.49,33.97 278.14,33.62 277.15,33.62 276.77,33.24 276,33.24 v1(275.75,32.98) 275.26,32.49 275.26,32.46 274.69,31.9 273.99,31.9 273.68,31.59 v1(273.21,31.59)
  BOTTOM w0.114: v1(299.37,42.51) v1(299.37,43.5) 299.37,44.22 297.99,45.6 297.99,46.04 R6212.1 ; v1(273.21,31.59) 273.21,31.46 272.59,30.84 U6001.M12
PVT_SPI_MISO_R: length 3.9
  BOTTOM w0.114: R6212.2 297.82,46.96 297.47,47.31 297.47,47.31 297.14,47.64 297.14,47.74 TP6206.1 296.35,48.17 295.76,48.76 U6203.2
PWM_EC_IN: length 19.9
  TOP w0.114: R909.1 254.74,33.63 R910.2 C859.2 257.17,33.63 v1(257.73,34.19)
  IN1 w0.076: v3(266.29,26.62) 266.29,27.07 264.73,28.64 262.82,28.64 262.34,29.12 262.34,31.28 263.52,32.46 263.52,32.83 263.24,33.11 261.98,33.11 261.49,33.61 258.32,33.61 v1(257.73,34.19)
  BOTTOM w0.102: U6001.F3 v3(266.29,26.62)
PWM_EC_OUT: length 247.7
  IN3 w0.089: v3(267.59,29.87) 266.89,30.57 266.53,30.57 263.96,33.14 263.06,33.14 262.79,32.86 253.84,32.86 253.53,32.55 251.77,32.55 250,30.77 239.18,30.77 233.37,24.96 216.03,24.96 213.01,21.93 206.04,21.93 205.46,21.35 197.05,21.35 196.86,21.16 182.06,21.16 178.81,17.91 175.46,17.91 174.1,16.55 143.84,16.55 142.33,18.06 107.44,18.06 104.09,21.41 102.92,21.41 99.64,24.68 99.64,40.8 94.47,45.97 94.47,46.62 90.79,50.31 89.71,50.31 89.59,50.42 66.56,50.42 64.69,48.55 58.76,48.55 57.68,49.63 57.04,49.63 v1(55.79,50.89)
  BOTTOM w0.114: U6001.K5 v3(267.59,29.87) ; R3014.1 56.3,50.5 55.91,50.89 v1(55.79,50.89) v1(55.79,51.6)
PWM_LED#: length 152
  TOP w0.114: v1(187.48,49.77) 188.14,49.77 188.62,50.25 Q6800.2
  IN3 w0.076: 269.02,29.05 269.16,28.9 271.16,28.9 v3(271.49,28.57)
  IN3 w0.089: 269.02,29.05 268.89,29.17 268.89,29.94 268.08,30.75 266.6,30.75 263.96,33.39 263.05,33.39 262.71,33.05 253.78,33.05 253.56,32.83 251.19,32.83 250.5,32.15 248.95,32.15 247.8,31 239.16,31 233.29,25.14 215.96,25.14 213.01,22.19 206.04,22.19 205.41,21.55 197.01,21.55 196.79,21.34 181.99,21.34 178.74,18.09 173.73,18.09 v1(172.88,17.24)
  IN4 w0.076: v1(172.88,17.24) 172.63,17.49 172.63,23.84 173.9,25.11 173.9,26 176.69,28.79 179.85,28.79 182.01,30.95 183.61,30.95 184.14,31.48 184.68,31.48 185.81,32.61 185.81,44.39 187.87,46.45 187.87,49.39 v1(187.48,49.77)
  BOTTOM w0.114: U6001.H10 v3(271.49,28.57)
PWR_BTN_OUT#: length 86.3
  TOP w0.114: R6079.2 255.71,27.98 v1(255.96,27.73)
  IN2 w0.089: v1(252.38,36.13) 252.49,36.24 252.49,37 253.35,37.87 253.9,37.87 254.43,38.39 256.78,38.39 257.1,38.72 257.18,38.91 257.18,39.56 258.35,40.73 258.35,43.27 263.43,48.35 263.85,48.35 264.88,49.38 264.88,52.33 267.56,55.01 268.26,55.01 269.23,55.98 269.47,55.98 269.7,56.2 269.7,58.18 270.59,59.07 270.59,60.97 270.92,61.3 271.3,61.3 271.56,61.05 272.07,61.05 273.59,62.57 274.35,62.57 274.86,63.08 274.86,63.87 273.31,65.43 273.04,65.43 271.19,67.28 271.12,67.28 v1(270.21,68.18)
  IN3 w0.076: 270.52,24.35 270.52,25 v3(270.84,25.32)
  IN3 w0.089: 270.52,24.35 270.2,24.02 268.31,24.02 267.44,23.15 267.44,22.65 265.67,20.87 262.21,20.87 261.88,21.2 261.88,22.47 260.94,23.41 260.94,24.87 258.59,27.22 257.13,27.22 256.62,27.73 v1(255.96,27.73)
  BOTTOM w0.102: U9002.BE46 266.17,68.06 266.17,68.86 266.44,69.13 266.77,69.13 267.24,68.66 268.38,68.66 268.43,68.71 268.64,68.71
  BOTTOM w0.114: U6001.D9 v3(270.84,25.32) ; 268.64,68.71 269.13,68.71 269.66,68.18 v1(270.21,68.18) ; v1(252.38,36.13) 252.38,35.14 254.72,32.8 254.72,28.62 255.62,27.73 v1(255.96,27.73)
PWR_GATE#: length 39.6
  TOP w0.114: v1(109.25,97.75) 109.63,98.13 PR23020.2
  BOTTOM w0.114: v1(109.25,97.75) 109.94,97.75 111.62,99.43 113.85,99.43 114.84,100.42 115.22,100.42 117.56,102.76 117.56,103.65 118.88,104.97 120.48,104.97 121.98,103.47 123.35,103.47 125.13,101.69 125.13,92.37 124.52,91.76 123.47,91.76 122.53,90.82 121.67,90.82 120.84,89.99 R17908.1 R17911.2 121.58,88.13 Q9035.3
PWR_GOOD_3: length 240.5
  TOP w0.127: Q9002.5 190.53,94.55 190.66,94.67 190.66,95.18 191.45,95.98 192.56,95.98 193.07,95.47 v1(193.07,94.96)
  IN1 w0.127: v1(267.06,31.93) 266.91,31.93 266.35,32.5 266.35,34.61 265.02,35.94 264.42,35.94 264.25,35.77 263.42,35.77 262.9,36.29 258.65,36.29 257.92,37.02 257.61,37.02 256.7,37.02 253.75,39.97 252.15,39.97 249.68,42.44 249.68,42.98 249.03,43.63 247.45,43.63 247.17,43.35 246.41,43.35 241.92,47.84 v1(239.68,47.84)
  IN3 w0.127: v1(299.24,30.06) 298.41,30.9 295.23,30.9 294.69,30.36 292.12,30.36 291.19,31.28 289.16,31.28 287.38,29.5 285.38,29.5 284.14,28.27 282.65,28.27 282.1,28.82 278.77,28.82 278.16,29.43 274.05,29.43 272.78,30.7 269.27,30.7 268.69,31.28 267.72,31.28 v1(267.06,31.93) ; v1(191.62,148.67) 192.82,147.48 192.82,137.96 189.97,135.12 189.97,130.44 189.5,129.97 189.5,125.99 190.18,125.32 190.18,124.23 187.74,121.79 186.46,121.79 185.93,121.25 185.93,105.46 186.56,104.83 186.69,104.83 189.65,101.88 189.65,98.38 v1(193.07,94.96) 193.2,94.96 195.85,92.31 195.85,91.54 201.94,85.46 201.94,82.69 202.88,81.75 209.02,81.75 211.67,79.1 219.21,79.1 219.93,78.39 223.64,78.39 225.84,76.19 227.46,76.19 v1(227.69,76.42)
  IN4 w0.127: v1(226.22,68.04) 226.17,68.04 226.17,69.1 227.13,70.07 227.13,75.86 v1(227.69,76.42) ; v1(239.68,47.84) 238.93,47.84 233.33,53.44 233.33,54.19 231.74,55.78 231.74,60.33 234.27,62.86 v1(234.27,64.23)
  BOTTOM w0.114: U6001.M4 267.27,31.73 v1(267.06,31.93)
  BOTTOM w0.127: PR24003.1 187.62,154.01 187.73,154.01 R9284.1 188.43,154.33 188.43,154.2 189.02,153.61 R9283.1 189.02,153.22 189.44,152.8 189.44,151.73 191.04,150.13 191.04,149.26 v1(191.62,148.67) ; v1(299.24,30.06) 299.24,31.8 LED9002.1 298.85,33.46 PR25018.2 PR25020.1 PC25004.2 298.85,35.79 298.48,36.16 298.23,36.16 297.97,36.41 PU25000.1 ; v1(226.22,68.04) 226.54,67.72 230.01,67.72 233.5,64.23 v1(234.27,64.23)
PWR_LEVEL: length 15.4
  IN3 w0.089: v1(215.17,91.85) 215.35,92.03 215.35,96.03 216.95,97.63 216.95,99.12 v1(217.53,99.7)
  BOTTOM w0.102: U2000.N3 v1(217.53,99.7)
  BOTTOM w0.114: v1(215.17,91.85) 215.17,91.15 215.42,90.9 215.42,90.36 215.68,90.1 216.37,90.1 Q2014.1 216.39,91.18 216.39,92.22 R2085.2
PWRBTN#: length 11.3
  TOP w0.114: R6080.2 259.32,28.28 259.54,28.06 R6078.2 260.1,28.06 260.16,28 261.33,28 261.77,27.56 261.77,27.29 261.88,27.18 C6019.2 262.4,26.23 263.72,26.23 263.96,26.48 265.43,26.48 265.72,26.76 v1(265.72,27.01) 266.69,27.01 v3(267.59,27.92)
  BOTTOM w0.114: U6001.G5 v3(267.59,27.92)
R_A_SD#: length 4.4
  BOTTOM w0.114: U6001.L8 269.87,30.19 270.2,30.52 270.2,31.75 271.3,32.86 v1(271.3,32.98) 271.56,33.24 R6008.1
R_ADP_ID_CHK: length 7.2
  TOP w0.114: v3(270.84,29.87) 271.18,30.2 v1(271.18,30.82) 271.18,31.84 271.84,32.5 273.54,32.5 274.15,33.11 274.36,33.11 R6407.1
  BOTTOM w0.114: U6001.K9 v3(270.84,29.87)
R_CNV_RF_RESET#: length 17
  TOP w0.114: R4133.2 342.36,71.86 343.26,70.96 343.26,69.53 341.51,67.78 341.51,66.52 341.38,66.39 v3(341.38,64.66)
  BOTTOM w0.114: U4100.A42 341.39,64.66 v3(341.38,64.66) 341.46,64.58 341.87,64.58 342.39,64.06 U4100.58 342.39,63.09 342.78,62.7 342.78,62.22 342.27,61.71 v1(342.27,61.53) 342.27,61.43 342.7,61.01 344.75,61.01 344.85,60.92 R4120.1
R_LAN_DIS#: length 4.6
  TOP w0.114: v1(20.48,122.14) v1(21.24,122.14) 21.67,122.57 22.31,122.57 22.77,123.03 R4026.1
  BOTTOM w0.114: U4000.3 22.18,122.64 22.13,122.59 21.7,122.59 v1(21.24,122.14)
R_MODEM_CLKREQ: length 10.1
  TOP w0.114: v3(340.89,64.89) 340.89,66.22 341.28,66.61 341.28,67.28 R18066.1 341.28,67.77 341.28,67.96 342.58,69.26 342.58,69.79 342.16,70.2 R4134.2 341.58,70.2 v1(341.08,70.7)
  BOTTOM w0.114: U4100.59 341.89,64.11 341.72,64.28 341.2,64.28 340.89,64.59 v3(340.89,64.89) U4100.A43
R_SPK+:
  vias: v1(204.63,156.81)
R_SPK+_R:
  vias: v1(210.09,154.52) v1(210.34,153.63) v1(210.34,153)
R_SPK-:
  vias: v1(205.52,154.85)
R_SPK-_R:
  vias: v1(210.47,151.6) v1(212.5,152.11) v1(212.5,151.47)
R_WWAN_CONFIG_0: length 5.2
  BOTTOM w0.114: v1(332.52,5.6) 333.24,6.32 R4207.1 333.92,6.81 333.92,7.36 334.14,7.58 335.36,7.58 335.75,7.97 CON4201.21
REC_MUTE_LED: length 7.1
  TOP w0.114: R6811.1 237.01,51.27 237.65,50.64 237.65,50.26 237.85,50.05 R6808.2 238.15,50.2 238.49,50.54 v1(239.76,50.54) 239.76,50.33 240.17,49.93 240.17,49.46 240.9,48.72 Q6803.3
RECORD_MUTE_LED_CNTRL: length 137
  TOP w0.114: v1(243.11,44.54) 243.47,44.9 R6824.1 243.04,45.61 243.04,46.64 242.73,46.95 241.34,46.95 241.21,47.08 Q6803.2 ; U3600.11 338.43,14.38 338.31,14.5 338.31,15.29 338.8,15.78 338.8,17.52 338.53,17.79 338.41,17.9 338.41,19.05 338.76,19.4 338.76,20.05 338.8,20.08 338.8,20.51 338.49,20.82 338.16,20.82 335.64,23.34 335.64,25.71 336.18,26.24 336.18,28.82 338.59,31.23 339.3,31.23 v1(339.48,31.41)
  IN3 w0.089: v1(243.11,44.54) 244,44.54 244.46,44.08 244.46,41.85 247.76,38.55 249.38,38.55 250.2,39.36 251.37,39.36 252.18,38.55 256.45,38.55 256.81,38.18 257.97,38.18 260.24,40.45 261.94,40.45 262.32,40.07 268.43,40.07 270.52,37.99 276.22,37.99 277.41,36.79 283.3,36.79 283.71,36.38 286.45,36.38 286.93,35.9 295.18,35.9 295.54,36.26 296.71,36.26 298.65,34.31 300.56,34.31 302.9,31.97 304.6,31.97 305.43,31.15 307.83,31.15 310.18,28.79 321.34,28.79 322.1,28.03 328.26,28.03 328.79,28.56 330,28.56 331.76,30.32 331.76,31.21 333.16,32.61 335.22,32.61 336.12,31.71 336.63,31.71 337.32,31.03 339.1,31.03 v1(339.48,31.41)
REGN6V: length 6.2
  TOP w0.114: v1(244.18,16.91) 244.13,16.85 v1(244.13,16.09)
  TOP w0.508: v1(244.18,16.91) 244.84,16.91 245.31,17.37 PD11002.1
  BOTTOM w0.178: PU11000.24 246.16,15.15 245.73,15.58 245.73,15.92 245.5,16.14
  BOTTOM w0.508: v1(244.18,16.91) 244.65,16.44 PC11007.1 245.38,16.14 245.5,16.14
RIGHT+: length 2.5
  TOP w0.203: TP3603.1 334.3,7.95 335.03,8.68 U3600.27
RIGHT-: length 2
  TOP w0.203: U3600.25 334.13,9.48 TP3602.1
ROM_SCLK: length 16.8
  TOP w0.114: v1(222.52,101.32) 222.52,99.89 226.09,96.32 229.9,96.32 v1(231.81,94.42)
  BOTTOM w0.102: v1(222.52,101.32) 222.5,101.32 U2000.H4
  BOTTOM w0.114: R2028.1 231.55,92.27 231.55,93.29 R2026.2 232.06,94.17 v1(231.81,94.42)
ROM_SI: length 17.4
  TOP w0.114: v1(231.05,94.42) 229.42,96.05 225.93,96.05 222.1,99.88 222.1,101.78 v1(222.48,102.17)
  BOTTOM w0.114: v1(222.48,102.17) 222.48,102.1 U2000.H5 ; v1(231.05,94.42) R2022.2 230.54,93.29 230.54,92.27 R2025.1
ROM_SO: length 12.5
  TOP w0.114: R2029.1 222.62,92.99 222.62,93.72 222.79,93.89 222.79,94.59 R2027.2 223.3,95.22 v1(222.54,95.98) 222.28,96.24 222.28,98.52 220.89,99.91 220.89,102.15 v1(221.72,102.98)
  BOTTOM w0.127: v1(221.72,102.98) 221.72,103.04 U2000.H7
RSMRST#: length 276.3
  TOP w0.127: D6000.2 277.93,32.69 v1(277.51,33.11)
  IN1 w0.127: v1(277.51,33.11) 276.84,33.11 276.36,33.59 275.6,33.59 274.43,34.76 271.05,34.76 270.87,34.94 270.87,35.6 269.98,36.49 268.31,36.49 267.41,37.39 263.8,37.39 263.28,37.91 260.92,37.91 255.81,43.02 v1(255.81,43.14)
  IN2 w0.127: v1(100.21,27.2) 99.68,26.67 99.68,24.38 103.09,20.97 104.35,20.97 105.54,19.78 164.43,19.78 165.17,20.52 180.73,20.52 181.33,21.12 190.9,21.12 191.55,21.76 199.21,21.76 199.4,21.57 205.68,21.57 206.15,21.1 214.14,21.1 215.64,22.6 218.01,22.6 222.78,27.36 231.78,27.36 233.91,29.49 236.27,29.49 237.57,30.8 243.54,30.8 245.09,32.35 245.09,34.76 245.55,35.22 246.41,35.22 248.77,37.58 249.18,37.58 250.33,38.74 250.33,39.18 250.86,39.71 251.81,39.71 253.27,41.18 253.65,41.18 253.89,41.42 255.12,41.42 255.38,41.68 255.38,42.71 v1(255.81,43.14) 255.94,43.27 255.94,44.74 256.93,45.73 256.93,50.66 266.64,60.38 266.93,60.66 266.93,64.16 v1(266.98,64.21)
  BOTTOM w0.114: v1(266.98,64.21) 266.98,64.25 266.81,64.43 266.59,64.43 265.89,65.13 265.67,65.13 265.65,65.15 265.62,65.15 265.24,65.52 U9002.BA47
  BOTTOM w0.127: v1(277.51,33.11) 278.16,33.76 278.16,35.4 277.65,35.9 274.73,35.9 274.35,35.52 R6072.2 ; v1(100.21,27.2) 100.67,27.66 100.67,31.6 99.89,32.38 99.89,37.33 94.98,42.25 94.98,46.71 86.93,54.76 84.85,54.76 83.19,56.42 R404.2
RSMRST#_R: length 5.2
  BOTTOM w0.114: U6001.M10 271.25,30.93 271.25,31.79 272.32,32.86 v1(273.08,32.86) 273.46,33.24 R6077.1 273.84,33.65 274.06,33.86 R6072.1
RSMRST_PG: length 39.1
  TOP w0.127: R6073.2 276.52,29.81 277.2,29.81 277.93,30.55 D6000.1 277.93,31.13 278.92,32.11 278.92,39.58 v1(278.92,39.59) 280.66,41.32 280.66,43.4 281.15,43.9 286.55,43.9 287.94,42.51 290.61,42.51 291.24,41.87 292.26,41.87 292.54,41.59 295.89,41.59 v1(296.32,41.16)
  BOTTOM w0.127: v1(296.32,41.16) 296.7,41.54 PU25000.7 296.7,43.52 296.37,43.86 PR25021.2 295.69,45.22 295.69,45.73 PR25019.2
RSMRST_PG_R: length 6
  TOP w0.076: 272.32,28.77 271.8,28.25 271.16,28.25 v3(270.84,28.57)
  TOP w0.114: R6073.1 274.68,30.06 273.41,28.79 v1(272.7,28.79) 272.35,28.79 272.32,28.77
  BOTTOM w0.114: U6001.H9 v3(270.84,28.57)
RTC_REST1#_CL: length 2.6
  TOP w0.114: U6002.4 254.15,50.12 253.91,50.36 253.91,51.26 R6174.1 v1(252.89,51.4)
RTC_RST2_CL1: length 4.1
  TOP w0.114: v1(253.5,45.64) 252.9,46.24 R6504.2 R6175.2 254.05,48.62 U6002.1
RTC_RST2_CL2: length 4.8
  TOP w0.114: v1(249.83,50.76) Q6005.2 249.83,48.99 250.57,48.25 R6172.1 251.24,47.97 251.75,47.46 R6175.1
RTC_RST2_CL3: length 2.7
  TOP w0.114: R6504.1 251.57,46.45 v1(251.29,46.73) 250.81,47.21 R6173.1 250.57,46.72 250.6,46.7 Q6004.2
RTC_RST#: length 139.5
  TOP w0.127: v1(305.59,17.49) 305.47,17.36 J9000.1 306.58,14.7 C9188.1 307.41,15.25 R9131.2 ; Q6004.3 250.1,44.55 250.12,44.52 v1(250.12,43.96)
  IN2 w0.127: v1(250.12,43.96) 250.12,44.93 250.71,45.53 250.71,46.93 252.84,49.07 252.84,51.08 258.22,56.46 258.22,56.86 260.26,58.89 261.08,58.89 263.81,61.62 263.81,63.45 264.27,63.91 264.27,64.45 265.46,65.64 265.46,66.1 266,66.65 v1(266,67)
  IN3 w0.127: v1(281.57,15.46) 279.63,13.52 279.63,10.18 280.38,9.43 284.32,9.43 285.15,8.6 297.07,8.6 301.99,13.52 301.99,14.9 304.14,17.05 305.15,17.05 v1(305.59,17.49)
  IN4 w0.127: v1(256.84,24.67) 257.37,24.67 257.59,24.45 259.1,24.45 259.76,23.79 261.28,23.79 262.11,22.96 262.11,21.82 262.8,21.12 265.2,21.12 265.83,21.76 266.74,21.76 268.15,20.34 268.15,19.46 268.39,19.22 269.52,19.22 270.41,20.11 273.33,20.11 274.22,21 275.5,21 275.71,20.79 279.69,20.79 281.57,18.91 v1(281.57,15.46)
  BOTTOM w0.114: U9002.BE47 v1(266,67)
  BOTTOM w0.127: CON401.9 253.9,42.51 251.67,44.74 250.5,44.74 250.12,44.36 v1(250.12,43.96) 250.12,42.51 249.03,41.42 249.03,40.06 250.07,39.02 250.07,36.07 251.62,34.52 251.62,33.9 254.36,31.16 254.36,28.53 256.45,26.44 256.45,25.06 v1(256.84,24.67)
RTC_SR01#_CL: length 10.5
  TOP w0.114: U6002.3 255.56,49.62 255.97,49.21 R6176.2 255.97,48.25 255.18,47.47 v1(253.79,47.47) ; U6002.7 251.61,49.12 v1(251.11,49.62)
  IN1 w0.076: v1(253.79,47.47) 252.15,49.11 251.62,49.11 v1(251.11,49.62)
RTC_X1: length 7.8
  BOTTOM w0.114: U9002.BA49 265.92,65.41 266.68,64.64 267.29,64.64 267.33,64.61 270.03,64.61 R9175.1 270.49,64.37 270.49,64.21 C9214.2 271.15,63.55 271.15,62.49 Y9001.1
RTC_X2: length 8.9
  BOTTOM w0.114: Y9001.2 272.9,64.28 271.84,64.28 C9215.2 271.27,64.54 270.69,65.12 R9175.2 269.89,65.27 269.59,64.97 267.39,64.97 267.28,64.86 266.77,64.86 266.53,65.1 266.53,65.21 266.03,65.71 265.84,65.9 U9002.BA48
RTD3_CIO_PWR_EN: length 207.5
  TOP w0.114: v3(351.16,110.63) 351.16,110.3 351.01,110.15 R17979.2 350.7,109.95 350.83,109.82 351.19,109.82 351.42,109.59 U12002.2 ; v1(319.77,25.41) 319.82,25.41 320.33,25.92 320.33,31.33 319.44,32.22 319.44,35.52 318.73,36.24 318.73,38.44 320.33,40.05 320.86,40.05 321.55,40.73 321.55,43.73 321.17,44.1 321.17,46.14 v1(320.5,46.8) 320.32,46.99 320.13,46.99 319.29,47.83 319.29,48.49 319.33,48.53 319.33,48.75 320.96,50.38 320.96,53.13 321.34,53.51 321.34,58.51 321.82,58.99 v1(321.82,61) ; v1(282.33,54.17) 281.99,53.83 R9358.2
  IN1 w0.076: v3(351.16,110.63) 350.74,110.21 350.74,108.47 349.91,107.63 349.21,107.63 348.66,107.09 v1(345.73,107.09)
  IN2 w0.089: v1(319.77,25.41) 319.59,25.24 317.02,25.24 311.94,30.32 311.94,31.44 305.16,38.22 305.16,45.48 304.07,46.57 299.58,46.57 298.74,47.41 298.74,48.85 298.28,49.32 293.09,49.32 292.64,48.86 292.64,48.48 291.88,47.72 290.33,47.72 287.81,50.23 287.81,51.91 287.31,52.41 285.66,52.41 284.26,53.81 283.56,53.81 283.38,54 282.51,54 282.33,54.17 v1(282.33,54.17) ; v1(321.82,61) 321.82,61.2 319.54,63.49 319.54,65.22 319.7,65.38 319.7,65.79 318.9,66.59 318.9,68.65 326.04,75.78 327.01,75.78 332.95,81.73 332.95,82.51 335.93,85.5 335.93,90.05 337.47,91.58 337.47,94.71 338.52,95.76 338.52,99.52 340.27,101.28 340.27,105.1 342.26,107.09 v1(345.73,107.09)
  IN4 w0.076: v1(255.26,72.94) 256.14,72.06 256.14,71.64 257.61,70.17 257.61,69.75 260.42,66.94 260.42,65.97 261.4,64.99 261.4,64.73 261.27,64.61 261.27,64.1 262.03,63.34 263.25,63.34 267.19,59.4 268.08,59.4 268.81,58.67 274.11,58.67 274.14,58.64 276.3,56.48 279.36,56.48 281.68,54.17 v1(282.33,54.17)
  BOTTOM w0.102: v1(255.26,72.94) U9002.AU24
RTD3_CIO_PWR_EN_R: length 13.1
  TOP w0.076: 350.04,110.6 349.98,110.67 349.98,110.96 349.74,111.2 349.74,111.41 349.51,111.64 349.08,111.64 v3(348.77,111.95)
  TOP w0.114: R8020.2 353.99,108.28 R9589.2 353.53,107.58 352.66,107.58 352.56,107.68 351.84,107.68 351.44,107.28 v1(351.44,106.26) 351.06,106.26 350.77,106.56 U12002.4 350.77,107.45 350.43,107.79 350.43,108.86 350.25,109.03 R17979.1 350.25,110.39 350.04,110.6
  BOTTOM w0.102: v3(348.77,111.95) 348.43,112.3 U8001.T5
RTD3_WAKE#: length 6.1
  BOTTOM w0.102: U9002.BE19 256.59,77.13 257.05,77.59 257.23,77.59 258.1,78.46 258.1,80.43 258.48,80.8 258.48,81.88 TP9019.1
RTS5237_AV12: length 11.9
  IN4 w0.508: v1(32.7,64.12) 29.8,64.12 v1(27.97,65.95)
  BOTTOM w0.203: U7301.10 30.34,66.63 30.87,66.11 ; v1(27.97,65.95) 28.02,65.95 28.74,66.67 U7301.14
  BOTTOM w0.508: v1(32.7,64.12) 32.73,64.16 32.73,65.27 32.49,65.51 32.48,65.51 32.31,65.68 C7324.2 31.29,65.68 30.87,66.11
  vias: v1(27.34,65.75)
RTS5237_GPIO: length 2.3
  BOTTOM w0.114: R7307.1 29.88,73.04 v1(29.47,72.63) 29.14,72.31 U7301.28
RTS5237_RREF: length 4.3
  BOTTOM w0.203: 30.94,66.64 30.74,66.84 U7301.9
  BOTTOM w0.305: R7314.1 33.41,65.42 33.12,65.71 C7322.2 32.66,66.64 v1(31.5,66.64) 30.94,66.64
RUNSCI_EC#: length 8.8
  TOP w0.114: R18044.1 258.84,80.97 258.22,80.35 v1(258.22,79.85) 257.84,79.47 257.84,78.73 257.39,78.28 257.39,77.38 256.18,76.17 256.18,76.01 255.8,75.63 255.8,74.92 v1(255.73,74.85)
  BOTTOM w0.114: U9002.AV21 255.07,74.02 255.73,74.68 v1(255.73,74.85)
SATA_LED#: length 111.1
  TOP w0.114: R18047.1 317.98,44.3 317.56,43.88 317.56,41.21 317.38,41.04 v1(317.38,39.84) 317.38,37.28 316.31,36.2 316.31,31.99 316.84,31.46 318.51,31.46 319.1,30.87 319.1,30.52 319.03,30.45 319.03,25.01 319.56,24.47 319.56,22.95 318.8,22.19 318.8,19.47 318.55,19.22 318.55,16.65 317.76,15.86 D5100.2 317.76,14.75 319.86,12.64 319.86,12.11 319.73,11.97 319.73,10.44 319.74,10.43 319.74,10.07 319.73,10.07 319.73,9.42 319.74,9.41 319.74,9.06 320.88,7.91 D5101.2
  IN1 w0.076: v1(272.96,50.45) 273.81,49.6 276.16,49.6 278.97,46.78 281.89,46.78 283.42,45.25 284.01,45.25 284.46,44.81 287.5,44.81 288.91,43.4 295.15,43.4 295.9,42.65 298.6,42.65 299.12,42.13 306.99,42.13 307.27,41.85 311.72,41.85 313.72,39.84 v1(317.38,39.84)
  BOTTOM w0.102: 262.41,59.15 262.26,59.3 262.26,60.47 261.54,61.2 261.54,61.5 261.3,61.73 U9002.AK48
  BOTTOM w0.114: v1(272.96,50.45) 272.51,50.89 271.05,50.89 268.51,53.43 267.57,53.43 266.69,54.32 R9148.1 265.85,54.32 264.98,55.18 264.98,55.34 264.09,56.22 264.09,56.78 262.54,58.33 262.54,59.02 262.41,59.15
SATA_ODD_PWR_EN: length 7.9
  BOTTOM w0.114: U9002.AT49 264.19,63.48 265.59,62.08 265.59,60.97 268.36,58.19 268.71,58.19 TP9031.1
SATA_RXN3: length 249.5
  TOP w0.102: C630.1 60.78,55.17 60.71,55.23 60.71,55.44 61.12,55.84 61.37,55.84 62.2,56.67 62.97,56.67 v1(63.41,56.24)
  IN1 w0.076: v1(252.03,57.67) 251.48,58.22 250.82,58.22 250.53,57.93 250.53,57.16 247.36,54 241.65,54 240.77,53.13 236.56,53.13 234.8,54.88 231.6,54.88 230.09,53.37 230.09,32.48 226.57,28.96 215.34,28.96 211.58,25.2 207.97,25.2 205.78,27.38 142.94,27.38 142.43,27.89 112.09,27.89 106.93,33.05 106.93,36.2 105.4,37.72 105.4,45.05 104.05,46.41 102.38,46.41 95.37,53.41 95.37,57.81 93.82,59.36 91.61,59.36 89.95,57.7 89.95,56.5 88.94,55.49 84.49,55.49 84.07,55.91 79.88,55.91 77.44,58.35 75.78,58.35 74.6,59.53 70.26,59.53 69.34,58.6 66.37,58.6 64.26,56.49 63.66,56.49 v1(63.41,56.24)
  BOTTOM w0.102: v1(252.03,57.67) 252.11,57.74 U9002.L41
SATA_RXN3_HDD: length 3.7
  TOP w0.102: C631.2 60,45.17 59.88,45.05 59.88,44.48 v1(60.43,43.93) 59.88,43.38 59.88,42.95 CON5000.5
SATA_RXN3_R1: length 3.6
  TOP w0.102: U603.4 61.13,52.29 60.99,52.42 60.99,52.54 60.71,52.82 60.71,52.92 v1(61.27,53.48) 60.84,53.48 60.71,53.61 60.71,53.98 C630.2
SATA_RXN3_R2: length 3.1
  TOP w0.102: C631.1 59.85,46.38 59.85,46.57 59.98,46.7 60.67,46.7 60.98,47 60.98,47.32 61.13,47.47 U603.12
SATA_RXP3: length 249.5
  TOP w0.102: C632.1 60.44,55.17 60.51,55.23 60.51,55.52 61.03,56.05 61.29,56.05 62.11,56.87 v1(63.41,56.87)
  IN1 w0.076: v1(251.99,58.72) 251.99,58.58 251.8,58.38 250.75,58.38 250.36,58 250.36,57.23 247.3,54.17 241.58,54.17 240.7,53.29 236.63,53.29 234.87,55.04 231.54,55.04 229.93,53.44 229.93,32.55 226.5,29.12 215.27,29.12 211.51,25.36 208.04,25.36 205.85,27.55 143.01,27.55 142.5,28.06 112.16,28.06 107.09,33.12 107.09,36.27 105.57,37.79 105.57,45.12 104.11,46.57 102.44,46.57 95.54,53.48 95.54,57.88 93.89,59.53 91.54,59.53 89.78,57.77 89.78,56.57 88.87,55.65 84.56,55.65 84.14,56.07 79.95,56.07 77.51,58.51 75.85,58.51 74.67,59.69 70.19,59.69 69.27,58.76 66.3,58.76 64.19,56.66 63.62,56.66 v1(63.41,56.87)
  BOTTOM w0.102: U9002.M40 252,58.72 v1(251.99,58.72)
SATA_RXP3_HDD: length 3.7
  TOP w0.102: C633.2 59.54,45.17 59.68,45.02 59.68,44.47 v1(59.14,43.93) 59.68,43.39 59.68,43 CON5000.6
SATA_RXP3_R1: length 3.6
  TOP w0.102: U603.5 60.63,52.2 60.79,52.36 60.79,52.46 60.51,52.74 60.51,52.97 v1(60,53.48) 60.41,53.48 60.51,53.58 60.51,53.98 C632.2
SATA_RXP3_R2: length 3.1
  TOP w0.102: U603.11 60.63,47.45 60.78,47.3 60.78,47.09 60.59,46.9 59.89,46.9 59.65,46.66 59.65,46.33 C633.1
SATA_TXN3: length 239.9
  TOP w0.102: C628.1 62.58,55.17 62.74,55.34 62.74,55.55 63,55.8 64.56,55.8 v1(64.7,55.95)
  IN1 w0.076: v1(247.3,52.29) 247.47,52.46 247.79,52.46 248.07,52.74 248.07,53.3 247.81,53.56 241.86,53.56 241.01,52.71 236.32,52.71 234.54,54.49 231.94,54.49 230.47,53.02 230.47,37 231.13,36.34 231.13,32.97 226.73,28.56 216.34,28.56 212.5,24.73 207.87,24.73 205.6,27 182.03,27 181.45,26.42 179.71,26.42 179.13,27 138.22,27 137.71,27.51 111.88,27.51 106.19,33.2 106.19,35.92 105,37.12 105,44.73 103.79,45.94 102.31,45.94 94.14,54.1 91.48,54.1 90.48,55.11 84.17,55.11 83.77,55.51 79.74,55.51 77.46,57.79 75.79,57.79 74.45,59.13 70.7,59.13 68.59,57.03 65.83,57.03 65.14,56.34 65.14,55.87 65.02,55.74 64.9,55.74 v1(64.7,55.95)
  BOTTOM w0.102: U9002.B41 249.25,54.82 248.51,54.07 247.76,53.32 247.76,52.77 247.3,52.31 v1(247.3,52.29)
SATA_TXN3_HDD: length 4.6
  TOP w0.102: C629.2 62.54,44.76 62.54,44.46 62.44,44.36 v1(61.98,44.36) 62.54,43.8 62.54,43.55 62.82,43.27 63.39,43.27 63.46,43.19 63.46,42.97 CON5000.3
SATA_TXN3_R1: length 4.1
  TOP w0.102: C628.2 62.83,54.39 62.9,54.32 62.9,53.79 v1(62.57,53.46) 63.02,53.46 63.1,53.38 63.1,53.24 62.7,52.85 62.56,52.85 62.29,52.58 62.29,52.36 62.13,52.2 U603.2
SATA_TXN3_R2: length 3
  TOP w0.102: U603.14 62.13,46.92 v1(61.98,46.78) 62.47,46.78 62.57,46.67 62.57,46.04 62.47,45.95 C629.1
SATA_TXP3: length 239.8
  TOP w0.102: v1(64.7,55.31) 64.41,55.6 63.08,55.6 62.95,55.46 62.95,55.35 63.13,55.17 C625.1
  IN1 w0.076: v1(247.3,52.92) 247.3,52.87 247.55,52.62 247.72,52.62 247.9,52.81 247.9,53.23 247.74,53.39 241.93,53.39 241.08,52.54 236.25,52.54 234.47,54.32 232.01,54.32 230.64,52.95 230.64,37.07 231.3,36.41 231.3,32.9 226.8,28.4 216.41,28.4 212.57,24.56 207.8,24.56 205.53,26.84 182.1,26.84 181.52,26.25 179.64,26.25 179.06,26.84 138.15,26.84 137.64,27.35 111.81,27.35 106.03,33.13 106.03,35.85 104.83,37.05 104.83,44.66 103.72,45.77 102.24,45.77 94.07,53.94 91.42,53.94 90.41,54.94 84.11,54.94 83.7,55.35 79.67,55.35 77.4,57.62 75.72,57.62 74.38,58.97 70.77,58.97 68.66,56.86 65.89,56.86 65.31,56.28 65.31,55.8 65.09,55.58 64.8,55.58 64.7,55.48 v1(64.7,55.31)
  BOTTOM w0.102: U9002.C41 249.82,55.25 249.75,55.33 249.53,55.33 249.43,55.23 249.43,55.12 249.33,55.02 249.17,55.02 247.56,53.41 247.56,53.05 247.43,52.92 v1(247.3,52.92)
SATA_TXP3_HDD: length 4.5
  TOP w0.102: CON5000.2 63.67,42.97 63.67,43.28 63.47,43.47 62.91,43.47 62.74,43.63 62.74,43.83 v1(63.28,44.36) 62.85,44.36 62.74,44.46 62.74,44.76 C627.2
SATA_TXP3_R1: length 4.2
  TOP w0.102: U603.1 62.63,52.25 62.49,52.39 62.49,52.49 62.64,52.64 62.79,52.64 63.3,53.16 63.3,53.25 63.51,53.46 v1(63.84,53.46) 63.38,53.91 63.23,53.91 63.1,54.04 63.1,54.32 63.17,54.39 C625.2
SATA_TXP3_R2: length 3
  TOP w0.102: C627.1 62.89,45.95 62.77,46.06 62.77,46.65 62.9,46.78 v1(63.25,46.78) 62.63,47.4 U603.15
SC_PWRSV#: length 75.5
  TOP w0.114: v1(261.27,57.49) 260.81,57.95 260.18,57.95 259.92,58.21 v1(259.92,58.76) 259.74,58.95 259.74,60.48 259.12,61.1 259.12,62.19 258.18,63.13 v1(258.18,63.67)
  IN4 w0.076: v1(290.4,50.18) 290.38,50.18 289.82,50.74 285,50.74 284.22,51.53 280.16,51.53 279.66,51.53 279.27,51.92 277.81,51.92 277.62,52.11 277.25,52.11 275.9,53.46 271.69,53.46 271.41,53.74 267.8,53.74 267.54,53.99 264.99,53.99 264.15,54.83 263.79,54.83 261.27,57.34 v1(261.27,57.49)
  BOTTOM w0.114: R7303.1 284.99,23.97 285.25,24.22 288.58,24.22 289.21,24.86 289.72,24.86 290.65,25.79 290.65,27.19 293.12,29.66 293.12,30.56 292.65,31.03 292.33,31.03 291.75,31.61 291.75,35.46 291.37,35.83 291.37,38.45 291.1,38.71 289.27,40.55 289.27,40.78 289.27,45.04 290.22,45.99 290.22,47.18 290.61,47.56 290.61,49.95 290.4,50.15 v1(290.4,50.18) ; v1(258.18,63.67) 258.35,63.84 U9002.AH41
SCARDC6: length 16.9
  BOTTOM w0.114: CON7300.7 275.5,7.96 276.77,6.69 284.89,6.69 v1(287.61,9.41) 287.74,9.54 287.74,10.17 287.96,10.4 U7300.2
SCARDC8: length 17.1
  BOTTOM w0.114: U7300.1 288.61,12.38 287.88,13.11 287.62,13.11 287.31,13.43 287.31,14.06 286.93,14.44 279.66,14.44 278.99,13.77 v1(278.99,11.65) 278.99,10.82 279.5,10.31 CON7300.3
SCARDCLK: length 14.4
  BOTTOM w0.114: U7300.6 v1(285.36,9.87) 285.36,7.9 284.39,6.92 277.17,6.92 276.5,7.6 CON7300.6
SCARDDATA: length 12.7
  TOP w0.114: R7304.1 286.65,7.96 285.86,7.18 v1(285.02,7.18) 280.22,7.18 278.68,8.72 C7311.1 277.53,7.86 v1(277.5,7.84)
  BOTTOM w0.114: CON7300.5 v1(277.5,7.84)
SCARDFCB: length 14.2
  TOP w0.114: v1(287.31,10) 287.31,8.22 285.83,6.75 279.59,6.75 v1(278.5,7.84)
  BOTTOM w0.114: U7300.3 v1(287.31,10) ; CON7300.4 v1(278.5,7.84)
SCARDRST: length 17.3
  IN1 w0.076: v1(286.01,9.62) 286.01,8.45 284.77,7.2 277.4,7.2 274.86,9.74 v1(274.86,10.12)
  BOTTOM w0.114: CON7300.8 274.5,9.76 v1(274.86,10.12) ; U7300.5 v1(286.01,9.62)
SCL_BAT_CHG: length 344.4
  TOP w0.114: v1(244.87,6.14) 244.87,5.95 245.25,5.57 PR11019.2
  IN3 w0.089: v1(12.62,64.21) 12.62,61.66 13.24,61.04 13.24,55.46 22.32,46.38 28.23,46.38 29.31,45.3 32.42,45.3 33.69,44.03 48.17,44.03 48.42,43.78 65.56,43.78 66.26,44.48 69.31,44.48 70.52,45.68 72.5,45.68 75.2,48.39 88.75,48.39 88.86,48.27 89.64,48.27 92.08,45.84 92.08,43.62 97.61,38.09 97.61,20.36 98.2,19.77 98.2,18.64 103.14,13.7 103.14,7.75 103.63,7.27 176.14,7.27 176.93,7.27 185.06,15.4 196.72,15.4 204.44,7.68 219.21,7.68 220.82,9.3 221.07,9.54 222.23,9.54 222.79,8.98 v1(222.79,8.35) 223.43,8.35 223.81,7.96 232.13,7.96 232.49,8.32 235.87,8.32 236.1,8.55 239.08,8.55 239.92,7.71 243.66,7.71 244.46,6.92 244.46,6.55 v1(244.87,6.14) 245.28,6.54 249.31,6.54 249.68,6.91 254.64,6.91 256.81,9.09 256.81,11.07 257.26,11.52 262.73,11.52 263.93,10.33 271.38,10.33 276.21,15.15 276.21,19.9 274.25,21.86 274.25,22.21 v1(274.73,22.7)
  BOTTOM w0.114: PR12015.2 222.16,7.71 v1(222.79,8.35) 223.17,8.73 PD12000.3 ; U6001.C12 272.69,24.99 273.74,23.94 273.74,23.43 274.48,22.7 v1(274.73,22.7) R6036.2 ; Q3007.6 v1(12.62,64.21)
SD_CD#: length 14.7
  TOP w0.114: Q7300.2 39.2,78.96 39.4,78.75 39.4,77.76 39.2,77.56 v1(38.88,77.56) R7330.2 R7329.1 37.38,75.79 37.51,75.66 38.33,75.66 38.51,75.47 38.51,73.83 38.31,73.62 36.4,73.62 36.19,73.83 D7306.2 35.43,74.31 35.39,74.27 CON7301.18
SD_CD#_R: length 22
  TOP w0.114: R7330.1 35.34,78.82 Q7300.3 32.75,79.97 32.54,79.77 32.54,79.42 32.75,79.21 34.14,79.21 34.32,79.03 34.32,78.76 34.14,78.58 32.73,78.58 32.54,78.39 32.54,78.13 32.73,77.94 34.64,77.94 34.83,77.76 34.83,77.49 34.64,77.31 33.43,77.31 v1(32.42,76.29)
  BOTTOM w0.114: v1(32.42,76.29) 30.56,74.44 30.56,72.74 29.94,72.12 U7301.30
SD_CLK: length 34.9
  TOP w0.114: CON7301.5 35.32,65.77 v1(35.59,65.5) 35.84,65.25 D7305.2 36.23,66.24 EC9051.1
  IN1 w0.076: v1(35.59,65.5) 35.4,65.5 33.89,63.99 33.89,63.34 32.46,61.9 32.46,59.92 32.38,59.84 32.19,59.84 32.11,59.92 32.11,61.56 32.04,61.64 31.86,61.64 31.78,61.56 31.78,59.93 31.71,59.86 31.53,59.86 31.45,59.93 31.45,61.56 31.38,61.64 31.2,61.64 31.12,61.56 31.12,59.93 31.05,59.86 30.87,59.86 30.79,59.93 30.79,61.56 30.72,61.64 30.51,61.64 30.44,61.56 30.44,59.91 30.36,59.83 30.16,59.83 30.08,59.91 30.08,61.46 29.95,61.58 v1(28.71,61.58)
  BOTTOM w0.114: v1(28.71,61.58) 26.68,61.58 25.86,62.4 24.8,62.4 23.58,63.62 v1(23.58,64.99) 23.58,66.11 24.04,66.56 R7312.2

# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
MSOP8-4_9-65
  rect 0.406x1.448 smd: 1(-0.975,-2.325) 2(-0.325,-2.325) 3(0.325,-2.325) 4(0.975,-2.325) 5(0.975,2.325) 6(0.325,2.325) 7(-0.325,2.325) 8(-0.975,2.325)
NGFF-NFSB0-S6715-TP40-75P-KB
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.279x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NFSM0-S6710-TP58-75P-KM
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.279x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
PAD-MWS-VN-2NMP
  custom 7.485x7.485 smd: 1(0,0)
PAD-MWS-VN-3NMP
  custom 20x20 smd: 1(-0.051,-3.175)
PAD-MWS-VN-4NMP
  custom 8.88x8.88 smd: 1(0,0)
POWER-3_1X3_1-65-5P
  rect 0.406x0.406 smd: 1(1.55,-0.975) 2(1.55,-0.325) 3(1.55,0.325) 4(1.55,0.975)
  custom 0.625x0.625 smd: 5(-0.5,0)
POWER-5_2X5_55-1_27-5P
  rect 0.66x0.508 smd: 1(2.755,-1.905) 2(2.755,-0.635) 3(2.755,0.635) 4(2.755,1.905)
  custom 1.15x1.15 smd: 5(0,0)
POWER-5X6-1_27-10P
  rect 0.61x0.61 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75)
  rect 0.61x1.676 smd: 8(-1.905,2.21)
  rect 4.191x1.041 smd: 9(0,-1.535)
  custom 0.617x0.617 smd: 10(0,0)
PWQFN20-4X4-5-30P
  rect 0.279x0.838 smd: 1(-1,-1.975) 2(-0.5,-1.975) 3(0,-1.975) 4(0.5,-1.975) 5(1,-1.975) 11(1,1.975) 12(0.5,1.975) 13(0,1.975) 14(-0.5,1.975) 15(-1,1.975)
  rect 0.838x0.279 smd: 6(1.975,-1) 7(1.975,-0.5) 8(1.975,0) 9(1.975,0.5) 10(1.975,1) 16(-1.975,1) 17(-1.975,0.5) 18(-1.975,0) 19(-1.975,-0.5) 20(-1.975,-1)
  rect 2.692x2.692 smd: 21(0,0)
  round 0.61 hole 0.305: 22(0.9,-0.9) 23(0,-0.9) 24(-0.9,-0.9) 25(0.9,0) 26(0,0) 27(-0.9,0) 28(0.9,0.9) 29(0,0.9) 30(-0.9,0.9)
QFN12-1_25X2_1-4
  rect 0.203x0.889 smd: 1(-0.8,-0.775) 2(-0.4,-0.775) 3(0,-0.775) 4(0.4,-0.775) 5(0.8,-0.775) 7(0.8,0.775) 8(0.4,0.775) 9(0,0.775) 10(-0.4,0.775) 11(-0.8,0.775)
  rect 1.194x0.254 smd: 6(1.05,0) 12(-1.05,0)
QFN12-2X3-5
  rect 0.254x1.499 smd: 1(-0.5,-0.55) 2(0.5,-0.55) 7(0,0.55)
  rect 0.711x0.254 smd: 3(1.45,-0.75) 4(1.45,-0.25) 5(1.45,0.25) 6(1.45,0.75) 9(-1.45,0.75) 10(-1.45,0.25) 11(-1.45,-0.25) 12(-1.45,-0.75)
  rect 0.254x0.711 smd: 8(-0.5,0.95)
QFN12-3X2-5-13P
  rect 0.254x0.711 smd: 1(-0.25,-1.5) 2(0.25,-1.5) 7(0.25,1.5) 8(-0.25,1.5)
  rect 0.711x0.254 smd: 3(1,-0.75) 4(1,-0.25) 5(1,0.25) 6(1,0.75) 9(-1,0.75) 10(-1,0.25) 11(-1,-0.25) 12(-1,-0.75)
  rect 0.838x1.854 smd: 13(0,0)
QFN13-2X3-5
  rect 0.254x1.499 smd: 1(-0.5,-0.55) 2(0.5,-0.55) 8(0,0.55)
  rect 0.711x0.254 smd: 3(1.45,-0.75) 4(1.45,-0.25) 5(1.45,0.25) 6(1.45,0.75) 10(-1.45,0.75) 11(-1.45,0.25) 12(-1.45,-0.25) 13(-1.45,-0.75)
  rect 0.254x0.711 smd: 7(0.5,0.95) 9(-0.5,0.95)
QFN13-3X3-4
  rect 0.254x1.6 smd: 1(-0.55,-1) 2(-0.05,-1) 3(0.75,-1) 4(1.15,1) 5(0.35,1) 6(-0.55,1)
  custom 0.175x0.175 smd: 7(-1.45,1.2) 13(-1.45,-1.2)
  rect 0.711x0.203 smd: 8(-1.45,0.8) 9(-1.45,0.4) 10(-1.45,0) 11(-1.45,-0.4) 12(-1.45,-0.8)
QFN16-3X3-5-1H
  rect 0.254x2.108 smd: 1(-0.5,-0.75) 2(0.5,-0.75) 9(0,0.75)
  rect 0.711x0.254 smd: 3(1.45,-1.25) 4(1.45,-0.75) 5(1.45,-0.25) 6(1.45,0.25) 7(1.45,0.75) 8(1.45,1.25) 11(-1.45,1.25) 12(-1.45,0.75) 13(-1.45,0.25) 14(-1.45,-0.25) 15(-1.45,-0.75) 16(-1.45,-1.25)
  rect 0.254x0.889 smd: 10(-0.5,1.35)
QFN16-3X3-5-17P-G717R41U
  rect 0.254x0.711 smd: 1(-0.75,-1.5) 2(-0.25,-1.5) 3(0.25,-1.5) 4(0.75,-1.5) 9(0.75,1.5) 10(0.25,1.5) 11(-0.25,1.5) 12(-0.75,1.5)
  rect 0.711x0.254 smd: 5(1.5,-0.75) 6(1.5,-0.25) 7(1.5,0.25) 8(1.5,0.75) 13(-1.5,0.75) 14(-1.5,0.25) 15(-1.5,-0.25) 16(-1.5,-0.75)
  rect 1.6x1.6 smd: 17(0,0)
QFN16-3X3-5-17P-WM9001
  rect 0.305x0.965 smd: 1(-0.75,-1.612) 2(-0.25,-1.612) 3(0.25,-1.612) 4(0.75,-1.612) 9(0.75,1.612) 10(0.25,1.612) 11(-0.25,1.612) 12(-0.75,1.612)
  rect 0.965x0.305 smd: 5(1.612,-0.75) 6(1.612,-0.25) 7(1.612,0.25) 8(1.612,0.75) 13(-1.612,0.75) 14(-1.612,0.25) 15(-1.612,-0.25) 16(-1.612,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN16-4X4-65-17P-LM26420
  rect 0.305x0.61 smd: 1(-0.975,-1.9) 2(-0.325,-1.9) 3(0.325,-1.9) 4(0.975,-1.9) 9(0.975,1.9) 10(0.325,1.9) 11(-0.325,1.9) 12(-0.975,1.9)
  rect 0.61x0.305 smd: 5(1.9,-0.975) 6(1.9,-0.325) 7(1.9,0.325) 8(1.9,0.975) 13(-1.9,0.975) 14(-1.9,0.325) 15(-1.9,-0.325) 16(-1.9,-0.975)
  rect 2.591x2.591 smd: 17(0,0)
QFN20-4X4-5-21P-PS8527A
  custom 0.075x0.075 smd: 1(-1,-1.925) 2(-0.5,-1.925) 3(0,-1.925) 4(0.5,-1.925) 5(1,-1.925) 6(1.925,-1) 7(1.925,-0.5) 8(1.925,0) 9(1.925,0.5) 10(1.925,1) 11(1,1.925) 12(0.5,1.925) 13(0,1.925) 14(-0.5,1.925) 15(-1,1.925) 16(-1.925,1) 17(-1.925,0.5) 18(-1.925,0) 19(-1.925,-0.5) 20(-1.925,-1)
  rect 2.108x2.108 smd: 21(0,0)
QFN21-3X4-4-15P
  rect 1.6x0.254 smd: 1(-1,1.05) 2(-1,0.55) 3(-1,-0.25) 4(-1,-1.05) 12(1,-0.65) 13(1,0.15) 14(1,1.05)
  custom 0.2x0.2 smd: 5(0,-1.9)
  custom 0.175x0.175 smd: 15(1.2,1.9) 21(-1.2,1.9)
  rect 0.203x0.787 smd: 16(0.8,1.9) 17(0.4,1.9) 18(0,1.9) 19(-0.4,1.9) 20(-0.8,1.9)
QFN23-4X4-5-20P
  rect 0.254x0.457 smd: 1(-1.25,-1.825) 2(-0.75,-1.825) 3(-0.25,-1.825) 4(0.25,-1.825) 5(0.75,-1.825) 6(1.25,-1.825) 12(1.25,1.825) 13(0.75,1.825) 14(0.25,1.825) 15(-0.25,1.825) 16(-0.75,1.825) 17(-1.25,1.825)
  custom 0.346x0.346 smd: 7(1.825,-1.25)
  custom 0.249x0.249 smd: 10(1.825,0.75)
  rect 0.457x0.254 smd: 18(-1.825,1.25) 19(-1.825,0.75) 20(-1.825,0.25) 21(-1.825,-0.25) 22(-1.825,-0.75) 23(-1.825,-1.25)
QFN23-4X4-5-SMT
  rect 0.254x0.61 smd: 1(-1.25,-1.9) 2(-0.75,-1.9) 3(-0.25,-1.9) 4(0.25,-1.9) 5(0.75,-1.9) 6(1.25,-1.9) 12(1.25,1.9) 13(0.75,1.9) 14(0.25,1.9) 15(-0.25,1.9) 16(-0.75,1.9) 17(-1.25,1.9)
  rect 0.61x0.254 smd: 7(1.9,-1.25) 8(1.9,-0.75) 10(1.9,0.75) 18(-1.9,1.25) 19(-1.9,0.75) 20(-1.9,0.25) 21(-1.9,-0.25) 22(-1.9,-0.75) 23(-1.9,-1.25)
  custom 0.335x0.335 smd: 9(0.335,-0.67)
  custom 0.249x0.249 smd: 11(0.335,0.867)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.508 hole 0.254: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-5X5-5-33P-SLB9645VQ
  rect 0.254x0.711 smd: 1(-1.75,-2.4) 2(-1.25,-2.4) 3(-0.75,-2.4) 4(-0.25,-2.4) 5(0.25,-2.4) 6(0.75,-2.4) 7(1.25,-2.4) 8(1.75,-2.4) 17(1.75,2.4) 18(1.25,2.4) 19(0.75,2.4) 20(0.25,2.4) 21(-0.25,2.4) 22(-0.75,2.4) 23(-1.25,2.4) 24(-1.75,2.4)
  rect 0.711x0.254 smd: 9(2.4,-1.75) 10(2.4,-1.25) 11(2.4,-0.75) 12(2.4,-0.25) 13(2.4,0.25) 14(2.4,0.75) 15(2.4,1.25) 16(2.4,1.75) 25(-2.4,1.75) 26(-2.4,1.25) 27(-2.4,0.75) 28(-2.4,0.25) 29(-2.4,-0.25) 30(-2.4,-0.75) 31(-2.4,-1.25) 32(-2.4,-1.75)
  rect 3.607x3.607 smd: 33(0,0)
QFN48-6X6-4-49P-MP2939
  rect 0.203x0.711 smd: 1(-2.2,-2.95) 2(-1.8,-2.95) 3(-1.4,-2.95) 4(-1,-2.95) 5(-0.6,-2.95) 6(-0.2,-2.95) 7(0.2,-2.95) 8(0.6,-2.95) 9(1,-2.95) 10(1.4,-2.95) 11(1.8,-2.95) 12(2.2,-2.95) 25(2.2,2.95) 26(1.8,2.95) 27(1.4,2.95) 28(1,2.95) 29(0.6,2.95) 30(0.2,2.95) 31(-0.2,2.95) 32(-0.6,2.95) 33(-1,2.95) 34(-1.4,2.95) 35(-1.8,2.95) 36(-2.2,2.95)
  rect 0.711x0.203 smd: 13(2.95,-2.2) 14(2.95,-1.8) 15(2.95,-1.4) 16(2.95,-1) 17(2.95,-0.6) 18(2.95,-0.2) 19(2.95,0.2) 20(2.95,0.6) 21(2.95,1) 22(2.95,1.4) 23(2.95,1.8) 24(2.95,2.2) 37(-2.95,2.2) 38(-2.95,1.8) 39(-2.95,1.4) 40(-2.95,1) 41(-2.95,0.6) 42(-2.95,0.2) 43(-2.95,-0.2) 44(-2.95,-0.6) 45(-2.95,-1) 46(-2.95,-1.4) 47(-2.95,-1.8) 48(-2.95,-2.2)
  rect 4.699x4.699 smd: 49(0,0)
QFN48-6X6-4-49P-PS8409
  custom 0.05x0.05 smd: 1(-2.2,-2.975) 2(-1.8,-2.975) 3(-1.4,-2.975) 4(-1,-2.975) 5(-0.6,-2.975) 6(-0.2,-2.975) 7(0.2,-2.975) 8(0.6,-2.975) 9(1,-2.975) 10(1.4,-2.975) 11(1.8,-2.975) 12(2.2,-2.975) 13(2.975,-2.2) 14(2.975,-1.8) 15(2.975,-1.4) 16(2.975,-1) 17(2.975,-0.6) 18(2.975,-0.2) 19(2.975,0.2) 20(2.975,0.6) 21(2.975,1) 22(2.975,1.4) 23(2.975,1.8) 24(2.975,2.2) 25(2.2,2.975) 26(1.8,2.975) 27(1.4,2.975) 28(1,2.975) 29(0.6,2.975) 30(0.2,2.975) 31(-0.2,2.975) 32(-0.6,2.975) 33(-1,2.975) 34(-1.4,2.975) 35(-1.8,2.975) 36(-2.2,2.975) 37(-2.975,2.2) 38(-2.975,1.8) 39(-2.975,1.4) 40(-2.975,1) 41(-2.975,0.6) 42(-2.975,0.2) 43(-2.975,-0.2) 44(-2.975,-0.6) 45(-2.975,-1) 46(-2.975,-1.4) 47(-2.975,-1.8) 48(-2.975,-2.2)
  rect 4.496x4.496 smd: 49(0,0)
QFN48-6X6-4-49P-SLG8LV630
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 2.997x2.997 smd: 49(0,0)
QFN60-5X9-4-73P
  custom 0.05x0.05 smd: 1(-3.8,-2.475) 2(-3.4,-2.475) 3(-3,-2.475) 4(-2.6,-2.475) 5(-2.2,-2.475) 6(-1.8,-2.475) 7(-1.4,-2.475) 8(-1,-2.475) 9(-0.6,-2.475) 10(-0.2,-2.475) 11(0.2,-2.475) 12(0.6,-2.475) 13(1,-2.475) 14(1.4,-2.475) 15(1.8,-2.475) 16(2.2,-2.475) 17(2.6,-2.475) 18(3,-2.475) 19(3.4,-2.475) 20(3.8,-2.475) 21(4.475,-1.8) 22(4.475,-1.4) 23(4.475,-1) 24(4.475,-0.6) 25(4.475,-0.2) 26(4.475,0.2) 27(4.475,0.6) 28(4.475,1) 29(4.475,1.4) 30(4.475,1.8) 31(3.8,2.475) 32(3.4,2.475) 33(3,2.475) 34(2.6,2.475) 35(2.2,2.475) 36(1.8,2.475) 37(1.4,2.475) 38(1,2.475) 39(0.6,2.475) 40(0.2,2.475) 41(-0.2,2.475) 42(-0.6,2.475) 43(-1,2.475) 44(-1.4,2.475) 45(-1.8,2.475) 46(-2.2,2.475) 47(-2.6,2.475) 48(-3,2.475) 49(-3.4,2.475) 50(-3.8,2.475) 51(-4.475,1.8) 52(-4.475,1.4) 53(-4.475,1) 54(-4.475,0.6) 55(-4.475,0.2) 56(-4.475,-0.2) 57(-4.475,-0.6) 58(-4.475,-1) 59(-4.475,-1.4) 60(-4.475,-1.8)
  rect 7.01x2.997 smd: 61(0,0)
  round 0.508 hole 0.254: 62(-2.5,-0.5) 63(-1.5,-0.5) 64(-0.5,-0.5) 65(0.5,-0.5) 66(1.5,-0.5) 67(2.5,-0.5) 68(2.5,0.5) 69(1.5,0.5) 70(0.5,0.5) 71(-0.5,0.5) 72(-1.5,0.5) 73(-2.5,0.5)
QFN60-7X7-4-61P-0_85H
  rect 0.203x0.991 smd: 1(-2.8,-3.6) 2(-2.4,-3.6) 3(-2,-3.6) 4(-1.6,-3.6) 5(-1.2,-3.6) 6(-0.8,-3.6) 7(-0.4,-3.6) 8(0,-3.6) 9(0.4,-3.6) 10(0.8,-3.6) 11(1.2,-3.6) 12(1.6,-3.6) 13(2,-3.6) 14(2.4,-3.6) 15(2.8,-3.6) 31(2.8,3.6) 32(2.4,3.6) 33(2,3.6) 34(1.6,3.6) 35(1.2,3.6) 36(0.8,3.6) 37(0.4,3.6) 38(0,3.6) 39(-0.4,3.6) 40(-0.8,3.6) 41(-1.2,3.6) 42(-1.6,3.6) 43(-2,3.6) 44(-2.4,3.6) 45(-2.8,3.6)
  rect 0.991x0.203 smd: 16(3.6,-2.8) 17(3.6,-2.4) 18(3.6,-2) 19(3.6,-1.6) 20(3.6,-1.2) 21(3.6,-0.8) 22(3.6,-0.4) 23(3.6,0) 24(3.6,0.4) 25(3.6,0.8) 26(3.6,1.2) 27(3.6,1.6) 28(3.6,2) 29(3.6,2.4) 30(3.6,2.8) 46(-3.6,2.8) 47(-3.6,2.4) 48(-3.6,2) 49(-3.6,1.6) 50(-3.6,1.2) 51(-3.6,0.8) 52(-3.6,0.4) 53(-3.6,0) 54(-3.6,-0.4) 55(-3.6,-0.8) 56(-3.6,-1.2) 57(-3.6,-1.6) 58(-3.6,-2) 59(-3.6,-2.4) 60(-3.6,-2.8)
  rect 5.512x5.512 smd: 61(0,0)
QFN66-10X5-4-67P
  custom 0.05x0.05 smd: 1(-4.4,-2.475) 2(-4,-2.475) 3(-3.6,-2.475) 4(-3.2,-2.475) 5(-2.8,-2.475) 6(-2.4,-2.475) 7(-2,-2.475) 8(-1.6,-2.475) 9(-1.2,-2.475) 10(-0.8,-2.475) 11(-0.4,-2.475) 12(0,-2.475) 13(0.4,-2.475) 14(0.8,-2.475) 15(1.2,-2.475) 16(1.6,-2.475) 17(2,-2.475) 18(2.4,-2.475) 19(2.8,-2.475) 20(3.2,-2.475) 21(3.6,-2.475) 22(4,-2.475) 23(4.4,-2.475) 24(4.975,-1.8) 25(4.975,-1.4) 26(4.975,-1) 27(4.975,-0.6) 28(4.975,-0.2) 29(4.975,0.2) 30(4.975,0.6) 31(4.975,1) 32(4.975,1.4) 33(4.975,1.8) 34(4.4,2.475) 35(4,2.475) 36(3.6,2.475) 37(3.2,2.475) 38(2.8,2.475) 39(2.4,2.475) 40(2,2.475) 41(1.6,2.475) 42(1.2,2.475) 43(0.8,2.475) 44(0.4,2.475) 45(0,2.475) 46(-0.4,2.475) 47(-0.8,2.475) 48(-1.2,2.475) 49(-1.6,2.475) 50(-2,2.475) 51(-2.4,2.475) 52(-2.8,2.475) 53(-3.2,2.475) 54(-3.6,2.475) 55(-4,2.475) 56(-4.4,2.475) 57(-4.975,1.8) 58(-4.975,1.4) 59(-4.975,1) 60(-4.975,0.6) 61(-4.975,0.2) 62(-4.975,-0.2) 63(-4.975,-0.6) 64(-4.975,-1) 65(-4.975,-1.4) 66(-4.975,-1.8)
  rect 8.712x3.708 smd: 67(0,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
RJ45-2RJ1748-002111F-12P
  round 1.194 hole 0.889: 1(-3.57,3.3) 2(-2.55,4.4) 3(-1.53,3.3) 4(-0.51,4.4) 5(0.51,3.3) 6(1.53,4.4) 7(2.55,3.3) 8(3.57,4.4)
  round 1.295 hole 0.991: 9(7.075,4.275) 10(7.075,2.775) 11(-7.075,4.275) 12(-7.075,2.775)
  oval 0.991x2.388 hole 0.61x2.007: 13(-8.15,0) 14(8.15,0) 15(-8.15,-6.8) 16(8.15,-6.8)
RTC-53011-0020K-V09-2P
  round 1.194 hole 1.194 unplated: (0,8)
  round 0.787 hole 0.787 unplated: (0,-8)
  rect 2.007x3.988 smd: 1(14.5,0) 2(-15.6,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
SC70-2_1-65-5P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,-0.65)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SC70-2_1-65-6P-0_95H
  rect 0.508x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,0) 6(-0.95,-0.65)
SC70-2_1-65-6P-SN74AVC1T45
  rect 0.889x0.406 smd: 1(1.1,-0.65) 2(1.1,0) 3(1.1,0.65) 4(-1.1,0.65) 5(-1.1,0) 6(-1.1,-0.65)
SC88-2_1-65-6P
  rect 1.016x0.254 smd: 1(1.15,-0.65) 2(1.15,0) 3(1.15,0.65) 4(-1.15,0.65) 5(-1.15,0) 6(-1.15,-0.65)
SDCARD-5-531706004000-6-19P
  round 1.143 hole 1.143 unplated: (-9.95,-9.8)
  round 0.94 hole 0.94 unplated: (13.05,-9.8)
  rect 0.787x1.397 smd: 1(5.87,14.6) 2(3.37,14.6) 3(0.87,14.6) 4(-1.63,14.6) 5(-4.13,14.6) 6(-6.63,14.6) 7(-8.13,14.6) 8(-9.63,14.6) 9(8.37,14.6) 10(7.17,14.6) 11(4.67,14.6) 12(2.17,14.6) 13(9.53,14.6) 14(-0.33,14.6) 15(-2.83,14.6) 16(-5.33,14.6) 17(10.63,14.6) 18(-12.63,14.6) 19(-11.13,14.6)
  rect 2.108x2.489 smd: 20(14.65,-7.2) 21(-14.65,-7.2)
SHORT3720
  rect 3.759x1.537 smd: 1(0,1.008) 2(0,-1.008)
SHORT-SOLDERJUMPER-3
  custom 0.508x0.508 smd: 1(-1.016,0)
  custom 0.381x0.381 smd: 2(1.016,0)
SIMCARD-159-1000302600-10P-L
  round 0.889 hole 0.889 unplated: (4.94,13.72) (5.64,2.62)
  rect 0.508x1.245 smd: 1(-3.545,15.145) 2(-2.845,15.145) 3(-2.145,15.145) 4(-1.445,15.145) 5(-0.745,15.145) 6(-0.045,15.145) 7(0.655,15.145) 8(1.355,15.145) 9(2.055,15.145) 10(2.755,15.145)
  rect 0.889x1.397 smd: 11(5.41,15.22) 18(-4.7,15.22)
  rect 0.381x1.6 smd: 12(7.165,12.67)
  rect 0.381x1.499 smd: 13(7.165,5.82) 16(-7.165,5.82)
  rect 1.092x1.092 smd: 14(6.8,0) 15(-6.8,0)
  rect 0.381x1.245 smd: 17(-7.165,12.06)
SOIC8-6-1_27
  rect 0.533x1.753 smd: 1(-1.905,-2.73) 2(-0.635,-2.73) 3(0.635,-2.73) 4(1.905,-2.73) 5(1.905,2.73) 6(0.635,2.73) 7(-0.635,2.73) 8(-1.905,2.73)
SOLDERJUMPER-2
  custom 0.381x0.381 smd: 1(-1.016,0) 2(1.016,0)
SON8-3X3-65-7P
  rect 0.305x0.508 smd: 1(-0.975,-1.35) 2(-0.325,-1.35) 3(0.325,-1.35) 4(0.975,-1.35) 5(0.975,1.35)
  rect 1.6x0.508 smd: 8(-0.325,1.35)
  rect 2.388x1.6 smd: 9(0,0)
SON8-8X6-1_27-9P
  rect 0.508x1.397 smd: 1(-1.905,-3.9) 2(-0.635,-3.9) 3(0.635,-3.9) 4(1.905,-3.9) 5(1.905,3.9) 6(0.635,3.9) 7(-0.635,3.9) 8(-1.905,3.9)
  rect 4.293x3.404 smd: 9(0,0)
SON14-3X2-4-15P-SMT
  custom 0.05x0.05 smd: 1(-1.2,-1.076) 2(-0.8,-1.076) 3(-0.4,-1.076) 4(0,-1.076) 5(0.4,-1.076) 6(0.8,-1.076) 7(1.2,-1.076) 8(1.2,1.076) 9(0.8,1.076) 10(0.4,1.076) 11(0,1.076) 12(-0.4,1.076) 13(-0.8,1.076) 14(-1.2,1.076)
  rect 2.489x0.889 smd: 15(0,0)
SOP8-6-1_27-9P-G5795F11U
  rect 0.406x1.981 smd: 1(-1.905,-3.15) 2(-0.635,-3.15) 3(0.635,-3.15) 4(1.905,-3.15) 5(1.905,3.15) 6(0.635,3.15) 7(-0.635,3.15) 8(-1.905,3.15)
  rect 3.607x2.438 smd: 9(0,0)
SOT23-2_85-95-6P-1_4H
  rect 0.991x0.61 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,0) 6(-1.2,-0.95)
SOT23-5
  rect 1.016x0.711 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT236-2_9-95-6P
  rect 0.991x0.711 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,0) 6(-1.2,-0.95)
SOT323_213-2_1-1_3-2N7002W
  rect 0.787x0.61 smd: 1(0.8,0.65) 2(0.8,-0.65) 3(-0.8,0)
SOT323_213-2_1-1_3-3P
  rect 0.559x0.61 smd: 1(0.925,0.65) 2(0.925,-0.65) 3(-0.925,0)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT353-2_1-65-5P-1_1H
  rect 1.194x0.305 smd: 1(1.05,-0.65) 2(1.05,0) 3(1.05,0.65) 4(-1.05,0.65) 5(-1.05,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SOT363-2_1-65-6P-PJ4N3KDW
  rect 0.508x0.457 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,0) 6(-0.95,-0.65)
SOT523_213-1_6-1-0_6H
  rect 0.457x0.406 smd: 1(0.675,0.5) 2(0.675,-0.5) 3(-0.675,0)
SOT563-1_6-5-6P-PJX138K
  rect 0.457x0.305 smd: 1(0.675,-0.5) 2(0.675,0) 3(0.675,0.5) 4(-0.675,0.5) 5(-0.675,0) 6(-0.675,-0.5)
SPAD-C138NP
  round 3.505 smd: 1(0,0)
SPAD-C157NP
  round 3.988 smd: 1(0,0)
SPAD-C236NP
  round 5.994 smd: 1(0,0)
SPAD-C236NPP
  round 5.994 smd: 1(0,0)
SPAD-RE47X512NP
  rect 1.194x13.005 smd: 1(0,0)
SPAD-RE79X185NP
  rect 2.007x4.699 smd: 1(0,0)
SPAD-RE79X282NP
  rect 2.007x7.163 smd: 1(0,0)
SPAD-RE79X322NP
  rect 2.007x8.179 smd: 1(0,0)
SPAD-RE79X393NP
  rect 2.007x9.982 smd: 1(0,0)
SPAD-RE79X922NP
  rect 2.007x23.419 smd: 1(0,0)
SPAD-RE317X59NP
  rect 8.052x1.499 smd: 1(0,0)
SPAD-RE317X60NP
  rect 8.052x1.524 smd: 1(0,0)
SPAD-XW2A-1NP
  custom 0.886x0.886 smd: 1(0,0)
SSOP5-P-A-TOSHIBA-B
  rect 1.067x0.305 smd: 1(0.85,-0.65) 2(0.85,0) 3(0.85,0.65) 4(-0.85,0.65) 5(-0.85,-0.65)
SSOP28-7_8-65-2H
  rect 0.381x1.651 smd: 1(-4.225,-3.675) 2(-3.575,-3.675) 3(-2.925,-3.675) 4(-2.275,-3.675) 5(-1.625,-3.675) 6(-0.975,-3.675) 7(-0.325,-3.675) 8(0.325,-3.675) 9(0.975,-3.675) 10(1.625,-3.675) 11(2.275,-3.675) 12(2.925,-3.675) 13(3.575,-3.675) 14(4.225,-3.675) 15(4.225,3.675) 16(3.575,3.675) 17(2.925,3.675) 18(2.275,3.675) 19(1.625,3.675) 20(0.975,3.675) 21(0.325,3.675) 22(-0.325,3.675) 23(-0.975,3.675) 24(-1.625,3.675) 25(-2.275,3.675) 26(-2.925,3.675) 27(-3.575,3.675) 28(-4.225,3.675)
TP2050
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TRF-15_6X9_4-1_27-25P
  rect 0.787x1.727 smd: 1(-6.985,-4.472) 2(-5.715,-4.472) 3(-4.445,-4.472) 4(-3.175,-4.472) 5(-1.905,-4.472) 6(-0.635,-4.472) 7(0.635,-4.472) 8(1.905,-4.472) 9(3.175,-4.472) 10(4.445,-4.472) 11(5.715,-4.472) 12(6.985,-4.472) 13(6.985,4.472) 14(5.715,4.472) 15(4.445,4.472) 16(3.175,4.472) 17(1.905,4.472) 18(0.635,4.472) 19(-0.635,4.472) 20(-1.905,4.472) 21(-3.175,4.472) 22(-4.445,4.472) 23(-5.715,4.472) 24(-6.985,4.472)
  rect 0.889x0.787 smd: 25(-7.055,0)
UB3-TAR24-9R6396-9P
  round 1.194 hole 0.787: 1(-3.5,5.6) 2(-1,5.6) 3(1,5.6) 4(3.5,5.6) 5(4,7.1) 6(2,7.1) 7(0,7.1) 8(-2,7.1) 9(-4,7.1)
  oval 1.397x1.6 hole 0.787x1.295: 10(-6.4,0) 11(6.4,0)
  oval 1.397x2.438 hole 0.787x1.854: 12(6.4,6.1) 13(-6.4,6.1)
UB31-UT1211C-1340Q-7H-24P
  round 0.813 hole 0.813 unplated: (-3.6,0)
  oval 0.813x0.762 hole 0.813x0.762 unplated: (3.6,0)
  oval 0.787x1.702 hole 0.508x1.397: 5(-4.6,-1.25) 6(4.6,-1.25)
  oval 0.787x1.905 hole 0.508x1.6: 7(-4.6,-6.25) 8(4.6,-6.25)
  rect 0.254x0.889 smd: A1(-2.75,0.56) A2(-2.25,0.56) A3(-1.75,0.56) A4(-1.25,0.56) A5(-0.75,0.56) A6(-0.25,0.56) A7(0.25,0.56) A8(0.75,0.56) A9(1.25,0.56) A10(1.75,0.56) A11(2.25,0.56) A12(2.75,0.56) B1(2.75,-1.14) B2(2.25,-1.14) B3(1.75,-1.14) B4(1.25,-1.14) B5(0.75,-1.14) B6(0.25,-1.14) B7(-0.25,-1.14) B8(-0.75,-1.14) B9(-1.25,-1.14) B10(-1.75,-1.14) B11(-2.25,-1.14) B12(-2.75,-1.14)
UDFN10-2_5X1-5
  rect 0.254x0.508 smd: 1(-1,-0.4) 2(-0.5,-0.4) 4(0.5,-0.4) 5(1,-0.4) 6(1,0.4) 7(0.5,0.4) 9(-0.5,0.4) 10(-1,0.4)
  rect 0.457x0.508 smd: 3(0,-0.4) 8(0,0.4)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed#2
  round 1.016 smd: 1(0,0)
WQFN24-4X4-5-25P-RT8813AGQW
  rect 0.305x0.991 smd: 1(-1.25,-2.1) 2(-0.75,-2.1) 3(-0.25,-2.1) 4(0.25,-2.1) 5(0.75,-2.1) 6(1.25,-2.1) 13(1.25,2.1) 14(0.75,2.1) 15(0.25,2.1) 16(-0.25,2.1) 17(-0.75,2.1) 18(-1.25,2.1)
  rect 0.991x0.305 smd: 7(2.1,-1.25) 8(2.1,-0.75) 9(2.1,-0.25) 10(2.1,0.25) 11(2.1,0.75) 12(2.1,1.25) 19(-2.1,1.25) 20(-2.1,0.75) 21(-2.1,0.25) 22(-2.1,-0.25) 23(-2.1,-0.75) 24(-2.1,-1.25)
  rect 2.515x2.515 smd: 25(0,0)
WTB-50450-0107C-001-10P-L
  rect 0.508x0.991 smd: 1(-3.6,1.45) 2(-2.8,1.45) 3(-2,1.45) 4(-1.2,1.45) 5(-0.4,1.45) 6(0.4,1.45) 7(1.2,1.45) 8(2,1.45) 9(2.8,1.45) 10(3.6,1.45)
  rect 1.194x1.702 smd: 11(-4.9,0) 12(4.9,0)
WTB-50450-0127C-001-12P-L
  rect 0.508x0.991 smd: 1(-4.4,1.45) 2(-3.6,1.45) 3(-2.8,1.45) 4(-2,1.45) 5(-1.2,1.45) 6(-0.4,1.45) 7(0.4,1.45) 8(1.2,1.45) 9(2,1.45) 10(2.8,1.45) 11(3.6,1.45) 12(4.4,1.45)
  rect 1.194x1.702 smd: 13(-5.7,0) 14(5.7,0)
XTL-2X1_6-1_35X1_05
  rect 0.838x0.762 smd: 1(-0.675,-0.525) 2(0.675,-0.525) 3(0.675,0.525) 4(-0.675,0.525)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_6-0_9H
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
XTL-3_2X2_5-2_2X1_7
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
XTL-3_2X2_5-2_2X1_7-0_8H
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
1V05A_PG: PR18003.1 PR25011.2
1V8_AON: C2132.2 C2142.1 C2143.2 C2148.1 C2149.2 D2004.1(CATHODE) PC9516.2 PR9006.1 PR9213.1 PR9502.2 PR9505.1 PU9503.5(VCC) Q2011.2(G) Q2014.2 Q2020.2(G) Q2020.5(G) Q2021.2(G) Q2024.2(G) Q2024.5(G) R2025.2 R2028.2 R2029.2 R2031.1 R2032.2 R2033.1 R2034.1 R2035.1 R2036.2 R2037.1 R2039.1 R2040.1 R2042.1 R2043.1 R2044.1 R2050.1 R2070.2 R2071.2 R2073.1 R2074.1 R2080.2 R2085.1 R2086.1 R2089.1 R2090.2 R2092.2 R2093.2 R2095.1 R2097.2 R2098.2 R2101.1 R2107.1 R2114.1 R2119.1 R2138.1 R2139.1 R2145.1 R2148.1 U2000.J8(1V8_AON_1) U2000.K8(1V8_AON_2) U2001.5(VCC) U2006.5(VCC) U2007.5(VCC)
1V8_AON_EN: PR9501.2 R2127.1 U2004.4(O)
1V8_AON_S: PC9505.1 PC9506.1 PR9502.1 PU9501.8(OUT2#1) PU9501.9(OUT2#2)
1V8_MAIN: C2009.2 C2027.2 C2028.2 C2038.2 C2042.2 C2043.1 C2044.1 C2084.2 C2090.2 C2095.2 C2100.2 C2101.2 C2106.2 L2001.2 L2010.1 PR9503.1 R2020.2 R2232.1 U2000.AG13(PEX_HVDD_1) U2000.AG15(PEX_HVDD_2) U2000.AG16(PEX_HVDD_3) U2000.AG18(PEX_HVDD_4) U2000.AG25(PEX_HVDD_5) U2000.AH15(PEX_HVDD_6) U2000.AH18(PEX_HVDD_7) U2000.AH26(PEX_HVDD_8) U2000.AH27(PEX_HVDD_9) U2000.AJ27(PEX_HVDD_10) U2000.AK27(PEX_HVDD_11) U2000.AL27(PEX_HVDD_12) U2000.AM28(PEX_HVDD_13) U2000.AN28(PEX_HVDD_14) U2000.L8(VDD18_1) U2000.M8(VDD18_2)
1V8_MAIN_EN: PD9501.1(CATHODE) PR9504.1 PU9503.1(INB) PU25002.2(INA) R2031.2 R2126.2 R2231.1
1V8_MAIN_EN_R: R2126.1 U2000.P7(GPIO4)
1V8_MAIN_S: PC9503.1 PC9504.1 PR9503.2 PU9501.13(VOUT1#1) PU9501.14(VOUT1#2)
1V8A_PG: PR16014.1 PR25007.2
2V5_PG: PR15012.1 R9278.2 R9279.1
3.3V#3: CON5000.10(3.3V#3)
3V3DS_PG: PR13015.1 PR25024.2
5V_PG: PR13007.1 PR25025.2
5V_USBSRC_PG: PR13018.1 PR25026.2
8813VID: PR9014.2 PU9001.5(VID)
8813VOUT1: PC9033.1 PC9034.1 PR9025.1 PU9001.11(VSNS)
8813VREF: PC9024.1 PR9015.1 PU9001.8(VREF)
9610VCC: PC9044.1 PR9035.2 PU9002.8(VCC)
+0.6V_DDR_VTT: C1019.1 C1021.1 C1022.1 C1049.1 C1051.1 C1052.1 C1062.1 C1064.1 C1066.1 C1091.1 C1094.1 C1096.1 JDIM1000.258(VTT) JDIM1001.258(VTT) JDIM1002.258(VTT) JDIM1003.258(VTT) PC14007.1 PC14008.1 PR14016.1 PU14000.5(VTT) PU14000.8(VTTS)
+1.0V_GFX_EN: PQ9502.2(G) PR9507.1 PR9522.1 PU9503.4(OUT Y)
+1.2V: C502.1 C503.1 C504.1 C506.1 C507.1 C508.1 C509.1 C510.1 C511.1 C512.1 C513.1 C535.1 C536.1 C537.1 C538.1 C539.1 C540.1 C541.1 C542.1 C543.1 C544.1 C545.1 PC23014.1 PC23016.1 PU23002.8(VOUT) R17972.1 R17972.2 R17973.1 R17973.2 R17974.1 R17974.2 R17975.1 R17975.2 R18077.2 U500.3(VDDRX12_3) U500.24(VDDRX12_24) U500.32(VDD12_32) U500.42(VDDTX12_42) U500.43(VDDA12_43) U500.55(VDDTX12_55) U500.56(VDD12_56) U501.3(VDDRX12_3) U501.24(VDDRX12_24) U501.32(VDD12_32) U501.42(VDDTX12_42) U501.43(VDDA12_43) U501.55(VDDTX12_55) U501.56(VDD12_56)
+1.2V_8409: C12051.1 C12052.1 C12054.2 C12055.2 C12057.1 C12058.1 C12060.2 C12061.1 C12062.1 C12063.2 C12065.1 C12066.2 R18077.1 U12006.6(VDD12_1) U12006.11(VDDA12) U12006.15(VDDTX12_1) U12006.18(VDDTX12_2) U12006.30(VDD12_2) U12006.43(VDDRX12_1) U12006.46(VDDRX12_2)
+1.2V_VCCPLL_OC: PC23012.1 PC23013.1 PQ23006.1(S) PR23014.1 R9044.2
+1.2VSUS: C1002.1 C1003.1 C1004.1 C1005.1 C1006.1 C1007.1 C1008.1 C1009.1 C1010.1 C1011.1 C1012.1 C1013.1 C1014.1 C1015.1 C1016.1 C1017.1 C1032.1 C1033.1 C1034.1 C1035.1 C1036.1 C1037.1 C1038.1 C1039.1 C1040.1 C1041.1 C1042.1 C1043.1 C1044.1 C1045.1 C1046.1 C1047.1 C1060.1 C1061.1 C1063.1 C1065.1 C1067.1 C1068.1 C1069.1 C1071.1 C1073.1 C1074.1 C1075.1 C1076.1 C1077.1 C1078.1 C1079.1 C1080.1 C1090.1 C1092.1 C1095.1 C1097.1 C1098.1 C1099.1 C1100.1 C1102.1 C1104.1 C1105.1 C1106.1 C1107.1 C1108.1 C1109.1 C1110.1 C1111.1 C1123.1 C1124.1 C9000.1 C9001.1 C9072.1 C9073.1 C9074.1 C9075.1 C9081.1 C9082.1 C9083.1 C9084.1 C9085.1 C9088.1 C9089.1 C9090.1 C9091.1 C9092.1 C9093.1 JDIM1000.12(DM0) JDIM1000.33(DM1) JDIM1000.54(DM2) JDIM1000.75(DM3) JDIM1000.96(DM8) JDIM1000.111(VDD1) JDIM1000.112(VDD2) JDIM1000.117(VDD3) JDIM1000.118(VDD4) JDIM1000.123(VDD5) JDIM1000.124(VDD6) JDIM1000.129(VDD7) JDIM1000.130(VDD8) JDIM1000.135(VDD9) JDIM1000.136(VDD10) JDIM1000.141(VDD11) JDIM1000.142(VDD12) JDIM1000.147(VDD13) JDIM1000.148(VDD14) JDIM1000.153(VDD15) JDIM1000.154(VDD16) JDIM1000.159(VDD17) JDIM1000.160(VDD18) JDIM1000.163(VDD19) JDIM1000.178(DM4) JDIM1000.199(DM5) JDIM1000.220(DM6) JDIM1000.241(DM7) JDIM1001.12(DM0) JDIM1001.33(DM1) JDIM1001.54(DM2) JDIM1001.75(DM3) JDIM1001.96(DM8) JDIM1001.111(VDD1) JDIM1001.112(VDD2) JDIM1001.117(VDD3) JDIM1001.118(VDD4) JDIM1001.123(VDD5) JDIM1001.124(VDD6) JDIM1001.129(VDD7) JDIM1001.130(VDD8) JDIM1001.135(VDD9) JDIM1001.136(VDD10) JDIM1001.141(VDD11) JDIM1001.142(VDD12) JDIM1001.147(VDD13) JDIM1001.148(VDD14) JDIM1001.153(VDD15) JDIM1001.154(VDD16) JDIM1001.159(VDD17) JDIM1001.160(VDD18) JDIM1001.163(VDD19) JDIM1001.178(DM4) JDIM1001.199(DM5) JDIM1001.220(DM6) JDIM1001.241(DM7) JDIM1002.12(DM0) JDIM1002.33(DM1) JDIM1002.54(DM2) JDIM1002.75(DM3) JDIM1002.96(DM8) JDIM1002.111(VDD1) JDIM1002.112(VDD2) JDIM1002.117(VDD3) JDIM1002.118(VDD4) JDIM1002.123(VDD5) JDIM1002.124(VDD6) JDIM1002.129(VDD7) JDIM1002.130(VDD8) JDIM1002.135(VDD9) JDIM1002.136(VDD10) JDIM1002.141(VDD11) JDIM1002.142(VDD12) JDIM1002.147(VDD13) JDIM1002.148(VDD14) JDIM1002.153(VDD15) JDIM1002.154(VDD16) JDIM1002.159(VDD17) JDIM1002.160(VDD18) JDIM1002.163(VDD19) JDIM1002.178(DM4) JDIM1002.199(DM5) JDIM1002.220(DM6) JDIM1002.241(DM7) JDIM1003.12(DM0) JDIM1003.33(DM1) JDIM1003.54(DM2) JDIM1003.75(DM3) JDIM1003.96(DM8) JDIM1003.111(VDD1) JDIM1003.112(VDD2) JDIM1003.117(VDD3) JDIM1003.118(VDD4) JDIM1003.123(VDD5) JDIM1003.124(VDD6) JDIM1003.129(VDD7) JDIM1003.130(VDD8) JDIM1003.135(VDD9) JDIM1003.136(VDD10) JDIM1003.141(VDD11) JDIM1003.142(VDD12) JDIM1003.147(VDD13) JDIM1003.148(VDD14) JDIM1003.153(VDD15) JDIM1003.154(VDD16) JDIM1003.159(VDD17) JDIM1003.160(VDD18) JDIM1003.163(VDD19) JDIM1003.178(DM4) JDIM1003.199(DM5) JDIM1003.220(DM6) JDIM1003.241(DM7) PC23011.1 PC23017.1 PJP14000.2 PQ23006.3(D) PU23002.1(VIN#1) PU23002.2(VIN#2) PU23002.9(VIN#3) R1000.2 R1002.1 R1017.1 R1025.1 R1030.1 R1043.1 R9043.2 R9085.2 U9001.AA6(VDDQ1) U9001.AE12(VDDQ2) U9001.AF5(VDDQ3) U9001.AF6(VDDQ4) U9001.AG5(VDDQ5) U9001.AG9(VDDQ6) U9001.AJ12(VDDQ7) U9001.AL11(VDDQ8) U9001.AP6(VDDQ9) U9001.AP7(VDDQ10) U9001.AR6(VDDQ12) U9001.AR12(VDDQ11) U9001.AT12(VDDQ13) U9001.AW6(VDDQ14) U9001.AY6(VDDQ15) U9001.J5(VDDQ16) U9001.J6(VDDQ17) U9001.K6(VDDQ19) U9001.K12(VDDQ18) U9001.L6(VDDQ21) U9001.L12(VDDQ20) U9001.R6(VDDQ22) U9001.T6(VDDQ23) U9001.W6(VDDQ24) U9001.Y12(VDDQ25)
+1.2VSUS_S: PC14009.2 PC14010.1 PC14011.1 PC14012.1 PC14013.1 PJP14000.1 PL14001.2 PR14006.2 PU14000.6(VDDQ)
+1.5V: EC9021.1 EC9022.1 PJP16001.2 R3044.1 R3053.2
+1.05V_DEEP_SUS: C9219.1 C9220.1 C9245.2 CON400.43(VCC_OBS_AB) CON400.44(VCC_OBS_CD) EC9041.1 EC9042.2 EC9043.1 EC9044.1 EC9045.1 EC9046.1 PC23005.1 PC23006.1 PJP18000.1 PQ23003.3(D) PQ23004.3(D) PQ26000.3(D) PQ26003.3(D) R402.2 R9124.1 R9141.2 R9257.2 R9259.2 R9260.2 R9261.2 R9262.2 R9263.2 R9265.2 R17900.2 R17901.2 R17909.2 R17910.2 U9002.AA22(VCCPRIM_1P051) U9002.AA23(VCCPRIM_1P052) U9002.AB20(VCCPRIM_1P053) U9002.AB22(VCCPRIM_1P054) U9002.AB23(VCCPRIM_1P055) U9002.AB27(VCCPRIM_1P056) U9002.AB28(VCCPRIM_1P057) U9002.AB30(VCCPRIM_1P058) U9002.AD20(VCCPRIM_1P059) U9002.AD23(VCCPRIM_1P0510) U9002.AD27(VCCPRIM_1P0511) U9002.AD28(VCCPRIM_1P0512) U9002.AD30(VCCPRIM_1P0513) U9002.AF23(VCCPRIM_1P0516) U9002.AF27(VCCPRIM_1P0517) U9002.AF30(VCCPRIM_1P0518) U9002.AF31(VCCPRIM_1P0519) U9002.AG31(VCCPRIM_1P0520) U9002.U26(VCCPRIM_1P0523) U9002.U29(VCCPRIM_1P0524) U9002.V25(VCCPRIM_1P0525) U9002.V27(VCCPRIM_1P0526) U9002.V28(VCCPRIM_1P0527) U9002.V30(VCCPRIM_1P0528) U9002.V31(VCCPRIM_1P0529)
+1.05V_DEEP_SUS_S: PC18007.1 PC18008.1 PC18009.1 PC18010.1 PC18011.1 PC18012.1 PJP18000.2 PL18001.2 PR18006.2
+1.05V_LAN: C4005.1 C4006.2 C4007.2 L4000.2 U4000.8(VDD1P0_8) U4000.11(VDD1P0_11) U4000.16(VDD1P0_16) U4000.22(VDD1P0_22) U4000.37(VDD1P0_37) U4000.40(VDD1P0_40) U4000.43(VDD1P0_43) U4000.46(VDD1P0_46) U4000.47(VDD1P0_47)
+1.5V_S: PC16015.1 PC16016.2 PC16018.1 PJP16001.1 PR16016.2 PU16001.5(NC) PU16001.6(VO)
+1.8V: CON10002.1 PC22006.1 PC22007.1 PR25004.2 PU22001.8(OUT2#1) PU22001.9(OUT2#2) R3601.1 R3604.1 R3609.2 R3622.1 R3683.2 R9352.2 R9502.2 R9513.1 R9514.1 R9533.1 R9535.1 R18003.1 R18024.2 U6004.1(VCCA) U12003.5(VCC)
+1.8V_AMP: C3645.1 C3646.1 EC9006.2 Q3602.2(G) Q3602.5(G) Q9042.2(G) Q9042.5(G) R3643.1 R3645.1 R3646.1 R3647.1 U3602.F2(ADS1) U3602.F3(ADS2) U3602.G3(VDDD) U3603.F3(ADS2) U3603.G3(VDDD) U3606.5(VCC)
+1.8V_CPAVDD18: C3616.2 C3617.1 R3622.2 U3600.28(CP_AVDD18)
+1.8V_DEEP_SUS: PC22004.1 PC22005.1 PR22012.1 PR25005.1 PU22001.13(VOUT1#1) PU22001.14(VOUT1#2) R618.1 R621.1 R3643.2 R6098.1 R9001.1 R9056.1 R9057.1 R9065.2 R9079.2 R9082.2 R9196.1 R9341.1 R9353.2 R9371.2 R9545.1 R9546.1 R17887.2 R17902.1 R17947.1 R17948.1 R17985.2 U3011.5(VCC)
+1.8V_DEEP_SUS_P1: C9225.2 R9591.1 R17902.2 U9002.AN15(VCCPRIM_1P85) U9002.AR15(VCCPRIM_1P86) U9002.BB11(VCCPRIM_1P87)
+1.8V_SM: C7309.1 C7310.1 U7300.15(V18OUT) U7300.16(VDD) U7300.17(VDDP)
+1.8V_USBP3: C618.1 R602.2 R618.2 R9531.2 R9533.2 U601.3(VDD(1V8))
+1.8V_USBP4: C619.1 R604.2 R615.2 R621.2 R9535.2 U600.3(VDD(1V8))
+1.8V_VDD18: C3603.1 C3604.2 R3601.2 U3600.50(VDD18)
+1.8VPCU: PC9501.1 PC9502.1 PC16013.2 PC16014.1 PC22001.1 PC22002.1 PJP16000.2 PR22012.2 PU9501.1(VIN1#1) PU9501.2(VIN1#2) PU9501.6(VIN2#1) PU9501.7(VIN2#2) PU16001.3(VIN) PU22001.1(VIN1#1) PU22001.2(VIN1#2) PU22001.6(VIN2#1) PU22001.7(VIN2#2) R3645.2 R6097.1 R6237.1 R17907.2 U4102.5(VCC) U4103.5(VCC)
+1.8VPCU_S: PC16007.1 PC16008.1 PC16009.1 PC16010.1 PJP16000.1 PL16001.2 PR16006.2
+2.5VSUS: C1023.1 C1025.1 C1027.1 C1028.1 C1053.1 C1054.1 C1055.1 C1056.1 C1082.1 C1084.1 C1085.1 C1086.1 C1113.1 C1115.1 C1116.1 C1117.1 JDIM1000.257(VPP1) JDIM1000.259(VPP2) JDIM1001.257(VPP1) JDIM1001.259(VPP2) JDIM1002.257(VPP1) JDIM1002.259(VPP2) JDIM1003.257(VPP1) JDIM1003.259(VPP2) PJP15000.2
+2.5VSUS_S: PC15008.1 PC15009.1 PC15010.1 PC15011.1 PJP15000.1 PL15001.2 PR15006.2
+3V: C621.2 C635.2 C652.2 C653.2 C1024.2 C1026.2 C1057.2 C1058.2 C1070.2 C1072.1 C1101.2 C1103.1 C2147.2 C2228.2 C2230.2 C3026.1 C3034.1 C3042.1 C3047.1 C5100.2 C5101.2 C5102.2 C5103.2 C5104.2 C5105.2 C5106.2 C5107.2 C5112.2 C5113.2 C5114.2 C5115.2 C5121.1 C5122.1 C6353.1 C6401.1 C7316.1 C7317.2 C7326.2 C7327.1 CON5100.2(3.3VAUX_2) CON5100.4(3.3VAUX_4) CON5100.14(3.3VAUX_14) CON5100.16(3.3VAUX_16) CON5100.18(3.3VAUX_18) CON5100.70(3.3VAUX_70) CON5100.72(3.3VAUX_72) CON5100.74(3.3VAUX_74) CON5101.2(3.3VAUX_2) CON5101.4(3.3VAUX_4) CON5101.14(3.3VAUX_14) CON5101.16(3.3VAUX_16) CON5101.18(3.3VAUX_18) CON5101.70(3.3VAUX_70) CON5101.72(3.3VAUX_72) CON5101.74(3.3VAUX_74) CON6351.1 EC5101.1 EC5102.1 EC9002.1 EC9003.1 EC9015.1 EC9016.1 EC9017.1 EC9018.1 EC9032.1 EC9033.2 EC9034.1 F7200.2 JDIM1000.255(VDDSPD) JDIM1001.255(VDDSPD) JDIM1002.255(VDDSPD) JDIM1003.255(VDDSPD) LED9004.1 LED9004.2 PC22030.1 PC22031.1 PC25014.1 PR9811.1 PR9813.2 PR9815.2 PR9819.1 PR9820.2 PR9821.1 PR12011.1 PR19017.1 PR25000.2 PR25002.2 PR25020.2 PU22002.13(VOUT1#1) PU22002.14(VOUT1#2) PU25002.5(VCC) Q4101.5(G) Q6402.2(G) Q6402.5(G) Q9008.2(G1) Q9008.5(G2) Q9032.2(G) Q9032.5(G) Q9047.2(G) Q9047.5(G) R500.1 R620.1 R623.1 R626.1 R627.1 R631.1 R633.1 R634.1 R911.1 R1004.1 R1005.1 R1006.1 R1019.1 R1020.1 R1021.1 R1027.1 R1028.1 R1029.1 R1045.1 R1046.1 R1047.1 R2078.1 R2102.2 R2132.1 R2135.1 R2146.1 R3000.1 R3012.1 R3034.1 R3042.2 R3043.2 R3045.1 R3047.1 R3048.2 R3052.2 R3058.2 R3059.2 R3060.2 R3062.1 R3063.1 R3064.1 R3065.1 R3066.1 R3067.1 R3068.1 R3602.2 R3606.2 R3619.2 R4104.2 R4201.1 R4215.1 R5100.2 R5102.2 R5106.2 R5108.2 R6090.2 R6091.2 R6132.2 R6133.2 R6179.1 R6224.1 R6225.1 R6303.1 R6304.1 R6305.1 R6401.1 R6405.1 R6406.1 R6511.1 R6824.2 R7307.2 R7328.2 R7329.2 R7331.2 R8046.1 R9002.2 R9052.1 R9053.1 R9054.2 R9055.1 R9071.2 R9073.2 R9075.2 R9077.2 R9103.2 R9125.1 R9126.1 R9132.2 R9145.2 R9148.2 R9149.1 R9151.1 R9153.1 R9158.2 R9160.2 R9171.2 R9172.2 R9173.2 R9174.2 R9176.2 R9177.2 R9178.2 R9179.2 R9180.2 R9181.2 R9182.2 R9183.2 R9184.2 R9185.2 R9186.2 R9187.2 R9208.1 R9224.2 R9225.2 R9227.2 R9229.2 R9231.2 R9232.1 R9234.1 R9239.1 R9242.2 R9243.2 R9244.2 R9245.2 R9246.2 R9247.2 R9301.2 R9323.1 R9327.2 R9330.2 R9354.2 R9355.2 R9360.2 R9361.2 R9364.2 R9365.2 R9374.2 R9375.2 R9501.2 R9508.1 R9543.2 R17888.2 R17987.1 R18011.1 R18044.2 R18067.2 U603.6(VDD1) U603.16(VDD2) U2004.5(+3V) U2005.5(+3V) U2008.5(VCC) U2009.5(VCC) U2010.5(VCC) U2011.5(VCC) U3001.5(IN) U3002.5(IN) U3005.5(IN) U3007.26(VDD33_2) U3007.49(VDD33_4) U3008.5(VCC) U3009.5(VCC) U3010.5(VCC) U3607.5(VCC) U6004.8(VCCB) U6401.1(VCC) U7301.11(3V3_IN) U7301.27(3V3AUX) U9000.5(VCC)
+3V_8409: C12043.2 C12044.2 C12045.1 C12046.1 C12047.1 C12048.1 C12049.1 C12056.2 R18067.1 R18069.2 R18072.2 R18073.2 R18079.2 U12006.1(VDD33_1) U12006.24(VDD33_2)
+3V_ALW: C6033.2 PC13015.2 PD12000.1 PD12001.1 PR14017.2 PR16000.1 PR24002.1 PR25009.1 PU13001.6(LDO) PU25001.5 R6053.1 R6169.1 R6170.1 R9130.1 R9276.1 U6002.5(DSR) U6002.8(VCC)
+3V_AR: C8056.2 C8057.2 C8059.2 C8060.2 C8061.2 C8062.2 R8026.1 R8045.2 R8046.2 U8001.E6(VCC3P3A) U8001.G1(VCC3P3_SVR#1) U8001.G2(VCC3P3_SVR#3) U8001.H2(VCC3P3_SVR#2) U8001.L6(VCC3P3_S0)
+3V_CAM: C3023.2 C3024.1 CON3000.38 U3001.1(VOUT)
+3V_DEEP_SUS: C9217.2 C9237.2 C9238.2 CON401.1 PC22025.1 PC22032.1 PR11012.2 PR17000.2 PR17002.2 PR17011.1 PR22013.1 PR24000.2 PR25003.1 PR25021.1 PU22002.8(OUT2#1) PU22002.9(OUT2#2) Q9009.2(G) Q9009.5(G) Q9043.2(G) R4107.2 R4227.2 R6203.2 R8043.1 R9067.1 R9068.2 R9101.2 R9105.2 R9106.1 R9110.2 R9113.2 R9116.2 R9118.2 R9119.2 R9120.2 R9123.2 R9135.2 R9142.2 R9144.2 R9192.2 R9193.2 R9201.2 R9203.2 R9204.2 R9210.2 R9211.2 R9214.2 R9223.1 R9237.1 R9241.2 R9252.1 R9255.2 R9258.1 R9287.1 R9308.2 R9312.1 R9313.1 R9324.1 R9325.1 R9326.1 R9338.2 R9339.1 R9358.1 R9368.2 R9370.2 R9379.2 R9380.2 R17898.1 R17908.2 R17956.2 R17958.2 R17977.1 R17992.1 R18023.1 U9002.AC35(VCCPGPPHK1) U9002.AC36(VCCPGPPHK2) U9002.AE35(VCCPGPPEF1) U9002.AE36(VCCPGPPEF2) U9002.AN21(VCCPGPPG_3P3) U9002.AN24(VCCPGPPD) U9002.AN26(VCCPGPPBC1) U9002.AP26(VCCPGPPBC2) U9002.AT44(VCCPRIM_3P31) U9002.AW9(VCCPRIM_3P32) U9002.V23(VCCPRIM_3P35) U9003.5(VCC) U12001.5(VCC)
+3V_DP: C501.1 C505.1 C533.1 C534.1 C10010.1 C10011.1 C10012.1 C10013.1 R500.2 R502.1 R503.1 R506.1 R508.1 R510.2 R511.2 R513.2 R514.2 R515.2 R518.2 R520.2 R524.2 R527.1 R529.1 R532.1 R534.1 R536.2 R537.2 R539.2 R540.2 R541.2 R542.2 R546.2 R549.2 R10052.2 R10055.2 R17949.2 R17950.2 R17951.2 R17952.2 TP22066.1 TP22068.1 U500.1(VDDIO_1) U500.2(VDD33_2) U500.29(VDD33_29) U501.1(VDDIO_1) U501.2(VDD33_2) U501.29(VDD33_29)
+3V_DREAM: CON3002.2 CON3002.6 Q3007.2(G) Q3007.5(G) Q3008.2(G) Q3008.5(G) R3083.2 R3084.2 R3085.2 R3086.2 R3093.1 U3005.1(VOUT)
+3V_ECACC: C6017.1 C6018.2 R6034.1 U6001.D1(AVCC)
+3V_FP: C7200.1 C7201.1 CON7200.7 CON7200.8 ESD7200.5 F7200.1 R7200.2
+3V_RTC: C6004.2 C9189.1 C9233.2 C9234.2 C9304.1 D9000.3(CATHODE) R4203.2 R9131.1 R9136.1 R9205.1 U6001.L4(VBAT) U9002.BC49(VCCRTC1) U9002.BD49(VCCRTC2)
+3V_RTC_0: CON9000.1 D9004.2(ANODE) R18105.1
+3V_RTC_0_R: D9004.1(CATHODE) R9137.1 R18105.2
+3V_RTC_1: D9000.1(ANODE1) R9137.2
+3V_RTC_2: C9301.1 D9000.2(ANODE2) R9130.2 R9133.1
+3V_SM: C7304.1 C7306.1 C7312.1 C7313.1 R7302.1 U7300.10(AV33) U7300.14(V33OUT) U7300.18(VDDH)
+3V_THR: C6403.1 R6402.1 U6402.5(VCC)
+3V_TS: C3032.1 C3033.1 CON3001.3 CON3001.4 R3016.1 R3017.1 R3029.2 R3030.2 R3031.2 U3002.1(VOUT)
+3V_VCC: C6012.1 C6015.2 C6016.2 C6030.2 C6031.2 PQ26006.2(G) PR10023.1 R6032.1 U6001.A7(VCC1#1) U6001.B1(VCC1#2) U6001.D12(VCC1#4) U6001.M8(VCC1#3)
+3V_VCCSPI: R9339.2 U9002.AN44(VCCSPI)
+3V_WLAN_EN: Q4106.6(D) R4127.1 U4101.4(EN) U12005.4(OUT Y)
+3V_WLAN_P: C4101.1 C4102.1 C4103.2 Q4101.2(G) R4101.2 R4108.2 R4110.1 R4118.2 R4122.1 R4123.2 R4125.1 U4101.1(VOUT)
+3V_WWAN_P: C4201.2 C4202.1 C4205.2 C4206.1 C4208.1 C4209.1 C4212.1 C4213.2 C4217.2 C4218.1 C4219.1 C4220.1 C4221.1 C4222.1 C4223.2 C4224.2 C4225.1 C4226.1 CON4201.2(3V3_2) CON4201.4(3V3_4) CON4201.70(3V3_70) CON4201.72(3V3_72) CON4201.74(3V3_74) EC9039.1 EC9040.1 R4202.2 R4205.2 R4210.1 R4216.2 R4223.2 R4226.1
+3VCARD: C7330.1 C7331.1 C7332.2 CON7301.4(VDD/VDD1) D7307.2 R7316.1
+3VCARD_1: R7316.2 U7301.12(CARD_3V3)
+3VLANVCC: C4002.1 C4003.1 C4004.1 PC22010.1 PC22011.1 PU22000.8(OUT2#1) PU22000.9(OUT2#2) R4001.2 R4002.2 R4003.2 R4004.2 R4010.2 R4013.1 R4014.1 R4022.1 R4023.2 R4024.2 R9104.2 R9549.1 R9550.1 TP22000.1 U4000.4(VDD3P3_OUT) U4000.5(VDD3P3_IN) U4000.15(VDD3P3_15) U4000.19(VDD3P3_19) U4000.29(VDD3P3_29)
+3VLCD_CON: C3017.1 C3018.1 C3019.1 C3020.1 C3021.1 CON3000.24 CON3000.25 CON3000.26 D9003.1(CATHODE) R3039.2 R18006.1 U3000.1(VOUT)
+3VPCU: C4100.2 C4203.1 C6029.1 C6800.1 C8580.2 C9248.2 CON401.3 CON401.7 CON6000.4 CON6000.5 JCN9000.22(+3VPCU) JCN9000.30(P5V0DS) L6000.2 LED6000.3 PC11024.2 PC12011.2 PC19002.1 PC20047.1 PC21009.2 PC21021.2 PC21029.2 PC22003.1 PC22023.1 PC22026.1 PJP13001.1 PQ10008.1(EMITTER) PQ10010.1(EMITTER) PQ12006.2(BASE) PQ12007.2(BASE) PQ12011.1(EMITTER) PQ12012.1(EMITTER) PR9508.1 PR11025.2 PR11030.2 PR11031.2 PR11034.2 PR12013.2 PR14000.2 PR15000.1 PR15007.2 PR15009.2 PR15010.2 PR16008.2 PR16009.2 PR17006.1 PR19000.2 PR19005.2 PR19006.2 PR19007.2 PR19029.2 PR20064.2 PR20066.2 PR20068.2 PR20070.2 PR20072.2 PR22013.2 PR23022.2 PR23024.2 PR23026.2 PR24001.2 PR25022.2 PR25023.2 PR26000.1 PR26005.1 PU11001.4(+VS) PU20004.2(VCC) PU20004.4(SEL) PU21000.20(VCC) PU21001.20(VCC) PU21002.12(VCC) PU22000.6(VIN2#1) PU22000.7(VIN2#2) PU22002.1(VIN1#1) PU22002.2(VIN1#2) PU22002.6(VIN2#1) PU22002.7(VIN2#2) Q6006.2(G) R912.1 R3008.2 R3080.1 R4100.2 R4102.2 R4127.2 R4137.2 R4200.2 R4216.1 R4219.1 R6018.1 R6020.2 R6028.2 R6029.1 R6031.2 R6032.2 R6036.1 R6037.1 R6038.1 R6039.1 R6040.2 R6045.1 R6050.1 R6056.1 R6062.1 R6068.1 R6078.1 R6079.1 R6100.1 R6130.1 R6131.1 R6165.2 R6167.1 R6178.1 R6181.1 R6182.1 R6183.2 R6184.2 R6204.2 R6230.1 R6358.1 R6402.2 R6403.1 R6412.1 R6413.1 R6802.1 R6803.1 R6804.1 R6805.1 R6806.1 R6807.1 R6808.1 R6815.2 R6816.2 R6822.2 R8044.1 R8501.1 R8508.1 R8511.1 R8680.2 R8681.2 R8682.2 R9090.2 R9092.2 R9094.2 R9278.1 R9367.1 R9592.2 R17879.1 R17938.2 R17939.2 R17940.1 R17941.2 R17942.2 R17943.2 R17953.2 R17964.2 R17965.2 R17966.2 R17967.2 RP6800.5(R10) RP6800.10(R1) U4101.5(IN) U4200.5(VCC) U6003.5(VCC) U8500.A5(VSYS) U9002.BE48(VCCDSW_3P31) U9002.BE49(VCCDSW_3P32) U12005.5(VCC)
+3VPCU_S: PC13023.1 PC13024.1 PC13025.1 PC13026.2 PC13027.1 PJP13001.2 PL13003.2 PR13012.2
+5V: C3037.1 C6302.1 C6304.2 C6306.1 C6307.2 C7300.1 C7307.1 C7308.1 CON6300.3 CON6301.3 EC9000.1 EC9001.2 EC9011.1 EC9029.1 L3604.2 PC22008.1 PC22009.1 PQ26000.2(G) PQ26003.2(G) PR9032.1 PR22004.2 PR25001.2 PU22000.13(VOUT1#1) PU22000.14(VOUT1#2) Q6806.1 R3020.2 R3026.1 R3600.2 R5000.2 R6827.2 R9503.2 U3003.5(IN) U6300.5(+3V) U6301.5(+3V) U7300.4(SMIO_5VPWR) U7300.13(5VINPUT)
+5V_ALW: PC13000.2 PC22012.1 PC22013.1 PC22024.1 PR23009.1 PR23013.1 PR23015.1 PR26010.1 PU13000.6(LDO) PU22000.4(VBIAS) PU22001.4(VBIAS) PU22002.4(VBIAS)
+5V_AMP: C3647.1 C3648.2 C3649.2 C3650.1 C3651.2 C3652.2 EC9007.2 L3607.2 L3608.2 R3644.1 U3602.G2(VBAT) U3603.G2(VBAT)
+5V_AMP_HP: C3631.2 C3637.2 L3604.1 R3639.1 U3601.12(VDD_12) U3601.20($PIN19)
+5V_AUDIO: C3618.2 C3619.2 C3620.2 C3669.1 C3670.1 R3600.1 U3600.23(PVDD5_LEFT) U3600.26(PVDD5_RIGHT) U3600.41(AVDD5)
+5V_HDD: C5001.2 C5002.2 C5003.1 CON5000.14(5V#1) CON5000.15(5V#2) CON5000.16(5V#3) EC9036.2 R5000.1
+5V_HDMIC: C3202.1 C3203.1 C3204.1 C3205.1 CON3200.18(+5V) R3200.1 R3203.1 U3201.1(VOUT)
+5V_IR_LED: C3029.2 C3030.1 C3031.2 EC9037.1 EC9038.2 R3009.1 R3020.1 U3003.1(VOUT)
+5V_IR_LED_L: CON3000.39 CON3000.40 R3009.2
+5V_LED_KBLIGHT: C6825.2 CON6801.1 CON6801.2 CON6801.7 CON6801.8 Q6806.3
+5V_USBP1: C7000.2 C7007.1 C7008.1 C7009.2 C7019.1 CON7001.1 U7003.1(VOUT) VC7000.2
+5V_USBP2: C7001.1 C7002.1 C7005.2 C7021.1 C7022.2 CON7000.1 U7005.12(OUT) VC7001.2
+5V_USBP3: C7003.1 C7004.1 C7006.2 C7020.2 C7023.1 CON7002.1 U7004.1(VOUT) VC7002.2
+5V_USBSRC: C3201.2 C7013.2 C7016.2 C7138.1 C7139.1 C7140.1 C7141.1 C7146.1 C7147.1 C7154.1 C7155.1 C8586.1 C8587.2 PJP13002.2 R3201.2 R7142.1 R7154.1 R7187.1 R7189.2 R18018.2 R18019.2 R18020.2 R18021.2 U3201.5(VIN) U7003.5(VIN) U7112.A1(VIN #1) U7112.A2(VIN #2) U7113.A1(VIN #1) U7113.A2(VIN #2) U8500.J2(V5V_P1) U8500.L9(V5V_P2)
+5V_USBSRC_P1: R18018.1 U8500.J1(CSP_P1)
+5V_USBSRC_P2: R18019.1 U8500.L2(CSP_P2)
+5V_USBSRC_S: PC13040.1 PC13041.1 PJP13002.1 PL13005.2 PR13020.2
+5VPCU: C7014.2 C7015.2 C7017.2 C7018.2 EC9023.1 EC9024.1 PC9507.2 PC13011.1 PC13012.2 PC16019.1 PC18000.2 PC20000.2 PC20018.2 PC20032.2 PC20042.2 PC22000.1 PC25003.2 PD9002.2(ANODE) PL13001.2 PR8010.1 PR9002.1 PR9035.1 PR9521.1 PR13004.2 PR23023.2 PR23025.2 PR23027.2 PR26011.1 PU9501.4(VBIAS) PU16001.4(VPP) PU18000.21(VCC) PU20000.8(VCC) PU20001.8(VCC) PU20002.8(VCC) PU20003.8(VCC) PU22000.1(VIN1#1) PU22000.2(VIN1#2) PU25000.8(POWER) R3644.2 R6096.1 R7008.1 R7019.1 U7004.5(VIN) U7005.1(IN)
+V3.3DX_ADO: C9228.1 R9258.2 U9002.BB14(VCCHDA)
+VCC0V9_LC: C8087.2 U8001.J8(VCC0P9_LC)
+VCC0V9_LVR_OUT: C8053.2 C8054.2 C8055.2 C8058.2 R7322.2 U8001.H6(VCC0P9_LVR_SENSE) U8001.H8(VCC0P9_LVR)
+VCC0V9_PCIE: C8073.2 C8074.2 C8075.2 C8076.2 C8077.2 U8001.J18(VCC0P9_PCIE) U8001.L18(VCC0P9_ANA_PCIE_2#1) U8001.L19(VCC0P9_ANA_PCIE_1#1) U8001.M16(VCC0P9_ANA_PCIE_2#2) U8001.M18(VCC0P9_ANA_PCIE_2#3) U8001.M19(VCC0P9_ANA_PCIE_1#2)
+VCC0V9_SVR: C8063.2 C8064.2 C8065.2 C8066.2 C8067.2 C8068.2 C8069.2 C8070.2 C8071.2 C8072.2 C8080.1 C8081.1 C8082.1 C8083.2 C8084.2 C8085.2 C8086.2 L8001.2 U8001.E8(VCC0P9_SVR_BRD_SENSE) U8001.H9(VCC0P9_SVR_PAB_ANA#6) U8001.H11(VCC0P9_SVR_PAB_ANA#1) U8001.H12(VCC0P9_SVR_PAB_ANA#2) U8001.H13(VCC0P9_SVR_PAB_ANA#3) U8001.H15(VCC0P9_SVR_PAB_ANA#4) U8001.H16(VCC0P9_SVR_PAB_ANA#5) U8001.J13(VCC0P9_SVR#1) U8001.L11(VCC0P9_SVR#2) U8001.L13(VCC0P9_SVR#3) U8001.M8(VCC0P9_SVR#4) U8001.M11(VCC0P9_SVR#5) U8001.M13(VCC0P9_SVR#6) U8001.N6(VCC0P9_SVR_DPAUX_ANA) U8001.N8(VCC0P9_SVR#7) U8001.N11(VCC0P9_SVR#8) U8001.N13(VCC0P9_SVR#9) U8001.R8(VCC0P9_SVR#10) U8001.R11(VCC0P9_SVR#11) U8001.R13(VCC0P9_SVR#12) U8001.R16(VCC0P9_SVR#13) U8001.T8(VCC0P9_SVR#14) U8001.T9(VCC0P9_SVR_USB_ANA#1) U8001.T11(VCC0P9_SVR_USB_ANA#2) U8001.T12(VCC0P9_SVR_PC_ANA#1) U8001.T13(VCC0P9_SVR_PC_ANA#2) U8001.T15(VCC0P9_SVR_PC_ANA#3) U8001.T16(VCC0P9_SVR#15)
+VCC3P3_LC: C8091.2 R8014.2 R8015.2 R8016.2 R8017.2 U8001.V6(VCC3P3_LC)
+VCC3P3_SX: C8052.1 C8078.2 C8079.2 R8008.1 R8009.1 R8010.1 R8020.1 R8021.2 R8022.2 R8025.1 R8034.1 R8036.1 R8037.1 R8039.1 R8041.1 R8043.2 R8044.2 R8045.1 R8098.2 U8000.8(VCC) U8001.F18(VCC3P3_SX#1) U8001.R6(VCC3P3_SX#2) U12002.5

# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCSTPLL: length 12.4
  IN4 w0.508: v1(182.51,128.41) 182.3,128.2 180.38,128.2 178.8,126.62 178.8,123.36 177.93,122.49 v1(175.09,122.49)
  BOTTOM w0.254: v1(175.09,122.49) 174.84,122.24 U9001.H30
  vias: v1(185.33,127.6)
+VDD_HDA: length 5.2
  TOP w0.203: U3600.3 341.63,14.94
  TOP w0.254: R3602.1 342.04,17.37 341.79,17.12 R3610.1 342.18,16.51 342.42,16.51 C3608.2 341.99,15.3 ; 341.63,14.94 341.99,15.3 ; 341.99,15.3 v1(341.99,15.31)
+VDD_I2S: length 15.8
  TOP w0.203: U3600.55 343.94,11.08 344.05,11.2
  TOP w0.254: 344.05,11.2 344.79,11.93 C3601.2 344.99,11.45 v1(344.91,11.38)
  IN2 w0.254: v1(333.41,12.06) 333.92,12.06 335.44,13.58 342.7,13.58 v1(344.91,11.38)
  vias: v1(334.8,12.69)
+VDD_IO: length 3.3
  TOP w0.203: U3600.13 337.63,14.92
  TOP w0.254: 337.63,14.92 337.63,14.99 v1(337.42,15.2) 337.34,15.28 C3605.2 R3606.1
+VIN: length 77.4
  TOP w0.381: v1(229.19,22.34) 229.19,18.33 228.59,17.73 PQ11005.1 225.39,17.73 222.76,15.1 220.02,15.1 219.77,15.36 219.77,15.92 220.4,16.55 220.4,18.3 220.88,18.78 PD11006.1
  TOP w0.508: PC11000.2 v1(256.16,15.17)
  TOP w1.016: 311.82,61.71 311.82,60.29 312.96,59.15 312.96,57.11 313.42,56.66 313.42,52.75 312.68,52.01 312.68,47.66 311.82,46.79 311.82,43.53 309.91,41.62 309.91,39.46 308.24,37.79 308.24,33.35 303.56,28.67 303.56,27.52 301.97,25.94 301.97,19.97 302.8,19.14 302.8,17.43 302.01,16.63 302.01,15.26 302.1,15.17 302.1,10.87
  vias: v1(74.84,51.08) v1(75.47,51.08) v1(76.11,51.08) v1(76.74,51.08) v1(100.11,71.34) v1(125.13,134.84) v1(139.61,150.2) v1(140.37,150.2) v1(141.13,150.2) v1(147.43,150.17) v1(148.19,150.17) v1(148.95,150.17) v1(156.88,150.17) v1(157.64,150.17) v1(158.4,150.17) v1(166.4,150.17) v1(167.16,150.17) v1(167.93,150.17) v1(192.01,51.93) v1(192.06,51.3) v1(192.64,51.93) v1(192.69,51.3) v1(193.73,53.81) v1(193.73,53.15) v1(206.15,41.62) v1(216.29,28.54) v1(236.23,155.28) v1(236.23,154.65) v1(236.23,154.01) v1(236.86,154.32) v4(98.69,81.88) v4(98.94,81.12) v4(99.22,82.39) v4(99.47,81.62) v4(99.73,83.02) v4(99.98,82.26) v4(115.07,115.76) v4(115.07,115) v4(115.07,114.24) v4(115.07,113.48) v4(119.18,116.14) v4(119.16,115.33) v4(119.16,114.52) v4(119.29,126.58) v4(119.29,125.82) v4(119.82,115.71) v4(119.82,114.92) v4(124.11,131.84) v4(124.09,131.03) v4(124.09,130.27) v4(134.83,144.36) v4(134.83,143.58) v4(135.01,141.01) v4(135.57,141.77) v4(146.21,158.84) v4(146.21,158.08) v4(157.77,158.46) v4(161.6,158.97) v4(162.41,158.97) v4(171.48,156.4) v4(172.24,156.4) v4(173.01,156.4) v4(173.77,156.4) v4(176.94,159.98) v4(177.71,159.98) v4(178.47,159.98) v4(179.23,159.98) v4(207.8,42.25) v4(207.8,41.49) v4(207.8,40.73) v4(208.57,42.25) v4(208.57,41.49) v4(208.57,40.73) v4(209.33,42.25) v4(209.33,41.49) v4(209.33,40.73) v4(216.85,32.35) v4(217.1,33.06) v4(217.2,31.66) v4(217.58,32.35) v4(217.89,33.03) v4(217.94,31.64) v4(218.35,32.35) v4(218.65,33.03) v4(218.73,31.64) v4(219.11,32.35) v4(219.41,33.03) v4(220.17,33.03) v4(220.91,33.09) v4(247.5,20.44) v4(247.5,19.67) v4(248.27,20.44) v4(248.27,19.67) v4(252.25,18.25) v4(252.56,17.46)
+VIN_1.05V:
  vias: v1(305.59,69.31)
+VIN_1.8VPCU:
  vias: v1(292.51,10.25)
+VIN_3VPCU:
  vias: v1(216.11,42.76)
+VIN_5V_USBSRC:
  vias: v1(207.42,35.02)
+VIN_BLIGHT:
  vias: v1(66.07,53.43) v1(66.07,52.8) v1(66.71,53.43) v1(66.71,52.8) v1(67.34,52.8) v1(68.61,51.78)
AGND: length 26.6
  TOP w0.203: U3600.39 340.03,5.55 v1(339.95,5.48) ; 338.74,5.74 338.43,6.05 U3600.35 ; 338.74,5.74 338.83,5.83 U3600.36 ; 338.74,5.74 v1(338.74,5.15)
  TOP w0.254: U3601.9 351.45,25.99 v1(351.19,26.25) 350.95,26.01 U3601.10 ; v1(356.17,19.04) 356.26,19.13 Q3603.1 ; U3601.19 v1(352.45,20.42) ; U3601.13 349.21,23.33 v1(349.13,23.26) ; v1(354.97,22.98) 354.62,23.33 U3601.3
  TOP w0.381: C3612.1 342.96,2.73 343.17,2.52 343.17,2.39 v1(343.24,2.33) 343.65,2.33 Q3600.1
  TOP w0.508: v1(356.88,24.33) 356.88,24.36 356.39,24.85 C3642.1 ; v1(354.74,18.71) 354.57,18.54 C3631.1 ; C3633.1 350.91,19.13 v1(351.05,18.99) ; C3636.2 v1(357.16,22.44) ; VC3601.2 v1(355.17,12.44) ; v1(355.38,8.22) VC3602.2 ; v1(356.17,17.36) 356.17,16.36 C3644.2 ; C3641.2 v1(356,6.45) 356.01,6.44 VC3603.2 ; v1(355.51,2.38) VC3600.2 C3640.1 ; C3639.1 v1(355.17,11.42) ; C3635.2 v1(357.16,21.3) ; C3643.2 353.81,9.94 v1(354.24,9.51) ; R3640.2 v1(359.32,14.57) ; C3637.1 348.53,23.39 348.67,23.26 v1(349.13,23.26) ; EC3602.1 354.31,8.46 v1(354.31,8.45) ; C3606.1 345.04,6.35 v1(345.01,6.32) ; C3607.1 v1(340.01,2.71)
  BOTTOM w0.508: EC3602.1 354.31,8.46 v1(354.31,8.45)
  vias: v1(339.38,3.65) v4(338.74,1.03) v4(341.28,1.03) v4(343.82,1.03) v4(346.36,1.03) v4(348.9,1.03) v4(351.44,1.03) v4(353.98,1.03) v4(356.52,1.03) v4(359.06,1.03) v4(361.6,1.03) v4(364.14,1.03) v4(365.28,14.44) v4(366.68,1.03) v4(366.88,5.17) v4(366.94,12.92) v4(367.06,10)
AGND_1.05V: length 15.1
  TOP w0.254: PC18015.2 305.46,61.22 304.94,60.7 PC18000.1 304.58,60.26 304.8,60.03 PR18013.1 305.06,59.63 v1(305.54,60.11) ; PR18010.1 307.31,66.08 306.51,66.08 305.95,66.63 PU18000.4
  TOP w0.508: v1(309.02,64.99) 308.9,64.86 PR18005.2 308.27,65.37 308.51,65.61 PR18014.2 307.88,65.88 307.87,65.87 PR18010.1
  IN2 w0.508: v1(309.02,64.99) 308.01,63.97 308.01,62.88 305.54,60.42 v1(305.54,60.11)
DV33_18: length 4.5
  BOTTOM w0.114: C7320.1 24.45,68.04 23.4,68.04 v1(23.27,68.16)
  BOTTOM w0.203: 26.18,68.23 26.31,68.36 U7301.18
  BOTTOM w0.508: 26.18,68.23 25.86,67.91 25.24,67.91 C7320.1
GND: length 3026.9
  TOP w0.152: v1(236.76,6.14) 237.01,6.14 237.5,5.65 U6004.4
  TOP w0.178: PU22000.11 v1(40.42,65.37) ; PU22002.11 v1(264.32,43.14) ; PU22001.11 v1(284.39,37.02) ; v3(358.2,118.58) 358.41,118.82 D7126.1 ; PU9501.15 PU9501.11
  TOP w0.191: U3007.73 64.43,61.8 63.93,61.3 U3007.53 ; U3007.18 v1(68.28,67.73) ; U3007.64 65.93,63.73 U3007.8 ; U3007.33 63.41,67.73 63.9,67.23 U3007.68 ; U3007.41 61.55,64.53 v1(61.5,64.48) ; U3007.57 65.53,61.47 65.43,61.57 U3007.62
  TOP w0.203: v1(346.23,7.39) 345.6,8.02 C3604.1 ; Q9037.4 244.21,51.25 244.48,51.53 244.94,51.53 245.21,51.8 Q9037.1 245.21,52.57 244.5,53.28 C6829.1 ; D7112.1 357.58,133.49 v1(357.03,133.49) ; C9295.1 164.88,108.26 v1(165.29,107.86) ; C1053.2 184.66,43.96 184.44,44.18 C1055.2 ; v1(164.39,107.87) 164.12,108.15 C9294.1 ; R6231.2 259.21,29.93 259.64,30.36 v1(259.61,30.39) 259.78,30.26 R6238.1 ; v1(261.3,27.37) 261.43,27.3 C6019.1 ; R18064.1 C8079.1 347.96,113.81 v3(348.08,113.93) ; C3601.1 345.73,11.93 v1(345.98,12.19) ; C9298.1 171.83,108.65 v1(171.7,108.52) ; v1(257.82,26.34) 258.18,25.97 R6234.1 ; C9292.1 157.54,108.32 v1(157.99,107.87) ; v1(155.89,44.16) 156.14,44.41 R1048.2 ; C3602.1 333.82,12.92 v1(333.41,13.33) ; v1(196.24,159.6) 196.3,159.54 C3645.2 ; C9289.1 169.96,107.96 v1(169.88,107.87) ; C9299.1 C9297.1 160.05,108.09 v1(159.82,107.86) ; C3616.1 332.57,6.62 v1(332.16,6.21) ; C9256.1 175.15,108.27 v1(175.17,108.25) ; v1(155.02,44.41) C1007.2 154.57,44.38 154.57,44.19 154.13,43.75 153.42,43.75 153.2,43.97 C1108.2 ; C1023.2 181.92,44.53 181.76,44.36 C1056.2 ; C9293.1 163.35,107.96 v1(163.45,107.87) ; v1(170.79,107.87) 170.72,107.94 C9288.1 ; v1(172.62,107.87) 172.71,107.87 173.13,108.29 173.13,108.68 172.98,108.83 C9290.1 ; v1(269.86,22.94) 269.67,22.94 269.4,22.67 C6030.1 ; v1(166.22,107.87) C9296.1 ; R6066.2 261.43,34.65 R6223.1 260.88,34.43 260.86,34.38 R6047.2 ; v1(155.24,107.26) 155.86,107.87 C9287.1 C9291.1 ; v1(251.24,51.37) 251.11,51.25 C6033.1 ; C6015.1 264.54,24.12 264.7,23.97 v1(264.7,23.33) ; v1(165.37,122.14) 165.47,122.04 C9300.1 ; v1(274.1,27.98) 274.4,27.68 C6002.1
  TOP w0.254: C9225.1 252.15,74.26 R9607.2 ; v3(273.89,69.03) 274.38,68.54 275.08,68.54 U9000.3 ; JDIM1003.235 v1(174.1,30.68) ; JDIM1003.57 127.6,30.91 v1(127.79,30.72) ; JDIM1003.247 177.1,30.95 v1(177.35,30.7) ; H7.1 101.14,12.92 101.14,15.73 100.78,16.09 99.04,16.09 97.17,17.96 97.17,37.9 93.63,41.44 93.24,41.44 90.72,43.96 90.72,46.69 88.3,49.11 82.07,49.11 77.78,53.41 v1(77.78,56.1) 77.78,59.63 v1(78.24,60.09) 78.57,60.42 80.83,60.42 81.72,59.52 81.72,57.64 80.68,56.6 80.68,52.67 82.19,51.16 88.21,51.16 92.01,47.36 92.01,44.49 93.75,42.74 94.14,42.74 98.46,38.43 98.46,18.49 99.57,17.38 101.8,17.38 v1(101.81,17.39) 102.06,17.13 102.06,16.93 105.05,13.95 105.05,9.88 102.09,6.92 100.56,6.92 100.11,6.47 100.11,5.65 v1(99.93,5.48) 99.3,4.84 v1(98.86,4.84) ; Q9002.1 190.94,94.05 v1(190.76,93.87) ; JDIM1003.201 165.6,31.08 165.79,30.89 165.79,30.85 v1(165.94,30.7) ; v1(125.79,30.67) 126.1,30.99 JDIM1003.51 ; v1(178.08,30.7) 178.1,30.73 JDIM1003.251 ; v1(344.33,131.66) 344.51,131.84 U7113.D3 U7113.C3 U7113.B3 ; v1(48.5,61.48) 48.47,61.51 48.47,61.91 48.61,62.05 U12003.3 ; v3(265.13,80.02) 264.96,79.85 264.16,79.85 U9003.3 ; v1(157.61,30.68) 157.1,31.19 JDIM1003.167 ; U3009.2 247.03,38.22 246.49,38.76 v1(246.49,38.95) ; CON6801.6 193.33,49.87 v1(193.2,50) ; JDIM1003.209 v1(167.6,30.68) ; R6172.2 249.71,47.97 v1(249.54,47.79) R6173.2 ; v1(131.35,30.7) 131.61,30.95 JDIM1003.73 ; JDIM1003.197 164.6,30.81 v1(164.52,30.72) ; U6500.32 298.55,53.83 298.05,53.33 ; JDIM1003.5 v1(114.6,30.68) ; PR11040.2 PR11041.1 228.25,19.52 228.61,19.17 v1(228.61,19.14) ; JDIM1003.181 160.6,33.29 v1(160.35,33.54) ; 298.05,53.33 U6500.33 295.05,53.83 U6500.9 ; 298.05,53.33 U6500.2 ; v1(256.78,38.95) 256.78,39.28 257.21,39.71 U3010.2 ; v1(175.17,118.48) 174.76,118.9 C9098.1 ; R9589.1 351.11,108.04 v1(351.01,107.94) 350.77,108.18 U12002.3 ; v1(360.24,117.13) 360.07,116.96 R17935.2 359.7,116.97 D7128.1 357.93,116.97 v1(357.66,116.7) ; U6002.2 253.77,49.12 U6002.9 ; C9251.1 264.95,21.24 v1(264.64,21.55) ; R6164.1 276.64,31.61 v1(276.99,31.26) ; JDIM1003.19 v1(118.1,30.68) ; v1(176.35,30.7) 176.1,30.95 JDIM1003.243 ; v3(358.25,116.17) 358.26,116.16 D7123.1 ; v3(359.34,130.72) 359.32,130.69 D7115.1 ; v4(186.09,155.92) 185.96,155.79 PU20004.3 ; JDIM1003.31 121.1,31.2 120.68,30.77 120.58,30.77 v1(120.56,30.75) ; v1(87.76,61.21) 87.76,61.66 88.28,62.18 PQ14002.1 ; v1(302.69,63.77) 302.81,63.89 PU18000.19 ; JDIM1003.171 158.1,30.99 v1(158.41,30.68) ; JDIM1003.89 v1(135.61,30.68) ; v1(139.85,30.68) 140.1,30.93 JDIM1003.107 ; JDIM1003.231 v1(173.1,30.68) ; JDIM1003.193 v1(163.6,30.68) ; U4102.3 337.15,69.39 336.94,69.18 336.94,68.8 337.47,68.26 v1(337.47,66.77) ; PC18014.1 308.77,63.84 v1(308.9,63.97) ; CON6801.5 193.83,49.76 v1(194.08,50) 194.33,49.75 CON6801.4 ; v3(358.25,113.53) 358.41,113.36 D7131.1 ; JDIM1003.99 138.1,31 v1(138.46,30.65) ; JDIM1003.185 v1(161.6,30.68) ; JDIM1003.213 v1(168.6,30.68) ; PQ23007.1 113.84,92.28 114.21,92.64 v1(114.46,92.64) ; v1(118.85,30.7) 119.1,30.95 JDIM1003.23 ; v1(119.72,30.7) 120.1,31.09 JDIM1003.27 ; C9099.1 146.72,109.5 v1(147.02,109.2) ; JDIM1003.217 v1(169.6,30.68) ; JDIM1003.61 v1(128.6,30.68) ; JDIM1003.239 175.1,30.95 v1(174.85,30.7) ; v1(123.22,30.7) 123.22,31.08 123.1,31.2 JDIM1003.39 ; JDIM1003.9 115.6,30.98 v1(115.3,30.67) ; Q9040.4 247.29,51.65 v1(247.3,51.65) ; JDIM1003.205 v1(166.6,30.68) ; v3(359.57,114.39) 359.45,114.28 D7125.1 ; U3008.2 v1(251.16,38.95) ; v1(245.27,48.43) 244.89,48.81 244.89,49.24 244.9,49.25 244.9,49.26 245.22,49.58 Q9040.1 ; v1(136.3,30.72) 136.3,30.88 136.61,31.18 JDIM1003.93 ; JDIM1003.189 v1(162.6,30.68) ; JDIM1003.69 v1(130.6,30.68) ; U49.3 244.45,35.2 244.25,35.4 244.25,37.3 244.89,37.94 v1(246.29,37.94) ; Q3606.1 349.83,5.05 v1(349.56,5.32) ; v1(338.87,22.35) 339.12,22.6 U3607.2 ; JDIM1003.175 v1(159.1,30.68) ; v1(172.36,30.68) 172.1,30.94 JDIM1003.227 ; D7109.1 359.04,131.04 359.28,131.28 v3(359.37,131.28) ; v3(351.9,111.77) 351.77,111.7 350.48,111.7 R8013.2 ; JDIM1003.85 v1(134.61,30.68) ; v1(132.85,30.7) 132.61,30.95 JDIM1003.77 ; v1(360.33,118.51) 360.16,118.68 R17934.2 ; v1(112.94,33.9) 112.94,33.7 113.6,33.03 JDIM1003.1 ; JDIM1003.65 v1(129.6,30.68) ; U12005.3 332.66,69.72 332.25,69.31 R4138.2 ; U6500.23 298.05,49.04 298.36,48.73 v1(298.36,48.6) ; JDIM1003.15 117.1,30.92 v1(117.3,30.72) ; U6002.6 v1(251.75,49.62) ; v1(122.56,30.7) 122.56,30.72 122.1,31.18 JDIM1003.35 ; v1(336.2,72.1) 337.13,73.02 U4103.3 ; JDIM1003.47 v1(125.1,30.68) ; JDIM1003.103 v1(139.1,30.68) ; U3606.2 v1(202.27,158.33) ; JDIM1003.81 v1(133.61,30.68) ; v1(110.98,97.09) 110.98,97.2 111.52,97.74 PU23000.3 ; JDIM1003.223 v1(171.1,30.68) ; v1(175.17,117.7) 175.17,117.69 C9094.2 ; JDIM1003.43 v1(124.1,30.68)
  TOP w0.279: PQ23007.4 112.54,89.14 112.47,89.07 112.47,88.82 112.82,88.47 v1(113.1,88.47) ; v1(108.36,88.48) 108.43,88.56 PQ23005.4 ; v1(227.29,86.22) 227.2,86.14 U2001.3 ; v1(61.63,52.73) U603.3 ; PQ23005.1 v1(109.73,92.74) ; PQ14002.4 86.25,63.48 85.76,63.97 v1(85.76,64.48) ; v1(61.4,47) 61.63,47.23 U603.13 ; U2008.3 225.47,83.54 v1(224.97,84.04)
  TOP w0.305: v1(99.02,2.28) 99.28,2.54 Q6351.4 ; R6513.1 290.98,49.22 C6504.1 ; v1(189.47,96.18) 189.58,96.18 190.11,95.65 Q9002.4 ; C2220.1 233.38,71.17 C12023.2 ; v1(253.27,50.76) 253.52,50.51 U6002.9 ; v1(257.05,70.07) 257.16,70.18 257.87,70.18 257.94,70.11 258.32,70.11 ; Q6351.1 98.58,3.54 98.9,3.86 98.9,4.62 98.86,4.66 v1(98.86,4.84) ; Q9046.1 54.89,60.89 v1(55.63,61.64) ; C6501.1 300,57 v1(300.26,56.73) ; v1(221.77,89.82) 222.09,89.82 222.2,89.7 222.2,88.91 221.93,88.64 221.28,88.64 221.03,88.88 Q2023.1 ; v1(50.83,44.67) 50.83,45.05 51.35,45.56 Q3000.4 ; v1(53.04,58.64) 53.04,58.84 53.69,59.49 Q9046.4 ; v3(262.72,73.43) 262.72,72.95 262.85,72.81 ; v1(293.4,37.81) 292.77,38.44 PQ12008.1 ; v1(53.12,48) 52.97,48 Q3000.1 ; C9248.1 269.6,67.14 268.9,67.85 v1(268.25,67.85) ; v1(234.98,45.18) 235.24,45.18 236.04,44.37 Q9036.1 236.51,44.8 236.76,45.05 237.27,45.05 237.51,45.3 Q9036.4 ; v1(264.76,14.56) 264.57,14.75 264.57,15.08 264.32,15.34 Q9039.4 263.84,15.34 263.56,15.62 263.56,15.97 263.18,16.34 Q9039.1 ; Q7130.1 364.48,123.03 H25.1 ; v1(239.88,40.96) 239.94,41.02 Q9038.1 239.94,42.14 240.19,42.38 240.69,42.38 240.94,42.64 Q9038.4 ; U7005.14 v1(20.99,100.8)
  TOP w0.356: v1(235.36,63.8) 235.16,63.6 C2215.1
  TOP w0.381: v1(253.12,75.35) 252.96,75.51 R9250.1 252.02,74.47 C9225.1 ; v1(63.79,52.16) 64.21,51.74 R628.2 ; v1(246.13,127.42) 246.16,127.39 C2586.1 ; C9220.2 254.61,68.23 v1(254.79,68.4) ; R3001.1 54.26,55.6 v1(54.26,54.95) ; v1(134.02,113.93) 133.9,113.82 Q9001.4 ; R9134.2 272.46,69.58 v1(272.65,69.58) ; v1(223.55,91.37) 223.43,91.5 R2030.1 ; C9096.2 174.16,115.89 v1(173.62,115.35) ; R7190.2 v1(349.94,132.42) ; C9092.2 169.08,108 v1(168.96,107.89) ; PR11033.2 247.48,7.12 v1(247.48,7) ; PR9509.1 v1(203.36,82.58) ; v1(217.18,139.4) 217.18,139.4 C2592.1 ; v1(246.36,121.45) C2536.2 245.99,122.18 245.38,122.79 R2516.2 ; PC9513.1 203.36,83.33 v1(203.36,83.22) ; v1(222.78,147.35) 222.73,147.4 C2618.1 ; v1(202.44,144.16) 201.62,143.34 C2527.2 ; PC22030.2 264.28,47.62 264.2,47.71 R9597.2 ; C8087.1 346.73,113.87 v3(346.78,113.93) ; R9509.2 261.33,5.85 v1(261.32,5.85) ; C2051.2 219.61,120.2 v1(220,120.6) ; C2006.2 208.76,143.52 207.49,143.52 ; C2530.1 238.08,125.91 v1(238.14,125.85) ; C2593.1 217.93,147.4 v1(217.98,147.35) ; v1(16.57,109.82) 16.57,109.69 16.42,109.54 16.42,109.35 16.22,109.15 C7010.3 15.93,109.38 v1(15.93,109.95) ; v1(236.4,71.41) 236.07,71.08 C2219.1 ; R7155.2 v1(340.13,130.89) 339.73,131.29 Q7146.1 ; PR20067.1 147.37,153.6 147.49,153.72 v1(147.49,154.23) ; C12023.2 233.01,71.17 v1(232.7,71.48) ; C12027.1 253.71,68.42 v1(254.27,68.98) ; PR20065.1 139.98,153.13 v1(139.99,153.12) ; C9250.1 310.17,62.19 310.75,62.78 v1(310.75,62.83) ; R9600.2 271.18,70.83 v1(271.18,71.08) 271.03,71.23 R9139.1 ; C8512.1 343.05,94 343.24,93.82 v3(343.24,93.56) 343.24,93.31 343.19,93.27 C8513.2 ; C2084.1 204.98,108.04 v1(204.97,108.05) ; R8684.2 337.01,98.82 v1(336.96,98.77) ; v1(330.11,3.27) 329.46,3.91 329.46,4.39 ; v3(258.31,83.92) 257.94,83.55 R9240.1 257.74,83.42 R9606.2 ; Q9001.1 131.39,111.92 v1(131.32,111.98) ; C7141.2 350.25,139.55 v1(350.4,139.4) ; v1(198.94,83.24) 199.3,82.89 PC9512.2 ; v3(345.48,115.23) 345.48,115.4 345.21,115.67 C8053.1 ; PR10027.1 336.79,146.27 336.66,146.39 PR10034.2 336.18,146.25 335.87,145.94 v1(335.87,145.53) ; v1(225.62,87.69) 225.62,88.13 226.51,89.03 Q2022.1 ; v1(254.29,32.2) 254.42,32.32 C858.1 254.44,32.98 255.35,32.98 R910.1 255.48,32.68 v1(255.96,32.2) ; C2229.1 221.91,83.47 v1(222.54,82.84) ; R7324.2 352.14,144.04 v1(352.48,143.7) ; R2501.2 199.63,141 v1(198.78,140.15) ; v1(339.41,19.53) 339.61,19.53 339.9,19.82 C3022.1 ; R6826.2 242.47,43.92 Q6805.1 242.47,45.53 v1(242.49,45.56) ; v3(348.08,113.93) 347.96,113.93 347.68,114.21 C8062.1 ; v1(233.96,65.14) 233.41,64.59 Q2016.1 ; C9249.1 v1(199.82,23.69) ; v1(255.96,32.2) 256.52,32.76 C859.1 ; v1(255.96,32.2) 255.23,31.47 VC6000.2 ; v1(264.93,57.6) 264.39,58.13 264.39,58.17 R2227.1 ; v1(341,132.58) 341.28,132.3 C7153.1 ; v1(164.7,96.35) 165,96.35 165.5,95.85 C9085.2 ; PC9507.1 195.45,81.2 v1(195.05,81.6) ; R9213.1 260.62,77.58 v1(261.35,78.32) ; v1(150.1,44.97) 150.65,44.42 C1110.2 ; v1(224.19,91.37) 224.44,91.63 R2096.1 ; v1(216.95,88.58) 216.95,88.31 216.59,87.95 215.95,87.95 Q2008.1 ; Q7151.1 359.88,121.88 v1(360.43,121.33) ; v1(189.26,51.73) 189.06,51.93 188.25,51.93 187.62,51.31 Q6800.1 ; C9000.2 165.24,94.44 v1(164.7,94.44) 164.77,94.52 ; R9372.1 247.61,80.63 v1(247.17,81.07) ; R2057.2 217.21,87.7 217.58,88.07 v1(217.58,88.58) 217.96,88.58 C2166.1 ; R3010.1 51.48,50 v1(50.78,50) ; C9083.2 159.2,108.15 v1(158.9,107.86) ; v1(241.96,56.81) 241.64,56.81 Q6801.1 ; v1(336.96,96.74) 337.04,96.81 R8683.2 ; PC12011.1 v1(229.04,10.48) ; v1(337.34,17.52) 336.62,17.52 C3027.1 ; PR20069.1 155.22,153.7 155.37,153.85 v1(155.37,154.23) ; v1(274.2,25.01) 274.35,25.16 C6031.1 ; Q6802.1 238.93,61.82 v1(239.55,62.45) ; PC9515.1 203.11,85.67 v1(203.57,86.13) 202.85,86.85 PC9514.2 ; Q2017.1 233.77,87.48 v1(233.94,87.64) ; C6500.1 R6509.2 295.36,58.05 296.2,58.89 v1(296.2,59.2) ; PR16019.1 101.37,34.14 v1(101.63,33.87) ; R4119.1 343.07,75.64 v1(342.89,75.82) ; v1(247.76,118.63) 247.76,119.29 C2539.1 ; C2577.2 218,150.33 v1(217.58,149.91) ; C2542.1 240.76,116.02 240.76,116.52 v1(240.77,116.53) 241.21,116.98 C2587.1 ; v1(163.5,154.23) 163.5,153.25 PR20071.1 ; v1(250.06,79.97) 250.23,79.8 250.95,79.8 251.38,80.23 251.87,80.23 252.51,80.86 252.51,82.06 C9232.1 ; v1(355.68,27.14) 355.93,27.39 R10012.2 v1(356.39,26.51) ; PR18014.1 309.66,65.88 v1(309.91,66.13) ; v1(49.98,56.52) 50.42,56.08 C3017.2 ; C2222.1 206.66,121.47 v1(205.86,122.27) ; C7140.2 348.27,139.55 v1(348.14,139.41) 348.11,139.38 348.11,138.83 347.95,138.66 PR10006.2 ; C2540.1 243.84,115.7 v1(243.84,116.54) 243.84,116.71 243.36,117.18 C2595.1 ; C3084.2 59.2,62.89 v1(59.7,63.39) ; v1(243.87,56.8) 243.87,56.39 R6810.2 ; C2541.2 238.05,116.11 v1(238.05,116.51) ; v1(175.17,111.4) 174.95,111.61 C9100.1 ; v1(192.26,158.46) 192.25,158.47 PC24000.2 ; Q6803.1 242.21,48.01 v1(242.3,48.1) ; v1(307.49,42.24) 307.46,42.26 PR12027.1 ; R9381.2 258.48,51.32 v1(258.71,51.55) 257.68,52.58 RV6000.2 ; D7100.2 358.56,109.32 ; v1(248.83,49.24) Q6005.1 ; v1(259.09,73.96) 258.46,74.6 R9127.1 258.25,75.47 258.33,75.56 258.33,75.8 258.25,75.88 258.25,76.18 258.24,76.18 R18043.2 ; PC16012.1 297.8,13.88 298.57,13.11 PR16010.2 298.8,13.2 v1(299.19,13.2) ; v1(238.53,109.92) 237.86,109.92 237.67,110.1 C2546.2 ; Q6004.1 249.59,45.9 v1(249.38,45.68) ; v1(222.19,93.53) 222.19,94.23 R2024.1 ; R9220.2 261.29,61.03 261.29,59.98 v1(261.42,59.85) 261.5,59.76 C2230.1 ; C2617.1 222.67,149.06 v1(222.78,148.95) ; PR12026.1 295.56,33.81 PR12032.1 296,33.84 296.2,33.64 v1(296.2,33.67) ; R9376.2 264.44,71.88 v3(264.2,71.88) ; v1(220.03,122.3) 220,122.27 R2012.1 ; C9219.2 250.45,65.47 v1(250.45,65.15) ; EC3604.1 340.32,17.94 v1(339.76,17.37) EC3605.1 ; C6001.2 276.71,27.71 v1(277.03,27.71) ; 266.27,65.37 266.37,65.27 v1(266.94,65.27) 267.06,65.39 R9216.2 ; R2502.2 223.35,140.76 v1(223.57,140.99) ; R9512.2 191.58,21.52 191.09,22.01 v1(190.81,22.01) ; v1(341.41,131.28) 342.16,131.28 R7327.2 ; v1(224.38,146.55) 224.27,146.66 C2619.1 ; v1(233.62,73.27) 233.77,73.12 R2121.2 ; v1(235.24,60.14) 235.89,60.79 C2216.1 ; v1(250.93,121.01) 251.29,121.38 C2538.2 ; v1(292.23,49.49) 291.75,49.98 C6504.1 ; v1(49.05,44.55) 49.55,45.05 Q3010.1 ; v1(266.12,32.04) 266.85,31.32 RV6001.2 ; v1(310.72,60.89) 310.61,60.89 310.32,61.18 R9288.1 ; 267.78,64.78 267.78,64.48 267.67,64.38 v1(267.67,64.04) ; C2217.1 234.1,89.63 234.6,90.13 v1(234.6,90.38) 234.6,90.39 ; v3(267.88,69.01) 267.84,69.05 R9366.2 ; v1(165.43,120.52) 165.25,120.7 C9149.2 ; v1(331.1,51.75) 330.03,50.69 CON9000.2 ; v1(226.97,143.87) 226.76,143.66 R2500.1 ; C2588.2 250.13,123.15 v1(250.13,124.21) 250.17,124.17 C2581.1 ; PC11025.2 250.38,8.52 v1(249.71,8.52) 249.6,8.41 PC11026.2 ; v3(346.78,112.63) 346.73,112.58 C8063.1 ; PC9506.2 199.19,89.21 v1(199.55,89.57) ; v1(259.49,78.75) 259.49,78.73 259.57,78.65 259.57,78.4 R9154.2 ; v1(241,58.84) 240.95,58.89 R6823.2 ; v1(300.36,35.66) 300.88,35.15 PR12029.1 302.17,34.63 302.42,34.89 PQ12006.3 ; PQ8004.1 234.21,150.16 v1(234.73,149.65) ; v1(221.27,82.84) 221.27,82.25 C2231.1 ; v1(243.75,99.34) 244.06,99.03 R2522.1 ; v3(235.22,74.75) 235.86,74.75 236.12,74.5 Q2018.1 ; C2585.1 245.9,104.35 C2553.2 245.58,104.52 245.19,104.92 244.18,104.92 243.76,104.5 R2521.2 ; 266.68,60.37 267.13,59.91 v1(267.26,59.91) ; v1(333.2,68.95) 333.18,68.92 R4138.2 ; C2007.2 203.37,140.74 v1(203.58,140.95) ; Q6003.1 253.64,44.14 v1(253.65,44.16) ; PQ12007.3 303.97,38.72 303.99,38.7 v1(304.2,38.7) ; C2504.2 219.96,147.57 219.74,147.36 v1(218.77,147.36) ; C3207.2 v1(357.54,83.02) ; PC9046.2 199.05,56.22 v1(198.91,56.35) ; C9077.2 174.44,110.55 v1(175.17,109.82) 174.91,109.82 174.54,109.45 C9091.2 ; v1(177.77,121.63) 177.97,121.83 C9076.2 ; v1(246.92,121.01) 247.58,121.67 247.58,122.26 C2537.2 ; C4206.2 342.89,28.55 C4208.2 341.87,29.68 v1(341.99,29.81) ; v1(219.58,144.95) 219.62,144.91 C2510.2 221.44,144.09 C2529.2 ; VC3200.2 v1(358.55,83.02) ; v1(161.65,107.87) 161.69,107.92 C9093.2 ; U6003.2 v1(268.26,13.17) ; C2576.2 225.17,148.96 v1(225.18,148.95) ; C9054.2 126.96,126.91 ; v1(246.29,71.46) 247.32,71.46 C12025.1 ; C3085.1 53.33,48.63 v1(53.12,48.63) ; PC11020.2 237.73,8.65 v1(237.4,8.98) ; v1(225.18,143.35) 225.18,143.78 225.08,143.88 C2599.1 ; C9084.2 166.22,108.37 v1(166.22,107.87) ; v1(223.04,93.53) 223.17,93.66 223.17,94.19 R2027.1 ; C6029.2 v1(262.67,13.17) ; v1(175.17,112.97) 174.81,112.97 C9095.2 ; v1(328.33,24.86) 328.33,25.44 329.11,26.23 329.11,26.87 ; C6829.1 243.99,54.19 242.12,54.19 241.97,54.04 v1(240.9,54.04) 240.9,53.23 Q6804.1 ; Q2023.4 222.79,87.51 v1(222.79,86.62) 222.19,86.62 R2023.1 ; v1(257.55,65.59) 257.1,65.13 R2228.2 ; v1(336.02,14.63) 335.73,14.34 EC3603.1 ; v1(223.22,82.84) 223.22,82.67 222.54,81.99 R2128.2 222.54,81.79 221.98,81.22 221.98,79.89 C2228.1 ; C3608.1 v1(342.81,17.78) ; C3600.1 v1(343.82,17.65)
  TOP w0.406: R2504.1 C2511.1 215.22,144.3 v1(215.4,144.12) ; C2516.1 217.08,143.3 v1(217.16,143.37) ; C2508.1 215.3,146.07 v1(215.38,146.15) ; C2512.1 207.75,143.78 v1(207.31,143.34) ; v1(207.31,142.02) 207.32,142.04 C2517.1 ; v1(17.41,87.57) 16.75,88.23 16.16,88.23 15.91,87.97 C7011.3 16.4,87.69 v1(16.77,87.31) ; C2522.1 207.95,139.32 v1(207.2,139.32) ; v1(215.35,139.85) 215.24,139.75 C2521.1 214.53,140.77 C2620.1 ; v1(206.86,146.46) 207.37,145.96 C2509.1 ; CON7301.20 v1(12.57,45.25)
  TOP w0.457: v1(338.21,17.52) 338.36,17.37 EC3600.1 ; U7002.8 U7002.3 356.27,73.88 356.65,74.26 v1(356.88,74.26)
  TOP w0.508: v1(50.22,59.53) 50.22,60.13 C12037.1 ; R4020.1 v1(11.69,136.96) ; C2580.1 249.34,117.77 v1(249.34,117.77) ; v1(220.58,15.89) 221.51,16.82 PR11042.2 221.51,18.22 222.36,19.06 PR11043.2 ; PC22024.2 264.67,37.14 v1(264.67,36.67) ; C4204.2 C4211.1 312.61,11.23 v1(312.71,11.14) ; C3644.1 354.68,16.09 354.26,16.52 v1(354.26,16.96) ; v1(200.31,45.05) 199.93,45.43 197.02,45.43 C6825.1 ; PC18005.2 v1(313.09,63.34) ; v1(111.79,20.54) 111.79,22.84 JDIM1003.261 ; C9002.2 129.19,116.93 128.84,116.58 v1(128.84,116.17) ; v1(149.76,107.88) 149.77,107.89 C9302.2 ; PC23008.2 188.25,141.6 PC23007.2 187.26,144.72 ; v1(245.49,128.32) 245.49,128.85 C2533.1 R2513.1 ; v1(118.78,94.71) 118.49,94.42 PC23013.2 ; v1(262.77,61.81) 262.56,61.81 262.2,62.17 R9253.2 ; CON6352.6 83.48,55.34 v1(83.09,54.95) ; C2514.2 203.26,136.65 v1(203.58,136.97) ; R9014.2 134.77,112.04 v1(135.21,111.6) ; v1(204.95,106.4) 205.14,106.22 C2155.1 C2159.1 203.37,105.6 v1(203.28,105.52) ; v1(353.35,81.88) U7003.2 v1(353.35,83.76) ; C3667.2 218.09,151.6 v1(218.22,151.47) ; C7305.2 282.07,8.12 v1(282.35,7.84) ; v1(246.35,102.82) 246.66,103.13 C2585.1 ; D7304.1 37,59.18 v1(37.37,59.55) ; C2225.2 203.23,120.49 202.48,121.24 v1(202.48,121.37) ; C3664.1 v1(211.49,155.79) ; v1(347.55,10.16) 347.17,9.77 C3609.1 ; R622.2 66.45,49.98 v1(66.61,49.82) ; v1(220.53,132.42) 220.53,132.58 220.08,133.02 R2011.1 ; R632.2 v1(56.27,48.6) ; R9602.2 261.14,74.51 v3(261.14,74.93) 261.14,75.14 C9217.1 ; v1(236.76,9.87) 236.63,9.74 236.62,9.74 236.39,9.51 PC11024.1 ; PC22015.2 42.86,60.29 v1(42.96,60.19) ; 326.41,4.28 325.15,4.28 v1(325.03,4.15) ; C1056.2 181.76,43.61 v1(182.07,43.3) ; PC14007.2 91.51,66.85 v1(91.24,66.59) ; v1(225.24,34.12) PC13040.2 ; v1(189.26,51.73) 189.28,51.75 CON6801.10 ; C9279.2 144.17,134.84 v4(143.47,134.84) ; R629.2 v1(65.18,44.29) ; C2548.1 240.18,110.16 v1(239.94,109.92) ; PR12036.1 v1(224.8,13.81) ; PR10028.2 341.9,148.61 v1(341.9,147.93) 341.91,147.93 PR10016.2 ; PC9805.2 200.95,51.78 v1(201.33,51.78) ; PR23017.2 114.84,91.15 v1(114.46,91.53) ; v1(197.97,145.76) 197.91,145.82 C2608.1 ; PC22020.2 40.93,67.65 v1(40.42,68.16) 39.91,67.65 PC22019.2 ; v1(154.11,140.1) 153.9,140.31 C9157.2 ; PC22018.2 37.84,60.39 v1(37.65,60.2) C7329.1 ; v1(154.33,108.52) 153.97,108.89 C9082.2 ; R4019.2 v1(15.4,110.83) ; v1(246.49,38.95) 246.35,38.82 R9329.2 ; v1(319.44,12.28) C5100.1 C5105.1 C5104.1 ; C2582.1 243.86,109.07 v1(243.73,108.94) ; U3001.2 47.43,56.4 v1(47.48,56.45) ; C7302.2 284.21,7.99 v1(283.98,7.76) ; C2549.1 241.96,110.04 v1(241.84,109.92) ; C3626.1 R3631.1 348.51,9.78 v1(348.6,9.87) ; C7022.1 v1(20.35,100.8) ; v1(111.77,61.72) 113.18,63.13 JDIM1000.261 113.18,67.32 112.68,67.82 v1(112.27,67.82) ; v1(255.86,12.13) 255.86,12.23 255.44,12.66 PC11001.1 ; v1(257.55,65.59) 257.84,65.87 257.84,66.15 R9074.1 ; v1(30.72,80.25) 30.18,79.72 Q7301.1 ; v1(287.74,16.12) 287.66,16.04 EC9033.1 ; R8012.1 339.96,118.08 v3(339.5,117.63) ; v1(299.35,16.91) PR16007.1 ; v1(346.23,7.39) 346.49,7.64 C3603.2 ; v1(101.51,19.78) 101.48,19.8 101.48,21.07 101.94,21.53 PC16017.1 ; v1(31.86,126.33) 31.53,126.33 31.16,125.96 R4008.1 ; R6082.1 275.7,24.4 v1(276.38,23.71) ; v4(185.91,152.36) 185.41,151.86 PC17012.1 ; R3649.1 220.44,156.29 v1(220.16,156.57) ; v1(227.12,10.51) PC12010.1 PR12035.1 ; C2501.2 214.99,149.36 215.14,149.51 215.23,149.51 v1(215.53,149.8) ; R9117.1 242.71,81.57 v1(242.25,82.03) ; v1(195.23,89.11) 195.55,88.79 PC9511.2 194.66,88.46 PC9510.2 ; v1(54.9,50.81) 54.9,51.06 55.35,51.52 C3016.1 56.17,51.52 C653.1 C635.1 ; v1(114.82,20.54) 114.82,22.59 JDIM1003.261 ; C2050.1 202.35,105.64 v1(202.47,105.52) 202.33,105.38 C2045.2 ; v4(156.62,133.31) 156.12,133.31 C9266.2 ; v1(262.59,64.52) 262.59,64.35 R9157.1 ; C3029.1 v1(43.72,53.56) ; PC16007.2 v1(290.23,26) ; C7311.2 v1(277.53,10.12) ; C7304.2 v1(282.2,15.38) ; v1(139.99,153.12) PC20000.1 ; v1(214.15,155.77) 214.54,155.39 C3661.1 ; C7301.2 283.14,7.84 v1(283.22,7.76) ; v1(251.85,108.1) 251.91,108.05 C2604.1 ; C2591.1 249.32,125.82 v1(249.33,125.81) ; PC12008.1 296.84,39.2 297.09,38.95 v1(297.09,38.78) PC12009.2 ; v1(244.51,114.49) 244,113.98 C2612.2 ; R6825.2 241.85,51.53 241.71,51.67 v1(241.71,51.97) ; C2525.2 215.03,136.47 v1(215.36,136.8) ; EC9041.2 85.12,73.18 EC9042.1 85.93,73.57 v1(86.24,73.88) ; C8073.1 340.01,108.88 v1(340.19,108.7) ; Q2500.1 v1(230.54,143.57) ; C9278.2 v1(147.61,131.66) ; C2622.1 195.39,146.15 v1(195.37,146.13) ; R6404.2 128.56,111.61 v1(128.81,111.85) 127.67,111.85 127.41,112.1 U6402.2 125.51,112.1 124.56,113.05 U6402.4 ; C9238.1 253.67,70.03 v1(253.67,69.5) 253.61,69.43 C12026.1 ; v1(246.29,71.46) 245.77,70.95 R9266.1 ; v4(216.06,45.89) 216.73,45.89 PC13028.1 ; C2594.1 253.71,128.24 ; C7201.2 v1(288.2,9.11) ; C9264.2 C9268.2 v1(164,140.43) C9267.2 C9275.2 v1(166.28,140.43) C9265.2 ; v1(181.26,27.01) 181.26,24.71 JDIM1003.262 180.15,24.86 v1(180.15,27.01) ; C6352.2 v1(104.93,2.33) ; C9231.1 245.47,68.5 v1(245.44,68.48) ; C6353.2 105.71,5.54 105.72,5.55 v1(106.08,5.55) ; C3047.2 60.61,60.03 v1(60.1,60.03) 59.6,60.03 R3040.1 C3046.2 ; v1(27.59,128.99) 27.59,128.72 28.2,128.11 R4012.2 ; C2590.1 251.08,126.46 v1(250.93,126.61) ; v1(250.92,117.01) 251.33,116.6 C2544.2 ; v1(158.91,147.12) 158.91,145.62 PC20034.2 ; v1(231.68,90.39) 231.68,89.54 C2149.1 ; v1(245.34,108.16) 245.35,108.17 C2550.1 ; 284.5,39.15 284.97,38.68 PC22017.2 ; 284.5,39.15 PC22016.2 ; 284.5,39.15 v1(284.5,39.18) ; v1(247.42,102.67) 246.92,102.17 C2603.1 ; R9328.2 253.79,36.57 v1(253.88,36.67) ; v1(198.99,50.51) 199.21,50.73 PC9806.2 ; v1(35.59,64.1) 35.85,64.1 D7305.1 C7328.2 ; R9133.2 v1(320.43,13.1) ; PC20046.1 v1(164.23,159.72) ; v1(288.2,9.87) 288.58,10.25 C7200.2 ; C2551.2 246.79,105.6 v1(246.93,105.74) ; PQ12003.1 269.75,6.06 v1(269.22,6.59) ; C2611.1 198.03,136.1 v1(197.98,136.15) ; v1(191.29,72.73) 191.19,72.84 189.92,72.84 189.65,73.11 PQ9502.1 ; R3075.1 v1(63.79,57.51) ; v1(286.93,32.14) 286.88,32.09 PC22014.2 ; C9282.2 v1(138.84,140.93) ; v1(162.85,134.46) C9280.2 ; R3077.1 66.83,57.58 v1(66.76,57.51) ; v4(205.26,157.44) 205.53,157.44 C3665.2 ; C7313.2 C7312.2 v1(280.17,15.38) ; v1(33.2,61.43) 33.87,60.77 CON7301.3 ; R9221.2 258.35,57.81 v1(258.47,57.69) ; v1(247.96,109.91) 247.82,110.06 C2547.1 ; v1(320.33,9.08) 320.33,9.68 C9301.2 ; C9159.2 148.49,140.31 v1(148.11,140.68) 147.87,140.43 C9274.2 146.96,140.43 v1(146.72,140.68) 146.34,140.31 C9148.2 145.82,140.31 v1(145.32,140.81) C9277.2 ; C2607.1 206.21,147.35 v1(205.98,147.35) ; v1(119.41,94.71) 119.41,94.08 PC23012.2 ; Q3005.1 58.1,55.46 v1(57.43,54.8) ; v1(238.05,108.01) 238.05,108.19 C2583.1 ; R9249.1 v1(251.37,76.93) ; C5104.1 C5102.1 v1(319.31,9.23) ; C5104.1 v1(319.31,10.25) ; v1(250.92,118.63) 250.93,118.62 C2589.2 ; v1(249.53,75.24) 249.72,75.42 249.72,76.12 ; v1(238.67,6.54) 238.74,6.54 238.98,6.31 PC11022.2 ; PC9509.2 197.91,80.88 198.29,81.25 PC9502.2 v1(198.29,83.27) ; C2615.1 201.97,149.58 v1(201.71,149.32) C2606.1 ; C4207.1 307.38,13.31 v1(307.88,13.81) 308.38,13.31 C4214.1 ; C9189.2 312.23,13.79 v1(312.07,13.63) 312.07,12.74 312.02,12.69 C4216.2 ; C9306.1 242.7,73.75 v1(243.24,73.22) ; C2552.2 249.9,102.7 v1(250.01,102.59) ; C9284.2 143.41,140.93 v1(143.54,140.93) ; v1(113.18,20.55) JDIM1003.261 ; v1(64.29,44.29) 64.29,45.04 C621.1 ; v1(260.94,35.45) 261.26,35.13 R6223.1 ; PC20036.1 v1(156.11,159.68) ; R635.1 56.97,46.37 v1(56.42,46.37) ; v1(341.59,4.18) 341.2,3.8 C3618.1 ; R2116.2 235.74,86.42 235.99,86.66 C2218.1 237.05,86.66 v1(237.39,86.32) ; v1(168.05,147.12) 168.57,146.61 PC20044.2 ; PR23012.2 111.83,90.04 v1(111.83,90.6) ; v1(187.48,73.75) 187.61,73.62 PR9520.2 ; v1(102.74,69.68) 102.61,69.81 PC14017.1 ; v1(163.5,154.23) PC20042.1 ; PC19001.2 v1(123.35,155.03) ; PC22029.2 265.97,37.17 v1(265.97,36.67) ; ESD4200.2 v1(306.48,10.12) ; v1(249.33,101.74) 249.24,101.83 C2602.1 ; C3605.1 v1(337.34,17.52) ; C7152.1 355.3,143.27 v1(355.48,143.45) ; PC16013.1 v1(103.28,20.41) ; C9269.2 v1(156.5,140.31) C9273.2 155.73,140.3 155.12,140.3 v1(155.11,140.28) ; C2503.2 206.95,148.79 v1(207.16,148.58) ; PQ9501.1 v1(189.51,68.64) ; v1(264.27,46.24) 264.83,45.68 PC22028.2 ; v1(264.27,46.24) 263.86,45.84 PC22027.2 ; v1(264.27,46.24) 264.27,47.07 PC22030.2 ; D7303.1 v1(37.12,52.16) EC9050.2 ; CON7301.13 v1(33.23,52.11) ; v1(198.18,50.51) 197.48,51.21 CON6801.9 ; PR12037.1 234.87,15.04 v1(235.21,14.7) ; v1(175.17,120.06) 175.13,120.1 C9086.2 ; v1(250.93,100.14) 251.18,100.14 C2613.2 ; CON7301.6 34.56,68.27 35.31,69.03 35.66,69.03 35.72,68.97 v1(35.74,68.97) 35.92,68.97 35.98,68.92 D7300.1 EC9047.2 ; v1(140.49,159.73) 140.87,159.73 PC20012.1 ; v4(143.47,133.31) 144.3,133.31 C9271.2 ; U3000.2 51.09,53.18 v1(50.55,52.64) ; PC22012.2 284.39,30.32 v1(284.13,30.06) ; v1(258.05,5.86) 258.05,5.25 256.7,3.9 253.91,3.9 PQ11003.1 ; D7306.1 v1(37.62,74.31) ; v1(202.38,145.17) 202.84,145.64 C2614.1 ; R9271.1 245.14,78.45 245.14,79.33 v1(245.52,79.71) ; v1(199.58,148.95) 200.04,149.41 C2505.2 ; C2063.1 215.04,121.51 v1(215.17,121.64) ; v1(58.71,68.95) 58.86,68.8 R3061.2 R3057.1 ; CON7301.17 v1(33.23,51.01) ; C9190.2 306.97,18.26 v1(306.86,18.37) ; PC11027.1 246.55,11.57 PU11000.33 ; v1(147.49,154.23) PC20018.1 ; PC22013.2 40.15,59.52 v1(39.78,59.88) ; R9011.2 v1(134.77,113.88) ; v1(281.85,32.22) 281.97,32.09 PC22021.2 ; v1(59.52,58.16) 59.97,58.6 R3076.1 ; C6355.2 v1(100.62,2.33) ; C3026.2 44.41,58.58 v1(44.41,58.13) ; C2535.2 244.2,126.95 v1(243.73,127.42) 243.24,126.92 C2531.1 ; v4(205.01,153.29) 205.05,153.24 C3668.2 ; R2518.1 246.04,110.09 v1(246.21,109.92) ; PR17001.1 v1(188.75,156.43) ; PD11002.2 243.23,18.01 v1(243.15,18.09) ; v1(35.47,71.6) D7301.1 EC9048.2 ; v1(202.85,33.11) 203.62,33.11 PC15012.1 ; PC22022.2 263.68,37.02 v1(264.04,36.67) ; v1(244.86,6.77) 244.86,7.17 PR11039.2 ; C3666.2 v1(218.09,154.27) ; v1(141.13,147.12) 141.9,146.35 PC20010.2 ; v1(241.38,108.14) 241.32,108.19 C2584.1 ; C9246.1 235.34,65.76 v1(235.34,65.72) ; C9281.2 v1(154.59,131.66) ; v1(248.42,78.45) 248.42,78.6 247.7,79.31 R9544.1 ; C3610.2 v1(347.38,14.47) ; R9076.1 259.67,68.54 v1(259.67,68.72) ; v1(250.13,106.54) 250.13,106.53 C2139.2 ; v1(351.44,78.06) C7009.1 ; J9000.2 303.44,15 v1(303,14.57) ; v1(339.5,66.77) 340.26,67.52 R18066.2 ; C9270.2 v1(143.92,131.66) ; v1(319.77,5.17) C5101.1 ; v1(254.27,68.98) 254.27,69.1 C9237.1 ; v1(352.36,9.84) 352.58,10.07 C3643.1 ; C6351.2 v1(101.63,2.33) ; v1(78.29,64.91) 78.14,64.76 Q3003.1 ; PC20020.2 150.41,146.58 ; Q3004.1 56.9,64.94 v1(57.23,65.27) ; C7015.1 C7018.1 23.22,94.91 v1(23.91,95.59) 24.29,95.59 24.8,96.1 R7016.1 ; R2109.2 232.6,62.73 232.59,62.73 v1(232.21,62.35) 231.3,62.35 230.68,61.73 CON6800.43 ; C2579.1 246.04,116.4 v1(246.05,116.39) ; PC23005.2 191.15,135.42 v4(191.22,135.42) ; v1(162.85,133.19) C9272.2 ; R9078.1 267.53,61.16 267.97,60.71 v1(268.02,60.71) ; C4210.1 v1(310.28,13.31) ; EC3602.2 v1(352.38,8.96) ; v1(332.16,6.21) 332.31,6.07 C3617.2 ; PU11001.2 v1(233.46,7.13) ; PC23006.2 190.67,140.87 v4(191.22,140.32) ; C2543.1 248.13,115.61 v1(248.13,116.35) ; CON7301.21 v1(10.19,76.29) ; R2226.2 76.1,62.08 76.73,61.44 v1(76.73,61.08) ; v1(180.75,67.53) 180.78,67.5 JDIM1000.262 v1(180.78,61.75) ; C1055.2 184.44,45.84 v1(184.54,45.94) v1(184.54,46.57) ; v1(183.8,152.24) 184.43,152.86 PC20047.2 ; PC19002.2 131.22,152.61 v1(131.22,152) ; v1(104.14,20.16) 104.55,20.57 PC16014.2 ; PC20022.1 v1(147.48,159.06) ; v1(50.86,59.53) 50.86,58.61 51.71,57.76 C3019.2 C3020.2 C3018.2 C3021.2 55.15,58.43 55.33,58.61 v1(55.33,58.59) ; v1(38.64,80.1) 37.75,80.99 Q7300.1 ; v1(249.95,110.48) 250.31,110.85 C2545.2 ; R630.2 v1(56.27,47.59) ; v1(21.11,88.74) 21.47,89.09 U7004.2 ; C9283.2 v1(139.86,140.93) ; C7307.2 C7308.2 280.7,10.33 280.52,10.15 v1(280.52,10.12) ; R10041.1 R10040.1 ; CAS37.1 161.98,91.05 ; C9255.1 171.47,140.04 v1(170.97,139.54) ; C3642.2 v1(355.59,26.43) ; v1(259.09,64.61) 259.09,64.07 259.08,64.07 R2136.2 ; C2534.1 248.29,128.72 v1(247.97,128.4) ; v1(18.57,101.56) R7013.1 R7011.2 ; v1(249.78,128.38) 249.87,128.47 C2532.2 ; v1(106.46,29.17) 106.08,29.17 105.82,28.92 PC16019.2 ; U4001.25 25.43,134.46 v1(25.18,134.71) ; v1(239.43,116.53) 239.44,116.54 C2578.1 ; CON6352.5 v1(77.78,56.1) ; R619.2 v1(66.58,47.97) ; PU9502.2 201.68,81.75 v1(202.09,81.34) ; C3662.1 v1(213.52,155.77) ; v4(156.62,132.55) C9276.2 ; PR16001.1 v1(289.08,15.13) ; C7300.2 v1(285.9,15.37) ; CON6800.44 v1(230.68,34.4) ; C634.2 56.89,49.93 v1(57.46,50.49) 57.64,50.68 C652.1 ; v1(155.37,154.23) PC20032.1 ; C4200.2 v1(304.32,11.9) ; PR8021.2 PC8017.2 232.32,147.54 v1(232.57,147.28) ; PC23011.2 v1(120.05,91.25) ; C2601.2 202.07,144.16 v1(202.44,144.16) ; R9166.1 244.18,77.89 v1(243.52,77.89) ; C3663.1 v1(212.5,155.82) ; CAS35.3 148.78,88.98 152.19,92.39 v1(152.43,92.39) ; C9188.2 v1(308.26,14.7) ; CON7301.10 v1(33.23,54.47) ; C6354.2 v1(102.9,2.33)
  IN1 w0.203: 238.72,76.72 239.25,76.72 v1(239.33,76.7) 239.48,76.49 239.48,75.77 v1(240.53,74.72) 241.5,73.75 242.7,73.75 v1(243.24,73.22) 244.05,72.4 v1(244.63,72.4) 244.63,71.81 244.08,71.26 243.02,71.26 v1(242.52,71.76) 242.09,72.19 240.94,72.19 239.4,73.73 238.44,73.73 237.78,74.39 237.78,74.87 v1(237.9,75) 237.71,75.19 237.71,75.71 238.72,76.72
  IN1 w0.254: 34.78,63.29 34.78,63.01 v1(33.2,61.43) 33.2,59.91 32.72,59.43 29.65,59.43 29.29,59.78 v1(29.29,60.92) 28.48,60.92 28.05,61.36 v1(28.05,62.07) 31.58,62.07 v1(32.19,62.68) 32.42,62.68 v1(33.23,63.49) 33.41,63.67 33.41,64.4 34.96,65.96 36.56,65.96 v1(37.15,65.37) 37.5,65.02 v1(37.5,64.1) v1(35.59,64.1) 34.78,63.29
  BOTTOM w0.089: v1(173.44,127.57) 173.64,127.36 U9001.K38
  BOTTOM w0.114: Y9000.4 234.67,80.61 234.44,80.61 233.08,79.25 233.08,79.08 v1(233.46,78.7) ; C12049.2 v1(350.17,57.5) C12048.2 ; v1(242.7,76.44) 242.96,76.44 U9002.AD1 U9002.AD2 ; v1(247.42,55.1) 247.42,55.19 U9002.A37 ; U3602.B4 199.78,153.53 ; PQ23008.1 112.54,92.53 v1(112.3,92.77) ; R18070.2 v1(352.72,59.28) ; C12047.2 v1(351.45,57.5) ; C12056.1 v1(352.72,57.5) ; R9346.1 235.56,74.42
  BOTTOM w0.127: v1(175.82,113.76) 175.82,113.69 U9001.F19
  BOTTOM w0.152: U9002.BG25 259.52,76.15 260,76.62 260,76.75 260.54,77.3 260.55,77.3 261.35,78.09 v1(261.35,78.32) ; v1(245.52,79.71) 245.52,79.36 U9002.AM1 ; U9002.AM49 262.77,62.11 v1(262.77,61.81) ; U9001.M13 U9001.M14 ; v1(153.7,98.82) 153.69,98.84 U9001.AR1 U9001.AR2 U9001.AR3 ; U9001.AF2 U9001.AF1 v1(161.23,99.84) ; U9001.AF2 U9001.AF3 U9001.AF4 161.66,102.77 161.66,103.23 U9001.AE6 ; U9001.AF2 161.09,101.04 v1(160.79,101.34) ; U9002.BG17 256.83,78.66 256.83,79.02 v3(256.94,79.13) ; U9001.BH2 U9001.BH3 U9001.BH4 U9001.BH5 ; U9001.BB6 U9001.BB5 148.66,102.86 148.68,102.85 148.68,102.47 148.66,102.46 U9001.BB4 148.66,102.21 148.68,102.2 148.68,101.82 148.66,101.81 U9001.BB3 U9001.BB2 148.66,100.9 148.66,100.89 148.66,100.53 148.66,100.52 U9001.BB1 148.66,100.25 148.66,100.24 148.66,99.92 v1(148.22,99.48) ; v3(261.14,74.93) 260.9,74.69 U9002.BG28 ; v1(171.29,99.61) 171.29,99.67 171.3,99.67 171.3,100.25 171.29,100.25 U9001.N1 U9001.N2 U9001.N3 ; U9001.BE3 146.15,101.56 146.16,101.55 146.16,101.17 146.15,101.16 U9001.BE2 146.15,100.91 146.16,100.9 146.16,100.52 146.15,100.51 U9001.BE1 146.15,100.26 146.16,100.25 146.16,99.88 v1(145.7,99.42) ; v3(264.2,71.88) 264.2,71.86 263.92,71.58 U9002.BG37 ; v1(163.3,102.01) 163.63,102.34 U9001.AC4 ; U9001.W5 U9001.W4 U9001.W3 ; U9001.BN4 140.85,102.49 U9001.BM5 ; v1(158.72,99.84) U9001.AJ1 U9001.AJ2 U9001.AJ3 U9001.AJ4 U9001.AJ5 U9001.AJ6 ; U9002.AG49 261.22,60.55 261.22,60.05 v1(261.42,59.85) ; U9001.AC5 163.75,102.86 163.76,102.85 163.76,102.52 163.75,102.51 U9001.AC4 ; U9001.T5 U9001.T4 U9001.T3 ; v1(244,58.45) 244.47,58.45 U9002.A28 ; v1(163.76,99.87) 163.75,99.88 U9001.AC1 163.75,100.86 163.74,100.99 163.75,100.99 U9001.AC2 U9001.AC3 U9001.AC4 ; U9001.N3 U9001.N4 U9001.N5 ; U9001.N3 171.18,101.69 v1(170.85,101.36) ; U9001.T3 168.66,101.69 v1(168.34,101.38) ; U9001.T3 U9001.T2 U9001.T1 168.78,100.29 168.78,100.29 168.78,99.88 v1(168.33,99.42) ; U9001.BT3 v1(138.16,101.49) ; U9002.AG1 243.88,77.89 v1(243.52,77.89) ; U8001.AB2 U8001.AB1 ; U9002.AD49 260.51,58.89 v1(260.51,58.38) ; U9001.K4 173.81,102.07 173.82,102.06 173.82,101.82 173.81,101.81 U9001.K3 ; v1(258.47,57.69) 258.69,57.9 U9002.AA49 ; U9001.W3 U9001.W2 166.26,100.91 166.26,100.69 U9001.W1 166.26,99.82 v1(165.82,99.46) ; U9001.W3 166.15,101.69 v1(165.82,101.36) ; U9001.C37 178.44,126.74 178.44,127.19 178.82,127.57 v1(178.9,127.57) 179.23,127.24 179.23,126.83 U9001.B37 ; v3(262.72,73.43) 262.56,73.43 U9002.BG33 ; U9001.K3 U9001.K2 U9001.K1 173.81,99.62 v1(173.81,99.61) ; U9001.K3 173.69,101.69 v1(173.37,101.36) ; U9002.BG22 258.34,77.17 259.49,78.33 v1(259.49,78.75) ; U9001.AW5 U9001.AW4 U9001.AW3 U9001.AW2 U9001.AW1 151.18,99.87 v1(150.76,99.45) ; U9002.T49 v1(257.14,56.22) ; U9002.A33 245.92,56.8 v1(245.77,56.8)
  BOTTOM w0.178: U8001.F1 U8001.F2 ; v3(339.25,113.02) 339.4,112.87 U8001.R23 U8001.R22 ; U8001.A22 U8001.B22 U8001.C22 U8001.C23 339.66,118.39 v3(339.5,118.55) v3(339.5,119.09) v1(339.5,119.72) ; v3(347.18,108.63) 347,108.81 U8001.AC8 U8001.AB8 ; U8001.B12 U8001.A12 345.16,119.74 v3(345.02,119.88) ; U8001.U22 U8001.U23 v3(339.25,111.95) ; v3(343.32,108.55) U8001.AC16 U8001.AB16 ; U8001.D2 U8001.D1 350.43,117.93 v3(351.14,118.63) ; U8001.B4 U8001.A4 348.84,119.74 v3(348.68,119.9) ; v3(343.16,119.9) 343.32,119.74 U8001.A16 U8001.B16 ; U8001.B10 U8001.A10 346.08,119.74 345.92,119.9 v3(345.92,119.88) ; v3(344.24,108.55) U8001.AC14 U8001.AB14 ; U8001.N22 U8001.N23 339.56,113.79 339.35,114 v3(339.25,114) ; U8001.W22 U8001.W23 339.47,111.03 v3(339.33,110.89) ; v3(342.4,108.55) U8001.AC18 U8001.AB18 ; U8001.G22 U8001.G23 339.66,116.55 v3(339.5,116.71) ; U8001.AB12 U8001.AC12 345.16,108.74 v3(345.35,108.55) ; U8001.L22 U8001.L23 339.69,114.71 339.4,115 v3(339.26,115) ; U8001.AB20 U8001.AC20 v3(341.48,108.55) ; D7129.1 359.3,111.71 v1(359.44,111.85) 359.54,111.75 R17936.2 ; v3(344.08,119.9) 344.24,119.74 U8001.A14 U8001.B14 ; D7130.1 360.47,109.45 360.46,109.44 ; v3(346.26,108.55) 346.08,108.74 U8001.AC10 U8001.AB10 ; v3(350.79,114.1) 350.64,114.25 U8001.M1 U8001.M2 ; v3(349.94,108.12) 349.94,108.12 v3(349.94,108.65) 349.76,108.84 U8001.AC2 U8001.AB2 ; v3(348.73,110.07) 348.84,109.96 U8001.AB4 U8001.AC4 348.84,108.86 348.83,108.86 348.65,108.68 v3(348.1,108.68) 347.92,108.86 U8001.AC6 U8001.AB6 ; U8001.J22 U8001.J23 339.69,115.63 v3(339.5,115.82) ; v3(342.24,119.9) 342.4,119.74 U8001.A18 U8001.B18 ; v3(341.32,119.9) 341.48,119.74 U8001.A20 U8001.B20 341.48,118.38 ; v3(349.6,119.9) 349.76,119.74 U8001.A2 U8001.B2 U8001.B1 ; U8001.H1 350.61,116.09 v3(350.68,116.02) 350.29,115.63 U8001.J1 U8001.J2 ; U8001.B6 U8001.A6 347.92,119.74 v3(347.76,119.9) ; U8001.B8 U8001.A8 347,119.74 v3(346.84,119.9) ; U8001.E22 U8001.E23 339.66,117.47 v3(339.5,117.63)
  BOTTOM w0.203: U9001.T11 U9001.T12 ; U9001.T11 v1(168.96,107.26) ; U9001.T11 U9001.T10 ; U9001.T11 v1(168.97,106.62) ; U9001.T12 U9001.T13 U9001.T14 ; U9001.T12 v1(168.96,107.89) U9001.R12 v1(169.88,107.87) U9001.P12 v1(170.79,107.87) U9001.N12 ; U9001.T12 v1(168.96,107.26) ; v1(166.22,105.92) U9001.Y10 ; v1(166.22,105.92) v1(166.22,106.57) ; v1(166.22,105.92) v1(166.22,105.27) ; v1(166.22,105.92) U9001.Y9 ; U9001.Y10 U9001.Y9 ; U9001.Y10 v1(166.22,106.57) ; U9001.Y10 U9001.Y11 v1(166.22,106.57) ; U9001.BG13 U9001.BG12 v1(144.27,107.26) ; U9001.BG13 U9001.BG14 ; U9001.BG13 v1(145.19,108.52) U9001.BG14 ; U9001.BG13 v1(145.19,107.87) U9001.BF12 ; U9001.N12 U9001.N11 U9001.N10 ; U9001.N12 v1(171.7,107.89) ; v1(145.57,44.29) 145.45,44.41 C1061.2 ; U9001.N9 v1(171.7,105.99) ; U9001.N9 U9001.N8 U9001.N7 171.25,104.04 171.29,103.99 U9001.N6 ; U9001.N9 U9001.N10 ; v1(171.7,105.99) U9001.N10 ; v1(171.7,105.99) v1(171.71,106.62) U9001.N10 ; U9001.BA10 U9001.BA11 ; U9001.BA10 v1(149.76,105.98) ; U9001.BA10 U9001.BA9 ; U9001.BA10 v1(149.76,106.61) ; U9001.BA11 v1(149.76,106.61) ; U9001.BA11 v1(149.76,107.25) ; U9001.BA11 U9001.BA12 ; U9002.AN38 259.15,65.61 ; U9001.N5 171.33,103.03 171.33,103.6 U9001.N6 ; U9001.BH12 v1(143.36,107.22) U9001.BJ12 ; U9001.BH12 v1(144.27,107.26) ; U9001.BH12 U9001.BH11 ; v1(152.51,106.62) U9001.AU10 ; v1(152.51,106.62) U9001.AU11 ; v1(152.51,106.62) v1(152.5,105.99) ; U9001.AU10 U9001.AU9 ; U9001.AU10 U9001.AU11 ; U9001.AU10 v1(152.5,105.99) ; 271.45,65.37 271.45,65.42 270.93,65.94 269.79,65.94 269.37,65.52 267.77,65.52 267.62,65.37 267.04,65.37 v1(266.94,65.27) ; v1(183.67,126.25) 183.67,126.25 C9097.1 ; v1(144.28,106.62) U9001.BH10 ; v1(144.28,106.62) v1(144.27,105.99) ; v1(144.28,106.62) U9001.BH11 ; v1(144.28,106.62) v1(144.27,107.26) ; U9001.BH10 U9001.BH11 ; U9001.BH10 U9001.BH9 ; U9001.BH10 v1(144.27,105.99) ; v1(152.5,105.35) U9001.AU8 ; v1(152.5,105.35) v1(152.5,105.99) ; v1(152.5,105.35) U9001.AU9 ; U9001.AU8 U9001.AU9 ; U9001.AU8 U9001.AU7 ; U9001.AL8 v1(157.99,105.27) U9001.AL9 ; U9001.AL8 U9001.AL7 157.84,103.99 158.03,103.99 158.13,103.89 158.47,103.89 U9001.AJ6 U9001.AH6 U9001.AG6 160.4,103.66 v1(160.79,103.93) 160.31,104.3 U9001.AG7 U9001.AG8 v1(160.73,105.27) ; U9001.AL8 U9001.AL9 ; U9001.BM6 U9001.BL6 U9001.BK6 143.12,103.31 v1(143.16,103.31) 143.21,103.31 143.54,103.64 U9001.BH6 ; U9001.BM6 141.16,103.56 140.79,103.94 140.79,103.94 140.72,104.45 U9001.BN7 ; U9001.BM6 U9001.BM5 v1(141.5,102.46) U9001.BM3 ; VRAM2503.E12 241.35,100.16 v1(240.51,100.16) ; U9001.N6 v1(170.85,103.31) 170.52,103.64 U9001.P6 ; U9001.N6 U9001.M6 ; U9001.Y9 v1(166.22,105.27) ; U9001.Y9 U9001.Y8 ; U9001.BM3 U9001.BM2 v1(141.26,100.84) U9001.BN2 ; U9001.BM3 U9001.BN4 ; v1(160.73,107.22) U9001.AG11 v1(160.73,106.57) U9001.AG10 ; v1(199.3,51.91) 199.22,51.84 PU9802.3 ; C8050.1 339.05,120.99 339.76,120.99 340.19,121.43 340.19,124.75 339.88,125.06 v1(339.33,125.06) 338.74,125.06 338.51,124.82 336.22,124.82 336.07,124.67 v1(336.07,121.26) ; v1(144.27,105.99) U9001.BH9 ; v1(181.93,121.68) 182.26,122.01 C9101.1 ; U9001.AU11 U9001.AU12 151.78,107.81 151.39,107.81 U9001.AW12 150.87,107.81 150.61,107.81 150.35,107.55 U9001.AY12 v1(149.76,107.88) U9001.BA12 ; U9001.T9 v1(168.96,105.99) ; U9001.T9 U9001.T8 ; U9001.T9 U9001.T10 ; v1(168.96,105.99) U9001.T10 ; v1(168.96,105.99) v1(168.96,105.35) 168.91,105.35 U9001.T8 ; U9001.BN21 140.72,114.78 v1(141.04,115.1) U9001.BM21 ; v1(141.69,108.02) U9001.BM12 v1(141.04,107.23) ; v1(141.69,108.02) U9001.BM13 ; v1(141.69,108.02) 141.69,108.09 U9001.BL13 ; U9001.BD12 v1(147.02,107.26) ; U9001.BD12 v1(146.1,107.84) ; U9001.BD12 U9001.BD11 ; v1(147.02,107.26) U9001.BD11 ; v1(147.02,107.26) U9001.BC12 ; v1(138.16,102.34) 138.29,102.4 U9001.BT4 ; v1(163.47,105.92) U9001.AD10 ; v1(163.47,105.92) v1(163.47,106.57) ; v1(163.47,105.92) U9001.AD9 ; U9001.AD10 U9001.AD11 ; U9001.AD10 U9001.AD9 ; U9001.AD10 v1(163.47,106.57) ; U9001.T8 U9001.T7 168.25,104.05 168.25,103.95 U9001.U6 U9001.V6 166.85,103.39 166.66,103.39 U9001.W5 ; R6077.2 273.72,34.35 273.72,35.14 v1(273.84,35.27) ; PC19006.2 126.43,141.23 v1(126.26,141.06) ; v1(140.88,25.36) 140.88,24.83 140.54,24.5 C1123.2 ; 163.46,104.01 U9001.AD7 U9001.AD8 ; 163.46,104.01 U9001.AC6 ; 163.46,104.01 U9001.AD6 U9001.AE6 ; U9001.BD11 U9001.BD10 ; U9001.BD11 v1(147.02,106.62) ; U9001.BD10 v1(147.02,106.62) ; U9001.BD10 v1(147.02,105.99) ; U9001.BD10 U9001.BD9 ; U9001.AT30 U9001.AT29 ; U9001.BA8 U9001.BA7 149.05,104.05 149.05,104.02 U9001.BB6 ; U9001.BA8 U9001.BA9 ; U9001.BA8 v1(149.76,105.34) U9001.BA9 ; v1(138.12,103.28) 138.21,103.2 U9001.BT5 ; U9001.BA12 v1(149.76,107.25) ; U9001.BA12 v1(148.84,107.87) U9001.BB12 v1(147.93,107.86) 147.62,107.55 U9001.BC12 ; v1(149.76,107.25) v1(149.76,106.61) ; U9001.BT21 138.74,114.71 138.4,115.05 v1(138.4,115.12) ; v1(233.46,77.79) 233.19,77.79 R9347.1 ; U9001.M14 172.03,108.85 v1(171.7,108.52) ; U9001.T10 v1(168.97,106.62) ; v1(155.24,105.3) U9001.AP9 ; v1(155.24,105.3) v1(155.24,105.99) ; v1(155.24,105.3) U9001.AP8 ; U9001.AP9 U9001.AP8 ; U9001.AP9 v1(155.24,105.99) ; U600.9 v1(27.82,88.86) ; C9187.2 274.1,64.79 273.39,64.79 272.88,65.31 272.35,65.31 C9215.1 ; v1(150.73,101.36) 151.06,101.69 U9001.AW3 ; U9001.AP8 155.23,104.51 155.23,104.16 155.37,104.02 U9001.AN6 155.32,103.59 U9001.AN5 155.64,102.66 155.81,102.66 ; 146.57,103.89 146.56,103.9 U9001.BD7 U9001.BD8 ; 146.57,103.89 146.73,103.89 U9001.BD6 ; 146.57,103.89 146.4,103.89 U9001.BE6 ; v1(156.21,99.84) U9001.AM1 U9001.AM2 U9001.AM3 156.34,101.82 156.34,102.2 U9001.AM4 156.17,102.34 156.02,102.49 155.98,102.49 155.81,102.66 ; U9001.BG14 U9001.BH14 ; v1(152.5,105.99) U9001.AU9 ; C8051.1 336.17,118.49 336.71,117.95 337.98,117.95 338.3,117.63 v3(339.5,117.63) ; v1(161.65,107.87) 161.51,107.87 U9001.AF12 U9001.AF13 U9001.AF14 ; U9001.AC6 163.75,103.52 163.76,103.5 163.76,103.12 163.75,103.11 U9001.AC5 ; U9001.AC6 U9001.AB6 164.86,103.64 165.29,104.06 165.53,104.06 U9001.Y7 U9001.Y8 ; v1(267.67,64.04) 269.6,64.04 v1(269.65,64.09) ; U9001.M12 U9001.M13 ; v1(27.64,105.12) 27.64,105.25 27.67,105.27 27.67,106.36 27.06,106.97 25.64,106.97 25.46,107.15 U601.9 ; v1(184.54,46.57) 184.49,46.57 182.96,45.05 R1023.2 ; v1(164.39,107.87) U9001.AC12 v1(163.45,107.87) v1(163.47,107.22) ; U9001.BN7 U9001.BM7 141.12,104.73 141.12,105.01 U9001.BM8 141.12,105.51 141.12,105.8 U9001.BM9 141.49,106.17 141.49,106.72 U9001.BM11 141.37,106.9 v1(141.04,107.23) ; U9001.BN7 U9001.BP7 v1(139.74,104.87) ; U9001.AR13 154.01,108.2 v1(154.33,108.52) 154.01,108.85 U9001.AR14 ; v1(147.02,106.62) v1(147.02,105.99) ; U9001.BE5 146.15,102.86 146.16,102.85 146.16,102.47 146.15,102.46 U9001.BE4 146.15,102.21 146.16,102.2 146.16,101.82 146.15,101.81 U9001.BE3 146.03,101.69 v1(145.7,101.36) ; U9001.BE5 146.03,103.1 146.03,103.52 U9001.BE6 ; U9001.BE5 146.47,103.31 v1(146.54,103.31) 146.87,103.64 U9001.BD6 ; 272.95,62.39 272.95,61.75 272.16,60.96 271.63,60.96 270.03,62.56 270.03,63 C9214.1 ; 272.95,62.39 273.27,62.39 274.2,63.31 v1(274.4,63.31) ; 272.95,62.39 v1(272.57,62.77) ; U9001.BD9 v1(147.02,105.99) ; U9001.BD9 v1(147.02,105.35) ; U9001.BD9 U9001.BD8 ; v1(147.02,105.99) v1(147.02,105.35) ; U9001.AW30 U9001.AW29 150.81,120.74 151.04,120.52 v1(151.33,120.52) ; U9001.Y13 165.63,108.2 v1(165.29,107.86) 164.98,107.55 U9001.AA12 ; U9001.Y13 165.77,108.2 166.09,107.87 v1(166.22,107.87) U9001.W12 v1(167.13,107.87) U9001.V12 ; U9001.Y13 U9001.Y14 ; U9001.AT6 152.44,104.05 152.3,104.05 U9001.AU7 ; U9001.BH6 143.63,103.54 143.67,103.5 143.67,103.12 143.63,103.08 U9001.BH5 ; U9001.BH6 U9001.BG6 U9001.BF6 U9001.BE6 ; U9001.BH6 143.81,103.82 U9001.BH7 U9001.BH8 ; PC19008.2 v1(124.24,140.29) ; v1(141.04,107.23) 141.04,107.3 U9001.BN12 140.67,107.57 140.59,107.57 140.58,107.56 140.2,107.56 140.19,107.57 140.12,107.57 U9001.BP12 139.99,107.62 139.93,107.56 139.55,107.56 139.49,107.62 U9001.BR12 139.37,107.57 138.82,107.57 U9001.BT12 v1(138.17,107.75) ; D7116.1 359.38,133.56 v3(359.24,133.42) ; U9001.BA9 v1(149.76,105.98) ; v1(168.97,106.62) 168.96,106.63 v1(168.96,107.26) ; U9001.BH9 U9001.BH8 ; U9001.BH9 v1(144.27,105.35) U9001.BH8 ; v1(147.02,105.35) 146.61,104.95 U9001.BD8 ; v1(148.22,101.36) 148.55,101.69 U9001.BB3 ; U9001.AL14 157.51,108.85 v1(157.08,109.28) ; U9001.Y8 v1(166.22,105.27) ; U9001.AR5 153.69,102.85 U9001.AR4 153.69,102.21 153.7,102.2 153.7,101.7 U9001.AR3 153.52,101.69 v1(153.25,101.41) ; v1(163.47,106.57) U9001.AD11 ; v1(163.47,106.57) v1(163.47,107.22) ; U9001.AD11 U9001.AD12 ; U9001.AD11 v1(163.47,107.22) ; U9001.K5 173.81,102.86 173.82,102.85 173.82,102.47 173.81,102.46 U9001.K4 U9001.J4 ; U9001.BD6 U9001.BC6 148.15,103.31 v1(148.22,103.31) 148.55,103.64 U9001.BB6 ; v1(261.3,27.37) 261.83,27.37 C6006.2 ; v1(172.66,120.57) 172.85,120.77 U9001.L29 U9001.L30 ; VRAM2501.E14 226.2,139.75 225.82,139.37 225.16,139.37 VRAM2501.E12 ; v1(139.74,104.87) U9001.BR7 ; v1(139.74,104.87) 138.93,104.87 U9001.BT8 ; U9001.AY14 150.22,109.04 v1(150.5,109.33) ; v1(144.27,107.26) U9001.BH11 ; v1(155.25,106.62) v1(155.24,105.99) ; v1(155.25,106.62) 155.24,106.63 v1(155.24,107.26) ; v1(155.25,106.62) U9001.AP11 v1(155.24,107.26) ; v1(155.25,106.62) U9001.AP10 v1(155.24,105.99) ; U9001.BB6 U9001.BA6 ; v1(149.76,106.61) v1(149.76,105.98) ; U9001.AL9 U9001.AL10 ; U9001.AL9 v1(157.99,105.92) ; U9001.AL10 v1(157.99,106.57) v1(157.99,105.92) ; U9001.AL10 v1(157.99,105.92) ; v1(138.38,111.96) U9001.BT18 U9001.BR18 U9001.BP18 ; PR11023.1 242.94,9.78 242.24,9.08 v1(242.17,9.08) ; R1049.2 R1050.2 166.02,22.34 165.59,22.77 v1(165.59,23.33) ; U9001.BN20 140.39,113.6 v1(140.39,113.53) 140.39,113.46 U9001.BN19 ; v1(184.54,45.94) 184.08,45.47 C1024.1 ; U9001.AD9 U9001.AD8 ; U9001.AD9 v1(163.47,105.27) U9001.AD8 ; v1(182.07,43.3) 182.07,43.4 181.61,43.86 C1049.2 C1051.2 ; v1(237.14,65.5) 237.41,65.5 U9002.A8 ; U9001.BC12 U9001.BC13 U9001.BC14 147.37,108.85 v1(147.02,109.2) ; U9001.AL4 157.24,102.19 157.69,102.19 U9001.AK4 U9001.AJ4 ; C1018.1 156.14,44.41 v1(155.89,44.16) ; 155.81,102.66 156.14,102.99 U9001.AM5 ; CON5101.51 v1(324.67,16.65) ; U9001.BR9 v1(139.74,106.44) ; U9001.L33 173.17,124.08 v1(173.25,124.08) 172.92,124.41 U9001.L34 ; U9001.AU7 152.04,103.67 U9001.AU6 151.76,103.39 151.58,103.39 U9001.AW5 ; C1097.2 143.89,44.72 142.91,45.71 v1(142.73,45.71) ; PC12001.1 258.39,21.49 258.23,21.33 258.23,20.71 258.73,20.21 v1(258.83,20.21) ; R9345.1 235.22,75.43 v3(235.22,74.75) 235.56,74.42 ; U9001.AG30 U9001.AG29 ; U9001.AG13 159.93,107.86 v1(159.82,107.86) 159.64,107.68 159.63,107.68 159.5,107.55 U9001.AH12 159.21,107.55 v1(158.9,107.86) 158.79,107.86 U9001.AJ13 158.12,107.87 v1(157.99,107.87) 157.86,107.87 U9001.AL12 157.27,107.81 156.88,107.81 U9001.AM12 156.36,107.81 155.96,107.81 U9001.AN12 v1(155.24,107.26) ; v1(154.35,127.36) 154.35,128.22 152.31,130.27 PR19046.2 ; U9001.BL14 v1(141.69,109.59) U9001.BM14 v1(141.04,109.59) U9001.BN14 v1(140.39,109.59) U9001.BP14 v1(139.74,109.59) U9001.BR14 ; v1(155.24,107.26) U9001.AP12 ; v1(143.83,99.68) 143.38,100.13 U9001.BH1 143.38,100.78 U9001.BH2 143.58,101.04 143.26,101.36 v1(143.19,101.36) ; U9002.AT1 247.17,80.85 v1(247.17,81.07) ; v1(269.58,33.11) 269.81,33.34 C6016.1 ; C1124.2 157.03,25.21 v1(156.88,25.36) ; C6032.1 v1(266.81,35.27) ; v1(155.02,44.41) C1098.2
  BOTTOM w0.229: VRAM2501.B5 218.78,136.95 218.78,135.9 v1(218.78,135.9)
  BOTTOM w0.25: U2000.D2 225.43,99.15 225.37,99.1 225.37,98.7 225.43,98.65 225.43,98.49 v1(225.94,97.97)
  BOTTOM w0.254: D7122.1 359.61,118.51 v1(360.33,118.51) ; v1(143.79,120.56) 143.74,120.56 143.42,120.88 U9001.BJ29 143.15,120.88 142.81,121.22 U9001.BK29 ; v1(28.05,62.07) 27.06,62.07 26.24,62.88 24.92,62.88 24.14,63.67 v1(24.14,65.88) ; v1(337.6,10.28) 337.25,9.93 CON4201.27 ; U9001.BA38 149.16,127.01 v1(148.84,126.69) 149.16,126.36 U9001.BA37 ; U9001.BP26 139.74,118.32 v1(139.74,118.25) ; U9001.N33 170.95,124.09 v1(170.88,124.09) ; CON400.59 v1(76.73,61.08) ; v1(114.6,30.68) 114.85,30.93 JDIM1002.6 ; U9001.M13 v1(171.7,108.52) ; U9001.M13 v1(171.7,107.89) ; U9001.M13 v1(172.62,107.87) U9001.M12 v1(171.7,107.26) ; JDIM1002.230 172.85,30.93 v1(173.1,30.68) ; U9001.AR29 153.96,120.88 v1(154.35,120.49) ; U9001.AR29 U9001.AR30 U9001.AR31 154.02,122.46 v1(154.35,122.79) 154.28,122.79 U9001.AR32 153.96,123.15 154.24,123.44 v1(154.35,123.44) 154.02,123.76 U9001.AR33 ; U9001.AR29 U9001.AT29 153.15,121.11 153.04,121 152.76,120.72 152.6,120.55 v1(152.6,120.52) ; U9001.BN31 U9001.BN30 v1(140.39,121.4) ; U9001.F4 176.13,102.38 v1(176.48,102.73) ; U9001.F4 U9001.G4 ; U9001.F4 U9001.F3 v1(175.84,101.36) U9001.F2 ; U9001.BP29 v1(140.39,121.4) ; v1(140.39,121.4) U9001.BN29 ; U9001.BL35 142.47,124.73 v1(142.54,124.73) 142.61,124.73 U9001.BJ34 ; U9001.BL35 141.48,125.06 U9001.BM35 ; U9001.BL35 142.47,125.38 v1(142.54,125.38) 142.61,125.38 U9001.BJ35 ; v1(175.12,106.65) U9001.G10 ; v1(175.12,106.65) 174.84,106.93 U9001.H11 ; v1(175.12,106.65) 174.77,106.29 U9001.J10 ; U9001.G10 175.49,106.35 v1(175.82,106.68) 175.82,106.74 U9001.F11 175.82,107.39 v1(175.82,107.46) 175.82,107.53 U9001.G12 175.17,108.18 v1(175.17,108.25) 174.84,107.92 U9001.H12 ; U9001.G10 175.49,106.21 v1(175.82,105.88) 175.49,105.56 U9001.G9 175.49,105.42 175.82,105.1 ; v1(168.6,30.68) 168.85,30.93 JDIM1002.214 ; v1(170.89,120.52) v1(170.18,120.52) U9001.R29 U9001.R30 170.08,122.14 v1(170.1,122.14) ; v1(163.6,30.68) 163.36,30.93 JDIM1002.192 ; U9001.G22 175.82,115.4 v1(175.82,115.34) 175.82,115.26 U9001.F21 ; U9001.G22 175.34,115.88 174.95,115.88 U9001.H22 ; U9001.G22 175.82,116.05 v1(175.82,116.12) ; v1(149.62,124.74) 149.69,124.74 U9001.AY34 149.89,124.28 149.89,123.89 U9001.AY33 ; JDIM1002.206 166.85,30.93 v1(166.6,30.68) ; v1(157.61,30.68) 157.61,30.93 157.35,31.19 JDIM1002.168 ; U9001.AL33 156.78,124.09 v1(156.71,124.09) ; v1(347.55,10.16) 347.55,10.15 345.17,10.15 344.75,9.73 CON4201.57 ; v1(178.42,109.82) 178.42,109.89 U9001.C15 177.77,110.54 177.77,110.68 U9001.D16 ; v1(199.99,124.78) 200.32,125.1 U2000.AP33 ; v1(176.35,30.7) JDIM1002.244 ; v1(269.86,22.94) 269.86,23.69 U6001.A8 ; CON400.14 88.23,70.14 v1(88.18,70.19) ; U9001.A16 179.97,111 v1(180.13,111.16) ; JDIM1002.202 165.85,30.8 165.94,30.71 v1(165.94,30.7) ; U9001.AU34 152.31,124.41 v1(151.99,124.09) 152.31,123.76 U9001.AU33 ; v1(175.05,102.66) U9001.G4 ; v1(175.05,102.66) 174.97,102.66 U9001.J4 174.97,102.01 v1(175.06,102.01) 175.13,102.01 U9001.G4 ; v1(175.05,102.66) 175.12,102.66 U9001.G5 175.98,102.99 U9001.F5 ; U9001.BR36 139.27,125.58 139.15,125.7 U9001.BT36 138.67,125.7 v1(138.26,125.28) 138.65,124.88 U9001.BT35 ; U9001.A26 179.86,118.88 179.99,119.01 v1(180,119.01) ; U9001.BP24 139.74,117.4 v1(139.74,117.47) 139.74,117.54 U9001.BP25 ; U9001.BT32 v1(138.13,123.31) ; v1(168.48,120.52) v1(167.72,120.52) U9001.V29 U9001.V30 167.72,122.14 v1(167.73,122.14) ; v1(55.55,54.95) 55.93,54.57 CON3000.20 ; v1(135.61,30.68) 135.85,30.93 JDIM1002.90 ; CON400.38 v1(82.23,67.05) ; U9002.E40 250.23,56.05 v1(250.32,55.96) ; U2000.AL23 202.7,116.98 202.7,117.42 U2000.AL24 202.88,117.65 U2000.AM25 ; v1(178.42,108.25) 178.42,108.32 U9001.C13 177.44,109.29 U9001.D14 ; U2000.AN7 200.91,103.08 v1(200.91,103.02) ; U9001.BJ31 142.93,122.39 v1(142.61,122.07) 142.74,122.07 U9001.BJ30 142.66,121.33 U9001.BK29 ; v1(167.73,127.34) 167.8,127.34 U9001.U38 ; v1(143.84,109.47) U9001.BJ15 v3(142.99,109.61) ; v1(143.84,109.47) 143.84,109.47 143.84,108.86 U9001.BH14 ; v1(143.84,109.47) U9001.BJ14 v3(142.99,109.61) ; JDIM1002.44 124.35,30.93 v1(124.1,30.68) ; 175.82,105.1 175.82,105.17 U9001.F9 ; 175.82,105.1 175.82,105.03 U9001.F8 ; 175.82,105.1 175.49,104.77 U9001.G8 175.55,104.65 v1(175.55,104.14) ; v1(156.71,127.34) 156.64,127.34 U9001.AM38 ; v1(175.17,111.4) 175.17,111.32 U9001.G16 ; U9001.BG37 144.44,126.36 v1(144.11,126.69) 144.44,127.01 U9001.BG38 ; 142.54,124.09 142.53,124.08 142.47,124.08 U9001.BL33 142.47,123.43 142.61,123.43 U9001.BJ32 ; 142.54,124.09 142.54,124.08 142.61,124.08 U9001.BJ33 ; 142.54,124.09 v1(142.54,124.09) ; U9001.BR26 139.09,118.32 v1(139.09,118.25) 138.77,118.58 U9001.BT26 ; v1(120.56,30.75) 120.56,30.77 120.85,31.07 JDIM1002.30 ; v1(225.94,94.42) 224.51,95.84 v1(224.29,95.84) ; U2000.AE2 208.19,99.05 208.19,98.13 208.97,97.35 v1(209.19,97.35) ; v1(23.5,67.58) 23.5,67.55 23.04,67.1 23.04,63.54 24.52,62.07 25.58,62.07 26.73,60.92 v1(29.29,60.92) ; U9001.BL19 142.17,113.33 142.17,113.73 U9001.BL20 141.69,114.32 U9001.BM21 141.69,115.04 v1(141.69,115.1) ; U9001.N34 170.95,124.74 v1(170.88,124.74) ; v1(218.35,126.3) 217.82,125.76 217.82,125.21 U2000.N33 ; U9001.BL21 142.02,114.78 v1(141.69,115.1) ; U2000.AH28 v1(204.98,121.4) U2000.AH29 v1(205.86,122.27) U2000.AH30 ; U9001.G20 175.81,114.48 v1(175.81,114.55) ; v1(151.2,127.34) 151.27,127.34 U9001.AV38 151.46,126.89 151.46,126.49 U9001.AV37 ; U9001.K7 v1(174.31,104.46) ; v1(174.31,104.46) 174.32,104.45 U9001.J7 174.91,104.14 v1(175.55,104.14) ; v1(174.31,104.46) U9001.K8 173.97,105.08 173.97,105.47 U9001.K9 173.97,105.73 173.97,106.12 U9001.K10 174.36,106.58 U9001.K11 ; v1(167.73,126.69) 167.8,126.69 U9001.U37 ; v1(159.86,124.74) 159.79,124.74 U9001.AH34 ; v1(180.1,115.83) 179.99,115.73 U9001.A22 ; v3(358.93,127.9) D7113.1 ; JDIM1002.106 v1(139.85,30.68) ; v1(158.41,30.68) 158.35,30.74 JDIM1002.172 ; v1(225.14,90.69) 225.08,90.75 v1(225.08,93.53) 225.22,93.67 C2182.2 ; v1(225.14,90.69) 225.33,90.5 225.33,90.03 225.51,89.85 229.44,89.85 229.67,90.08 229.67,92.21 v1(229.76,92.29) 229.76,93.04 229.13,93.67 C2183.2 ; v1(225.14,90.69) Y2000.2 ; U9001.F15 175.82,109.89 v1(175.82,109.82) ; v1(129.6,30.68) 129.35,30.93 JDIM1002.64 ; v1(166.16,124.09) 166.23,124.09 U9001.W33 ; U9001.C17 178.09,111.93 U9001.D18 177.12,112.9 v1(177.12,112.97) ; U9001.BP18 140.16,112.44 140.63,112.44 U9001.BN18 v1(141.04,111.96) U9001.BM18 141.49,112.44 141.89,112.44 U9001.BL18 U9001.BK18 U9001.BJ18 v1(143.92,112.35) ; v1(201.67,101.34) 201.7,101.37 202.45,101.37 U2000.AL5 ; U9001.AN29 v1(155.19,120.54) ; U9001.AN29 U9001.AN30 ; U9001.AN29 v1(155.88,120.52) ; U9001.BK22 U9001.BJ22 v1(143.97,115.5) ; v3(142.99,109.61) U9001.BK14 ; v3(142.99,109.61) U9001.BK15 ; 177.29,127.02 177.29,127.01 U9001.E38 ; 177.29,127.02 U9001.D38 ; 177.29,127.02 177.29,127.31 177.8,127.82 v1(177.8,127.95) ; v1(272.7,36.54) 272.7,35.9 273.11,35.5 273.11,34.89 272.86,34.64 VC6001.2 ; v1(176.48,102.73) 176.48,102.67 U9001.E4 ; v1(176.48,102.73) 176.12,103.09 U9001.F5 ; U9001.AH33 159.79,124.09 v1(159.86,124.09) ; v1(172.36,30.68) 171.85,31.19 JDIM1002.226 ; v1(234.39,74.09) 234.41,74.09 234.83,73.67 R9060.1 ; v1(220.54,98.76) 220.43,98.88 U2000.K2 ; U9001.BM28 141.69,119.9 141.69,119.76 U9001.BM27 141.37,119.37 v1(141.69,119.04) 141.69,118.97 U9001.BM26 ; v1(266.12,32.04) 266.12,31.56 266.62,31.07 U6001.M3 ; v1(236.58,90.41) 236.73,90.27 236.73,90.21 237.02,89.92 237.02,89.86 R2113.1 ; v1(255.63,8.65) 255.63,8.63 255.43,8.42 CON9500.14 ; U9001.AE33 161.5,124.09 v1(161.44,124.09) ; v1(273.08,26.43) 272.95,26.29 U6001.E12 ; v1(178.42,118.49) 178.42,118.42 U9001.C25 178.09,117.95 U9001.D24 ; v1(112.94,33.9) 113.85,32.98 JDIM1002.2 ; PR10008.1 338.1,139.1 337.76,138.76 PQ10004.4 ; v3(359.37,131.28) 359.25,131.17 D7105.1 ; v3(348.73,110.07) 348.69,110.07 U8001.Y5 ; v3(359.34,130.72) 358.93,130.31 D7111.1 ; C9213.1 234.98,77.1 234.98,76.8 235.83,75.95 v1(236.55,75.95) v1(237.12,75.38) 237.39,75.38 237.78,75 v1(237.9,75) 238.13,74.77 238.54,74.77 239.45,75.68 239.45,76.52 v1(239.33,76.7) 238.41,77.69 v1(238.41,77.94) 238.2,77.94 C9212.1 236.71,79.43 236.71,79.67 236.13,80.25 v1(236.13,80.38) ; v1(167.6,30.68) 167.85,30.93 JDIM1002.210 ; D7121.1 359.23,114.4 v3(359.57,114.39) ; CON400.2 91.23,70.19 91.6,70.57 91.6,71.09 v1(91.44,71.25) ; v1(176.47,118.49) 176.47,118.42 U9001.F25 ; CON5100.73 322.13,45.15 321.82,45.46 v1(321.6,45.46) 321.6,44.92 321.87,44.65 CON5100.71 ; v1(210.88,98.88) 210.46,99.3 U2000.AB2 ; JDIM1002.94 136.85,31.15 136.43,30.72 v1(136.3,30.72) ; U9001.BM33 141.37,123.44 v1(141.04,123.77) 141.04,123.83 U9001.BN34 ; U9001.AR34 154.02,124.41 v1(154.35,124.74) 154.02,125.06 U9001.AR35 ; JDIM1002.98 137.85,31.18 138.39,30.65 v1(138.46,30.65) ; U9001.T34 168.59,124.74 v1(168.52,124.74) ; v1(141.69,115.1) U9001.BL22 ; CON400.31 83.73,64.22 83.5,64.45 v1(83.24,64.45) 82.46,64.45 82.23,64.23 CON400.37 ; v1(177.77,120.06) 177.77,120.13 U9001.D28 ; v1(167.77,92.56) v1(167.77,90.1) C6401.2 ; v1(220.89,123.1) 220.86,123.13 220.86,123.87 U2000.K32 ; v1(159.1,30.68) 159.35,30.93 JDIM1002.176 ; v1(175.82,116.12) 175.49,116.44 U9001.G23 ; v1(175.82,116.12) 175.82,116.19 U9001.F23 ; v1(159.72,120.44) 159.72,120.57 U9001.AG29 160.35,121.01 v1(160.35,120.44) ; D7127.1 358.29,113.49 v3(358.25,113.53) ; CON5100.39 321.99,36.65 v1(321.65,36.31) ; v1(228.62,94.42) 228.62,94.94 228.25,95.31 227.24,95.31 225.38,97.17 223.91,97.17 v1(223.88,97.14) ; U2000.AM13 202.48,108.85 v1(202.48,108.86) 202.48,108.9 U2000.AL14 U2000.AL15 202.48,110.5 202.48,110.55 U2000.AM16 ; U2000.AM13 U2000.AN13 ; U2000.AM13 202.08,108.4 U2000.AL12 v1(202.48,107.2) ; U2000.AH32 205.43,124.31 v1(205.04,124.7) 205.43,125.09 U2000.AH33 205.43,125.11 v1(205.05,125.49) ; U3602.A5 200.18,152.39 v1(200.49,152.08) ; U9001.V12 v1(168.06,107.88) U9001.T13 v1(168.96,107.89) ; v1(341.66,10.28) 341.75,10.19 CON4201.45 ; U9001.BF33 145.14,123.92 145.14,124.26 U9001.BF34 144.97,124.74 v1(144.9,124.74) ; v1(125.1,30.68) 125.35,30.93 JDIM1002.48 ; U2000.AN16 U2000.AM16 ; U2000.AM16 202.08,111 U2000.AL17 v1(202.48,112.2) U2000.AL18 202.74,112.74 202.57,112.74 202.08,113.23 U2000.AM19 U2000.AN19 ; v1(165.37,127.34) 165.44,127.34 U9001.Y38 ; U9001.BM24 141.04,117.4 v1(141.04,117.47) 141.37,117.79 U9001.BM25 ; U9001.F5 175.61,103.64 U9001.G6 175.55,103.74 v1(175.55,104.14) ; v1(63.53,70.58) 63.53,70.1 R2104.2 ; v1(233.94,87.64) 234.17,87.87 U2009.3 236.3,87.87 R2151.2 ; U9001.BC33 147.59,123.76 v1(147.26,124.09) 147.59,124.41 U9001.BC34 ; U9001.BB30 U9001.BB29 148.87,120.68 v1(148.87,120.68) ; v1(267.9,23.03) 267.92,23.05 U6001.A5 ; U2000.AB5 210.43,102.48 v1(210.85,102.9) ; U9001.Y37 165.44,126.69 v1(165.37,126.69) ; U9001.AH36 159.79,126.04 v1(159.86,126.04) ; U9001.A6 179.89,103.93 v1(180,103.82) ; v1(321.72,34.76) 322.11,35.15 CON5100.33 ; CON4201.39 340.25,9.66 v1(339.63,10.28) 339.28,10.28 338.75,9.75 CON4201.33 ; CON3000.17 v1(57.43,54.8) ; v1(143.9,117.86) U9001.BJ25 U9001.BK25 ; v1(179.85,101.19) 179.85,101.91 U9001.A4 ; JDIM1002.36 122.35,31.01 122.56,30.8 v1(122.56,30.7) ; U2000.F28 223.83,121 v1(223.41,121.42) ; U9001.BR24 139.09,117.4 v1(139.09,117.47) 139.09,117.54 U9001.BR25 ; v1(170.1,126.69) 170.17,126.69 U9001.P37 ; U9001.BM29 141.51,120.87 141.87,120.87 U9001.BL29 142.45,121.01 U9001.BK29 ; v1(302.14,38.72) 302.44,39.03 302.44,41.72 301.71,42.46 301.71,42.82 301.9,43 Q6500.4 ; v1(156.71,126.69) 156.64,126.69 U9001.AM37 ; U2000.N5 217.52,102.11 v1(217.49,102.11) ; v1(207.51,125.5) 207.91,125.1 U2000.AE33 208.35,124.67 v1(208.35,124.66) 207.99,124.3 U2000.AE32 ; U9001.BN20 U9001.BN21 140.59,114.62 140.19,114.62 U9001.BP21 139.94,114.62 139.54,114.62 U9001.BR21 139.09,115.04 v1(139.09,115.11) 138.77,114.78 U9001.BT21 ; v1(256.06,55.19) 256.04,55.21 U9002.M49 ; U9001.C31 178.09,122.89 v1(177.77,123.21) 177.44,123.54 U9001.D33 177.44,123.67 v1(177.12,124) 177.12,124.06 U9001.E34 176.74,124.39 176.4,124.74 ; v1(175.82,117.7) 175.82,117.63 U9001.G24 ; v1(223.4,104.66) 223.4,103.82 U2000.G7 ; R526.1 346.88,36.68 347.4,36.16 v1(347.51,36.16) ; CON400.26 v1(85.23,70.17) ; v3(361.45,128.11) 361.41,128.11 361,128.52 R17932.2 ; C7105.1 361.38,130 361.19,130.19 v3(360.46,130.19) 360.41,130.24 R17933.2 ; v1(113.75,88.48) 113.84,88.57 113.84,89.01 ; v3(358.3,133.54) 358.72,133.96 D7108.1 ; v1(205.03,101.3) U2000.AH5 ; v1(89.16,70.19) 89.44,70.19 89.73,69.91 CON400.8 ; JDIM1002.86 134.85,30.93 v1(134.61,30.68) ; v3(358.25,116.17) 358.36,116.28 D7120.1 359.19,116.28 359.32,116.41 D7132.1 359.97,116.41 360.24,116.74 v1(360.24,117.13) 359.61,117.13 D7124.1 ; U2000.AL32 202.91,124.3 v1(202.52,124.68) 202.93,125.09 U2000.AL33 202.88,125.1 202.55,125.43 202.52,125.43 202.52,125.45 v1(202.51,125.45) ; U9001.AK29 U9001.AK30 ; U9001.AK29 v1(157.56,120.52) ; U9001.AK29 v1(158.32,120.52) ; U2010.3 230.96,89.55 231.68,90.28 v1(231.68,90.39) ; JDIM1002.60 128.35,30.93 v1(128.6,30.68) ; v1(175.82,109.04) 175.82,108.97 U9001.F13 ; CON5100.27 322.13,33.65 321.6,33.11 v1(321.6,32.93) ; U9001.C5 177.77,103.45 v1(177.77,103.52) 177.77,103.59 U9001.D6 177.44,104.05 U9001.C8 178.09,104.77 v1(177.77,105.1) ; U9001.AP33 155.07,124.09 ; 155.07,124.09 U9001.AP34 ; 155.07,124.09 v1(155.14,124.09) ; VRAM2501.K2 216.66,143.63 216.1,143.63 VRAM2501.K1 ; v1(220,120.6) 220.03,120.6 U2000.K28 ; U9001.A12 180.37,107.85 v1(180.48,107.96) ; U9001.BP33 139.74,123.7 v1(139.74,123.77) 139.42,124.09 U9001.BR34 ; v1(178.42,106.68) 178.42,106.74 U9001.C11 178.09,107.2 U9001.D12 ; v1(258.05,5.86) 258.93,6.74 CON9500.7 ; U9001.AG30 159.88,122.14 v1(159.86,122.14) ; U9001.A14 180.24,109.43 v1(180.37,109.56) ; CON400.49 79.23,61.69 78.76,61.23 C400.1 ; v1(324.64,9.16) 324.64,9.15 CON5101.21 ; v1(175.17,118.48) 175.17,118.56 U9001.G26 175.49,119.01 U9001.F27 ; v1(320.48,36.74) 320.48,37.45 321.17,38.15 CON5100.45 ; v1(170.1,127.34) 170.17,127.34 U9001.P38 ; U9001.A24 179.96,117.3 179.99,117.33 180.2,117.33 v1(180.22,117.35) ; v3(360.89,112.89) 361.36,113.37 C7100.1 ; CON5100.3 321.98,27.65 v1(321.72,27.4) 321.97,27.15 CON5100.1 ; v1(180.13,112.76) 179.94,112.58 U9001.A18 ; U9001.AL34 156.78,124.74 v1(156.71,124.74) ; JDIM1002.10 115.85,31.18 115.7,31.03 115.65,31.03 v1(115.3,30.67) ; CON400.32 83.73,69.86 83.42,70.17 v1(83.29,70.17) ; v1(176.37,124.74) 176.4,124.74 ; 176.4,124.74 176.46,124.74 U9001.E35 ; PU13002.19 v1(215.42,36.89) ; CON400.25 85.23,64.21 85.5,64.48 v1(85.76,64.48) ; v1(234.22,77.94) v1(233.46,78.7) ; CON5100.15 v1(321.6,30.65) 321.6,29.43 321.87,29.15 CON5100.9 ; U2000.AL20 202.69,114.49 202.69,114.91 U2000.AL21 202.57,115.41 202.43,115.41 202.08,115.77 U2000.AM22 202.08,116.01 v1(201.71,116.38) U2000.AN22 ; v1(163.01,127.34) 163.08,127.34 U9001.AC38 ; CON5101.71 324.42,21.65 324.51,21.74 324.53,21.74 v1(324.71,21.93) 324.49,22.15 CON5101.73 ; PU8001.4 v1(236.25,148.77) ; U9001.AR38 154,127.01 v1(154.35,127.36) ; C4008.1 18.19,128.23 17.72,128.7 v1(17.72,129.8) 17.72,132.08 18.07,132.42 22.13,132.42 22.34,132.21 v1(22.34,131.5) v1(22.34,128.87) ; v1(166.07,120.52) v1(165.43,120.52) U9001.AA29 U9001.AA30 165.36,122.14 v1(165.37,122.14) ; v1(177.77,105.1) 178.09,105.42 U9001.C9 U9001.B9 U9001.A9 180.54,105.49 180.71,105.32 v1(180.71,105.31) ; v1(177.77,105.1) 177.77,105.17 U9001.D9 ; v1(180.1,120.56) 179.99,120.45 U9001.A28 ; v1(164.52,30.72) 164.52,30.79 164.36,30.96 JDIM1002.196 ; U2000.AN25 U2000.AM25 ; U2000.AM25 v1(202.48,118.85) ; v1(63.25,52.52) 63.28,52.52 63.43,52.67 CON3000.5 ; JDIM1002.102 138.85,31.17 139.1,30.92 v1(139.1,30.68) ; v1(351.97,40.12) 351.97,40.91 R10051.1 ; v1(125.79,30.67) 125.84,30.67 126.35,31.19 JDIM1002.52 ; U9001.D26 177.75,119.19 177.75,119.32 U9001.C27 178.42,119.99 v1(178.42,120.06) ; PU13002.4 v1(212.59,33.62) ; v1(142.54,126.04) 142.61,126.04 U9001.BJ36 ; U9001.BT24 138.46,117.07 v1(138.26,117.28) ; U9001.F31 176.03,122.7 175.63,122.7 U9001.H32 175.14,123.11 v1(174.82,123.44) 174.76,123.44 U9001.J33 174.38,123.76 v1(174.05,123.43) 174.37,123.11 U9001.J32 ; v1(180.1,106.41) 179.97,106.28 U9001.A10 ; U9001.C29 177.77,121.56 v1(177.77,121.63) 177.77,121.7 U9001.D30 ; JDIM1002.40 123.35,31.16 123.22,31.03 v1(123.22,30.7) ; U9002.E33 247.42,58.41 U9002.D33 ; v1(200.88,123.02) 201.28,122.62 U2000.AN30 v1(200.88,122.2) ; v1(341.66,12.31) 342.34,12.31 343.25,11.41 CON4201.51 ; v1(163.8,124.74) 163.87,124.74 U9001.AB34 ; U9001.AE34 161.5,124.74 v1(161.44,124.74) ; CON5101.15 322.24,7.65 v1(322.23,7.66) ; v1(169.6,30.68) 169.85,30.93 JDIM1002.218 ; U9001.W34 166.23,124.74 v1(166.16,124.74) ; CON401.12 252.4,41.6 252.11,41.89 v1(251.62,41.89) 251.4,41.67 CON401.14 ; R17937.2 359.85,113.35 v3(359.57,113.63) ; v1(21.2,127) 21.22,127 21.25,127.02 C4009.1 ; v1(322.26,12.15) CON5101.33 ; v1(50.55,52.64) 50.93,53.02 CON3000.30 ; JDIM1002.234 173.85,30.93 v1(174.1,30.68) ; JDIM1002.68 130.35,30.93 v1(130.6,30.68) ; JDIM1002.72 v1(131.35,30.7) ; U9001.D9 177.31,105.62 176.92,105.62 U9001.E9 ; U9001.D9 U9001.D10 ; U9001.F36 175.67,125.39 175.54,125.39 U9001.H35 174.89,125.39 174.76,125.39 U9001.J36 174.1,125.39 v1(174.03,125.39) ; v1(171.1,30.68) 170.85,30.93 JDIM1002.222 ; U9001.BE30 U9001.BE29 146.08,121.07 v1(145.67,120.66) ; CON3000.8 61.93,55.74 v1(62.01,55.82) ; v1(59.49,56.17) 60.43,55.23 CON3000.11 ; R2112.1 231.47,83.74 231.47,82.82 231.03,82.39 230.69,82.39 229.89,81.58 PU25002.3 ; v1(331.88,143.07) 332.05,142.9 PQ10005.4 ; v1(141.04,116.68) 141.04,116.61 U9001.BM23 ; U9001.F29 175.85,120.94 175.85,120.81 U9001.G28 175.17,120.13 v1(175.17,120.06) ; U9001.T33 168.59,124.09 v1(168.52,124.09) ; v1(162.6,30.68) 162.35,30.93 JDIM1002.188 ; U9001.A20 179.94,114.15 v1(180.07,114.28) ; U9001.BR29 139.09,121.34 v1(139.09,121.4) 138.77,121.08 U9001.BT29 ; v1(161.6,30.68) 161.35,30.93 JDIM1002.184 ; v1(20.48,125.72) 19.06,125.72 18.69,126.08 v1(18.69,127.6) ; CON10002.6 244.33,7.67 v1(243.43,6.76) ; JDIM1002.252 178.35,31.18 178.08,30.91 v1(178.08,30.7) ; v1(58.99,52.34) 58.93,52.39 CON3000.14 ; U9001.G14 175.17,109.75 v1(175.17,109.82) ; v1(202.55,123.06) 202.88,122.73 U2000.AL30 ; v1(159.86,125.39) 159.79,125.39 U9001.AH35 ; JCN9000.24 271.74,15.01 v1(271.56,14.82) ; v1(178.42,115.34) 178.42,115.27 U9001.C21 178.09,114.8 U9001.D20 ; JDIM1002.22 v1(118.85,30.7) ; v1(320.96,32.93) 320.96,32.79 321.6,32.15 CON5100.21 ; v1(163.01,122.14) 163,122.14 U9001.AD30 U9001.AD29 v1(163.14,120.52) v1(163.78,120.52) ; U6001.J12 272.86,28.89 v3(273.2,29.24) ; JDIM1002.26 119.85,31.07 119.72,30.93 v1(119.72,30.7) ; JDIM1002.56 127.35,31.16 v1(127.79,30.72) ; v1(140.39,123.77) 140.39,123.83 U9001.BP34 ; v1(270.62,31.59) 270.52,31.48 U6001.M9 ; CON400.20 v1(86.73,70.15) ; 244.57,60.92 U9002.C25 ; U6001.A1 265.06,23.69 v1(264.7,23.33) ; U9001.AC37 163.08,126.69 v1(163.01,126.69) ; v1(237.39,86.32) 236.53,86.32 235.62,85.42 U2011.3 234.02,85.42 233.76,85.17 233.76,84.77 R2152.2 ; v1(322.03,15.15) 322.03,15.15 CON5101.45 ; U9001.AR37 154.02,126.36 v1(154.35,126.04) 154.02,125.71 U9001.AR36 ; v1(243.7,120.2) 243.33,120.57 VRAM2502.L5 243.33,120.63 243.2,120.76 242.66,120.76 242.53,120.63 VRAM2502.M5 ; C6007.1 268.38,19.9 v1(268.55,19.73) ; U9001.D22 178.09,116.38 U9001.C23 178.42,116.84 v1(178.42,116.91) ; JDIM1002.238 v1(174.85,30.7) ; U9001.J18 U9001.H18 174.79,112.59 v1(175.17,112.97) 175.17,112.9 U9001.G18 175.82,112.25 v1(175.82,112.19) 175.82,112.12 U9001.F17 ; U9002.BF48 267.44,67.77 U9002.BG48 267.7,67.85 v1(268.25,67.85) ; v1(146.47,127.34) 146.54,127.34 U9001.BD38 146.77,126.91 146.77,126.47 U9001.BD37 ; U9001.AJ38 158.61,127.01 v1(158.29,126.69) 158.35,126.69 U9001.AJ37 ; U9001.BL38 142.22,127.08 v1(141.86,127.44) 141.51,127.08 U9001.BM38 ; v1(178.42,113.76) 178.42,113.69 U9001.C19 ; v1(133.61,30.68) 133.85,30.93 JDIM1002.82 ; v1(163.8,124.09) 163.87,124.09 U9001.AB33 ; JDIM1002.78 v1(132.85,30.7) ; PR8005.1 v1(235.62,149.41) ; v1(118.1,30.68) 117.85,30.93 JDIM1002.18 ; U9001.BN24 140.39,117.4 v1(140.39,117.47) ; U9001.BL14 142.67,108.55 U9001.BK13 142.14,108.28 U9001.BL13 ; CON5101.27 v1(324.64,10.65) ; v3(358.25,133.01) 358.29,133.05 D7104.1 ; CON5101.39 v1(322.18,13.65) ; v1(117.3,30.72) 116.85,31.17 JDIM1002.14 ; U9001.A30 179.98,122.23 v1(180.1,122.11) ; PR19037.2 v1(159.42,131.36) ; U9001.BM22 v1(141.04,115.1) ; U9001.BR14 U9001.BT14 ; JDIM1002.180 v1(160.35,33.54) ; U8001.T6 v3(348.08,111.98) ; U9001.AD12 v1(163.45,107.87) ; v1(177.35,30.7) JDIM1002.248 ; CON5101.3 322.09,4.65 v1(321.85,4.41) 322.11,4.15 CON5101.1 ; R9059.1 v1(233.62,73.27) ; CON5101.9 v1(322.23,6.15) ; D7106.1 v3(358.81,136.36) ; U2000.AH16 v1(204.98,111.35)
  BOTTOM w0.279: CON4201.3 331.25,7.59 v1(331.4,7.44) 331.75,7.79 CON4201.5 ; CON4201.11 333.25,7.39 v1(333.28,7.36) ; v1(222.79,86.62) 222.33,86.62 222.17,86.78 U2005.3 ; CON4201.73 348.75,7.59 v1(348.52,7.36) 348.25,7.63 CON4201.71 ; v1(198.53,85.27) 198.83,85.58 PU9503.3 ; CON400.7 89.73,61.59 89.57,61.43 v1(89.57,61.3) ; CON400.50 79.23,70.02 79.48,70.27 v1(79.48,70.32) ; CON400.19 86.73,64.09 86.39,64.43 v1(86.39,64.48) ; v1(87.76,61.21) 87.82,61.21 88.23,61.62 CON400.13 ; U2007.3 203.77,86.52 203.57,86.32 v1(203.57,86.13) ; PQ23008.4 113.84,89.01 ; PU23001.3 108.48,88.6 v1(108.36,88.48) ; CON5101.57 324.62,18.15 v1(324.67,18.1) ; CON5100.51 323.94,39.65 324.39,40.1 v1(324.39,40.93) 324.17,41.15 323.06,41.15 CON5100.57
  BOTTOM w0.305: v1(356.39,26.51) 356.39,27.68 R10056.1 ; U6301.3 20.72,99.04 v1(20.48,99.28) ; U2000.AN10 201.16,105.83 200.04,105.83 v1(199.82,105.61) ; v1(224.15,118.76) 224.06,118.68 223.21,118.68 U2000.G25 ; U2000.E10 224.6,105.87 223.91,105.87 v1(223.4,106.37) U2000.G10 ; VRAM2500.R3 204.39,137.76 v1(204.35,137.76) 203.98,138.13 VRAM2500.R4 ; VRAM2501.R4 v1(218.78,148.15) VRAM2501.T5 ; VRAM2501.R4 v1(218.77,147.36) ; VRAM2501.R4 v1(217.98,147.35) VRAM2501.R3 ; VRAM2503.H13 243.77,99.37 243.77,99.36 v1(243.75,99.34) ; VRAM2500.H2 VRAM2500.H1 206.9,143.75 v1(207.31,143.34) ; VRAM2501.C11 223.61,138.52 v1(223.58,138.52) 223.18,138.92 VRAM2501.D10 ; VRAM2501.C11 223.98,138.11 v1(224.38,137.71) 224.78,138.1 VRAM2501.C12 ; VRAM2501.C11 v1(223.58,137.75) VRAM2501.B10 ; v1(197.17,139.37) 197.55,139.75 VRAM2500.N12 ; VRAM2500.C11 v1(198.78,148.15) VRAM2500.B10 v1(199.58,148.95) ; U2000.AP2 200.22,99.04 v1(200.22,98.8) 200.52,98.5 U2000.AN1 ; VRAM2503.K13 246.08,99.39 246.08,99.38 v1(246.1,99.35) 245.73,98.98 VRAM2503.K14 245.73,98.94 v1(245.73,98.35) ; VRAM2502.H13 v1(246.13,127.42) ; v1(239.77,127.41) 240.13,127.77 VRAM2502.R14 240.13,127.86 240.47,128.2 v1(240.47,128.35) ; VRAM2500.P10 v1(198.78,138.55) VRAM2500.R11 ; VRAM2501.H14 v1(225.98,141.75) VRAM2501.H13 ; VRAM2500.L10 VRAM2500.M10 199.18,140.55 v1(198.78,140.15) ; VRAM2503.G10 VRAM2503.F10 v1(242.13,101.74) ; U2000.T7 v1(215.03,103.8) ; v1(225.1,101.32) 224.72,101.7 U2000.E5 ; VRAM2503.C1 239.94,109.53 v1(239.94,109.92) ; VRAM2500.R14 195.38,138.15 v1(195.37,138.16) ; v1(220.02,103.79) 220.04,103.79 U2000.K7 ; VRAM2502.F10 v1(247.73,125.01) ; U2000.A2 v1(227.48,98.9) U2000.B1 ; v1(225.08,118.88) 225.08,118.85 U2000.E25 ; v1(201.67,101.34) U2000.AN4 ; v1(215.4,144.12) 215.61,144.12 VRAM2501.K1 ; VRAM2502.R4 240.11,119.81 v1(239.74,119.45) 239.74,119.4 VRAM2502.R3 ; VRAM2503.C4 v1(240.53,107.34) VRAM2503.C3 ; VRAM2502.C4 249.73,119.82 v1(250.13,120.22) ; C6502.1 307.34,45.22 307.25,45.13 ; Q4106.4 329.36,68.18 v1(330.36,69.18) ; VRAM2503.R3 v1(249.33,107.34) VRAM2503.R4 ; v1(58.78,47.59) 58.58,47.59 57.65,48.52 Q3009.4 ; v1(207.19,137.75) 206.78,137.75 VRAM2500.R1 ; v1(195.58,149.71) 195.93,149.35 VRAM2500.A14 ; v1(223.36,102.13) U2000.G5 ; v1(349.16,63.97) 349.12,63.93 U4100.99 ; VRAM2501.C4 v1(217.98,138.55) 217.59,138.15 VRAM2501.C3 ; v1(248.53,108.14) VRAM2503.N3 248.53,107.34 v1(248.53,107.34) ; v1(223.41,121.42) U2000.G28 v1(222.58,120.6) ; v1(315.73,48.53) 316.26,49.06 C6201.2 ; VRAM2501.N1 v1(215.38,146.15) ; U2000.K33 220.56,125.23 220.56,125.75 v1(220.04,126.26) ; VRAM2502.E1 v1(248.13,116.35) ; VRAM2501.H1 v1(216.38,141.75) VRAM2501.H2 ; v1(243.84,116.54) 243.84,117.12 VRAM2502.K1 VRAM2502.K2 ; VRAM2502.H14 245.5,128.05 245.5,128.32 ; v1(251.06,98.43) 251.06,98.74 251.25,98.94 VRAM2503.U14 ; VRAM2503.R12 250.15,100.12 v1(250.15,100.12) ; VRAM2501.E3 217.53,139.75 v1(217.18,139.4) ; v1(249.31,106.52) VRAM2503.R4 ; VRAM2503.R4 v1(250.13,106.54) VRAM2503.T5 ; R10054.1 354.58,28.19 353.98,28.79 v1(353.98,28.92) ; v1(226.92,136.22) 226.59,136.55 VRAM2501.A14 ; VRAM2502.C11 249.73,125.41 v1(250.13,125.01) ; U2000.B34 227.26,126.08 227.26,126.8 227.22,126.84 227.21,126.83 v1(227.19,126.85) ; VRAM2503.E1 241.83,109.44 241.83,109.92 v1(241.84,109.92) ; VRAM2502.F5 246.94,121.01 v1(246.92,121.01) VRAM2502.G5 ; VRAM2500.C4 v1(203.58,148.15) VRAM2500.B5 ; VRAM2500.C4 v1(203.58,147.35) ; VRAM2500.C4 v1(204.38,147.35) VRAM2500.C3 ; EC5102.2 312.08,45.76 312.08,45.93 312.49,46.34 v1(312.71,46.34) ; VRAM2502.L10 243.18,124.47 242.68,124.47 VRAM2502.M10 v1(242.13,125.01) ; v1(217.16,143.37) VRAM2501.K2 ; R10049.1 353.88,40.35 v1(353.88,40.12) ; VRAM2500.K14 v1(196.38,141.75) VRAM2500.K13 ; U2000.K5 220.05,101.32 v1(220.05,101.31) ; PC23017.2 199.49,14.65 199.38,14.76 199.38,15.59 199.22,15.75 199.14,15.75 PC23018.1 ; VRAM2503.C11 v1(239.73,100.94) VRAM2503.C12 240.13,100.54 v1(240.51,100.16) ; v1(199.96,126.3) 200.81,126.3 v1(200.84,126.34) ; v1(225.18,148.95) VRAM2501.U12 225.23,149.8 225.95,149.8 v1(225.99,149.75) 226.38,149.36 VRAM2501.U14 ; PQ10004.1 339.06,136.09 339.15,136.01 339.55,136.01 339.71,136.16 v1(339.71,136.34) ; U2000.T5 v1(214.98,102.15) ; v1(291.37,9.87) 291.7,9.54 CON7200.4 ; v1(240.19,92.67) 240.41,92.46 240.41,89.99 ; PQ8003.1 232.33,150.18 v1(231.89,150.62) ; VRAM2502.D10 v1(248.53,125.01) ; U2000.B4 227.48,100.55 v1(227.48,100.53) ; VRAM2501.A3 217.46,136.43 217.46,136.11 217.47,136.11 v1(217.47,136) ; CON401.10 253.4,41.97 v1(253.47,42.03) ; v1(246.05,116.39) 246.05,117.1 VRAM2502.H1 VRAM2502.H2 ; VRAM2501.F5 v1(218.78,140.95) VRAM2501.G5 ; VRAM2501.L10 v1(222.78,144.95) VRAM2501.M10 ; VRAM2503.B5 v1(238.93,106.54) ; VRAM2503.C14 239.81,98.62 v1(239.81,98.31) ; 345.68,75.78 345.89,75.57 U4100.26 ; 345.68,75.78 v1(345.68,75.78) ; 345.68,75.78 345.69,75.78 345.59,75.88 R4124.1 ; v1(207.16,148.58) 207.15,148.58 VRAM2500.A1 ; VRAM2503.U3 251.69,108.1 v1(251.85,108.1) ; VRAM2501.N3 v1(217.98,146.55) ; v1(238.53,109.92) VRAM2503.A1 ; VRAM2502.U3 238.48,119.02 238.19,119.31 v1(238.03,119.31) ; v1(310.29,64.53) 310.29,64.48 311.16,63.61 U8000.4 ; U2000.AL28 202.88,120.97 v1(202.48,121.37) ; v1(241.36,127.43) 241.39,127.43 241.43,127.48 241.43,127.52 VRAM2502.N14 ; VRAM2502.K13 v1(243.73,127.42) VRAM2502.K14 ; VRAM2501.C1 215.5,138.15 v1(215.42,138.07) ; U2000.G30 222.96,122.7 v1(223.35,123.1) ; VRAM2503.A12 237.8,100.54 v1(237.56,100.3) ; VRAM2500.L5 203.18,141.35 v1(203.58,140.95) VRAM2500.M5 ; v1(210.85,102.9) 210.43,103.33 U2000.AB7 ; VRAM2500.D10 199.79,146.95 v1(199.8,146.94) ; VRAM2500.U1 206.71,136.22 v1(207.24,136.22) ; VRAM2503.L10 246.53,102.65 v1(246.35,102.82) ; VRAM2500.F5 203.13,145.3 202.5,145.3 v1(202.38,145.17) 203,144.55 VRAM2500.G5 202.79,144.16 v1(202.44,144.16) ; VRAM2503.E3 241.73,107.79 241.38,108.14 v1(241.38,108.14) ; v1(249.14,97.83) 249.48,97.83 249.73,98.07 VRAM2503.R14 ; U4100.98 347.64,74.9 346.87,74.13 v1(346.87,74) 347.04,73.84 U4100.A26 ; v1(204.79,150) 204.78,149.99 VRAM2500.A3 ; v1(272.5,55.44) 272.61,55.55 R9382.2 ; v1(253.78,128.18) 252.36,128.18 252,127.81 VRAM2502.A14 ; PC23014.2 202.95,11.45 202.72,11.68 PU23002.5 ; VRAM2500.K2 205.73,142 206.23,142 VRAM2500.K1 206.51,142.02 v1(207.31,142.02) ; VRAM2501.U1 v1(215.53,149.8) ; U4100.20 v1(342.89,75.82) ; VRAM2500.T5 203.56,136.97 v1(203.58,136.97) ; CON7300.1 v1(281.5,7.84) ; v1(354.36,33.49) 354.36,32.97 R10053.2 ; VRAM2502.E3 247.76,118.64 v1(247.76,118.63) ; VRAM2502.R1 240.06,117.42 239.43,116.78 v1(239.43,116.53) ; VRAM2500.E14 195.39,146.15 v1(195.37,146.13) ; v1(228.27,98.04) 229.05,98.82 v1(229.05,98.97) ; VRAM2502.C14 249.75,127.84 249.75,128.36 v1(249.78,128.38) ; Q3009.1 58.79,49.61 58.35,50.05 57.89,50.05 v1(57.46,50.49) ; U2000.AN34 v1(200.84,126.34) ; v1(200.84,126.34) v1(200.84,127.04) ; VRAM2503.R1 249.95,109.56 v1(249.95,110.48) ; U6001.G1 264.87,27.59 v1(264.75,27.47) ; 270.62,76.69 270.62,77.03 271.13,77.54 v3(271.13,77.56) ; v1(215.36,136.8) 215.73,136.8 VRAM2501.A1 ; U3011.3 18.94,63.97 18.57,63.59 R3094.2 ; U2000.AE5 207.85,101.78 v1(207.85,102.45) 207.83,102.48 207.83,103.3 U2000.AE7 ; C9216.1 266.88,77.48 v3(267.32,77.92) ; VRAM2501.E14 226.87,139.75 v1(226.97,139.84) ; U2000.N2 217.93,98.6 v1(217.9,98.57) ; U2000.G2 222.93,99.33 v1(223.33,99.73) 222.97,100.1 U2000.G3 ; VRAM2502.B10 v1(250.13,124.21) ; VRAM2500.N1 206.77,139.75 v1(207.2,139.32) ; v1(247.03,124.14) 246.55,124.61 VRAM2502.G10 ; R5109.1 324.84,21.8 v1(324.71,21.93) ; v1(205.18,139.4) 205.13,139.4 VRAM2500.N3 ; v1(245.34,108.16) 245.72,108.54 VRAM2503.K2 ; v1(344.39,75.78) U4100.23 ; v1(238.05,116.51) 238.05,116.93 VRAM2502.U1 ; VRAM2503.G5 243.28,106.14 v1(242.88,106.54) 242.53,106.19 VRAM2503.F5 ; VRAM2500.R11 v1(197.98,138.55) VRAM2500.R12 ; VRAM2500.R11 v1(197.96,137.73) ; VRAM2503.B10 238.95,101.76 v1(238.95,101.76) ; VRAM2500.E12 v1(197.97,145.76) ; v1(246.21,109.92) 245.73,109.44 VRAM2503.K1 ; U4100.38 348.14,69.68 v1(348.77,69.05) ; CON6000.1 v1(32.73,143.35) ; CON401.8 254.4,42.03 v1(254.33,42.09) ; VRAM2502.T5 238.93,120.21 v1(238.93,120.17) ; CON7300.9 v1(273.5,7.87) ; v1(204.93,113.79) 205.04,113.79 U2000.AH19 ; v1(247.42,102.67) 247.33,102.58 VRAM2503.M10 ; v1(202.48,118.85) 202.88,119.25 U2000.AL26 ; v1(248.56,100.13) 248.51,100.13 248.13,100.52 VRAM2503.N12 ; v1(270.9,42.76) 270.9,42.15 271.16,41.89 PU25001.3 ; VRAM2500.C1 v1(205.98,147.35) ; v1(218.35,103.78) 218.31,103.78 U2000.N7 ; VRAM2502.T10 v1(238.93,125.01) ; CON6000.8 v1(36.23,143.35) ; v1(225.9,121.38) 226.28,121 U2000.C28 ; v1(208.36,120.6) 208.23,120.72 208.21,120.72 U2000.AE28 208.35,121.42 v1(208.36,121.42) ; v1(214.98,99.7) 215.03,99.7 U2000.T2 ; 208.3,126.3 207.6,127 v1(207.51,127) ; 208.3,126.3 v1(208.36,126.3) ; 208.3,126.3 v1(207.51,125.5) ; PQ10005.1 333.35,139.98 v1(333.58,139.74) ; VRAM2502.A3 251.31,119.02 v1(250.92,118.63) ; VRAM2503.N1 247.96,109.51 v1(247.96,109.91) ; v1(106.08,5.55) 106.22,5.55 106.98,6.31 CON6351.4 ; v1(180.1,124.95) 179.99,124.85 U9001.A34 ; U4100.62 v1(340.39,63.16) ; v1(247.73,106.54) VRAM2503.M5 v1(246.93,105.74) VRAM2503.L5 ; v1(224.38,146.55) VRAM2501.N12 v1(225.18,146.55) ; VRAM2502.E12 v1(247.73,125.82) ; VRAM2503.U1 v1(251.78,109.79) ; U2000.AH7 205.28,103.4 v1(204.93,103.05) ; VRAM2501.F10 223.18,140.58 223.57,140.97 v1(223.57,140.99) 223.21,141.35 VRAM2501.G10 ; U2000.AJ7 v1(204.12,103.04) ; VRAM2503.H14 244.13,98.87 v1(243.64,98.38) ; VRAM2503.N14 248.01,98.82 v1(248.01,98.23) ; VRAM2503.T10 250.08,102.59 v1(250.01,102.59) ; VRAM2502.N3 v1(242.12,119.4) ; VRAM2501.C14 226.46,138.07 v1(226.98,138.07) ; VRAM2502.P10 v1(240.53,125.01) VRAM2502.R11 v1(239.73,125.82) VRAM2502.R12 ; v1(205.04,98.91) U2000.AH2 ; VRAM2500.U3 204.36,136.13 204.32,136.13 v1(204.33,136.14) ; U2000.D33 v1(225.43,125.84) ; U2000.G22 v1(222.56,115.52) ; v1(197.18,148.95) VRAM2500.A12 ; v1(225.18,143.35) VRAM2501.K13 225.73,143.6 226.23,143.6 VRAM2501.K14 226.85,143.75 v1(226.97,143.87) ; U2004.3 202.74,92.54 202.94,92.73 v1(202.94,93.63) ; VRAM2501.T10 v1(222.78,148.95) ; v1(341.39,75.71) U4100.17 ; v1(241.78,98.35) 241.78,98.89 VRAM2503.E14 ; VRAM2503.U12 v1(250.93,100.14) ; VRAM2500.G10 199.4,144.55 199.68,144.83 v1(199.68,145.12) 199.41,145.12 VRAM2500.F10 199.14,145.35 198.76,145.72 v1(198.76,145.75) ; v1(240.77,116.53) 240.85,116.53 VRAM2502.N1 ; v1(226.98,146.15) VRAM2501.N14 ; v1(197.98,136.15) VRAM2500.U12 ; v1(237.89,98.39) 237.89,98.51 238.33,98.94 VRAM2503.A14 ; v1(247.97,128.4) 248.13,128.24 VRAM2502.E14 ; VRAM2501.A12 v1(224.4,136.17) ; VRAM2500.T10 v1(198.78,136.95) ; v1(217.58,149.91) VRAM2501.U3 ; v1(238.14,125.85) 238.17,125.85 VRAM2502.U12 ; VRAM2502.C1 249.37,117.77 v1(249.34,117.77) ; v1(220.03,122.3) U2000.K30 ; U2000.G16 v1(223.41,111.38) ; v1(222.78,147.35) VRAM2501.P10 v1(223.58,147.35) VRAM2501.R11 ; VRAM2502.B5 v1(250.93,121.01) ; VRAM2501.R12 v1(225.18,148.15) ; U6300.3 324.15,73.86 324.39,73.62 v1(324.39,73.29) ; VRAM2501.L5 v1(219.58,144.95) VRAM2501.M5 v1(218.78,145.75) ; VRAM2500.C12 197.54,147.75 v1(197.18,147.39) ; v1(225.88,108.85) U2000.C13 ; R8556.2 338.58,95.85 v1(339.12,95.85) ; v1(215.44,147.99) 215.68,147.75 VRAM2501.R1 ; VRAM2501.E1 215.45,139.75 v1(215.35,139.85) ; VRAM2500.E3 v1(205.18,146.55) ; v1(222.58,113.02) 222.58,113.05 U2000.G19 ; v1(227.51,123.9) 227.51,123.9 227.08,123.47 U2000.B31 ; v1(195.36,147.89) 195.5,147.75 VRAM2500.C14 ; VRAM2502.U14 238.91,128.19 v1(238.91,128.37) ; VRAM2500.U14 v1(195.45,136.55) ; VRAM2502.C3 v1(249.33,119.42) ; VRAM2500.N14 195.44,139.75 v1(195.29,139.9) ; VRAM2503.D10 v1(240.53,101.74) ; VRAM2502.A1 v1(250.92,117.01) ; VRAM2503.H2 v1(243.73,108.94) VRAM2503.H1 ; VRAM2503.R11 249.73,101.34 v1(249.33,101.74) VRAM2503.P10 ; VRAM2502.A12 v1(250.93,126.61) ; VRAM2502.C12 v1(249.33,125.81) ; U2000.AK7 v1(203.28,103.05) ; U2000.N28 v1(217.5,120.57)
  BOTTOM w0.356: Q6002.4 32.94,137.49 v1(33.18,137.25) ; v1(204.97,116.36) U2000.AH22 ; U2000.AH24 205.77,117.99 v1(205.77,118.02) ; Q6002.1 31.64,140.66 v1(31.78,140.81) ; U9001.B3 178.55,101.62 U9001.D3 177.46,101.51 v1(177.46,101.06) 177.48,101.08 U9001.C2 ; v1(175.17,117.7) 174.79,118.08 U9001.H25 U9001.J25 ; v1(328.07,62.32) 328.2,62.19 R501.1 ; v1(306.79,44.67) 306.52,44.4 305.19,44.4 305.09,44.3 Q6500.1
  BOTTOM w0.381: v1(338.61,58.76) 338.71,58.67 Q4104.1 ; C2563.2 209.7,146.46 v1(206.86,146.46) 206.69,146.46 VRAM2500.E1 ; U2000.E22 225.08,115.55 v1(225.08,115.53) ; C8050.1 338.67,120.55 v1(339.5,119.72) ; R9604.2 249.97,91.03 v1(249.97,91.78) ; C1108.2 153.2,44.15 153.47,43.88 154.74,43.88 155.02,44.16 v1(155.02,44.41) ; v1(225.9,111.37) 225.9,111.33 U2000.C16 ; R9016.1 270.53,18.24 v1(270.8,18.51) ; C8051.1 336.07,120.72 v1(336.07,121.26) ; v1(282.15,45.81) 282.15,45.61 281.58,45.04 R9598.2 ; v1(259.53,36.68) 259.39,36.82 259.39,37.78 CON401.19 ; C7314.2 v1(289.35,19.73) ; v1(364.65,60.54) 364.26,60.54 C12046.2 ; C8511.1 C8508.1 337.22,91.4 v1(336.96,91.66) ; v1(210.01,120.6) 210.03,120.6 U2000.AB28 ; C9501.2 255.69,10.06 255.53,9.9 PR11013.2 ; R9191.2 246.92,87.42 246.92,86.75 R9299.2 ; Q4105.4 340.96,59.13 340.52,59.57 v1(340.52,60.16) ; U2000.B7 227.48,103.05 v1(227.48,103.02) ; v1(324.16,69.31) 323.48,69.31 323.43,69.26 R525.2 ; C12045.2 362.23,60.79 v1(362.11,60.67) ; U2000.C19 225.92,113.81 v1(225.92,113.88) ; v1(299.35,12.21) 298.53,13.03 CON4200.12 ; v1(240.19,92.67) 240.32,92.8 C2558.2 ; U2000.C10 226.68,105.55 v1(226.68,105.53) ; 360.46,109.44 359.06,109.44 358.86,109.64 D7119.2 ; PR10008.1 338.1,140.04 v1(338.11,140.04) ; CON4200.13 298.53,5.96 v1(299.52,4.97) ; U2000.B28 227.49,121.36 v1(227.49,121.38) ; v1(293.4,37.81) 293.4,36.79 293.66,36.54 294.04,36.54 294.16,36.67 PU25000.4 ; Q3006.1 53.12,48.87 v1(53.12,48.63) ; CON3002.5 17.17,58.35 v1(17.17,60.74) ; U2000.AB32 210.83,123.9 v1(210.86,123.9) ; v1(225.88,116.37) 226.28,115.97 U2000.C22 ; v1(215.53,149.8) 213,149.8 C2561.2 ; C9230.1 231.91,70.04 v1(231.63,70.32) ; v1(243.43,6.76) 242.68,6.02 CON10002.8 ; U2000.A33 228.56,125.78 v1(228.66,125.78) ; C2597.1 229.78,143.19 v1(229.58,143) ; v1(333.58,139.74) 333.25,139.41 PR26016.1 ; U2000.W28 v1(212.54,120.61) ; C12043.1 C12044.1 v1(363.38,63.97) ; v1(54.9,50.81) 54.87,50.79 54.87,51.05 C3036.2 ; v1(195.74,101.18) 195.86,101.18 R2082.2 ; v1(339.41,19.53) 339.41,19.47 339.96,18.91 R4209.1 C4203.2 ; v1(355.25,108.66) 355.1,108.8 R8007.2 ; R9256.1 258.37,51.89 v1(258.71,51.55) ; v1(337.85,89.88) 338.22,89.88 C8587.1 C8586.2 ; v1(346.62,46.32) 346.62,45.82 R530.1 R528.1 ; PR25010.1 PC25000.2 298.2,35.65 v1(298.23,35.68) ; v1(202.51,98.9) 202.53,98.9 U2000.AL2 ; v1(196.51,56.11) PC9809.2 PC9808.1 198.67,56.11 v1(198.91,56.35) ; v1(294.8,46.32) 294.8,46.18 PR25017.2 PC25002.1 ; U2000.C25 v1(226.67,118.06) 226.69,118.06 U2000.B25 ; v3(263.35,81.5) 262.61,80.76 R9138.1 ; v1(342.81,17.78) 342.94,17.91 R4213.1 ; PC9804.2 200.7,54.12 v1(201.15,54.57) ; R9086.2 254.74,89.07 254.41,88.74 v1(254.41,88.64) 254.41,88.48 254.86,88.03 R9605.2 ; PU24000.2 186.85,156.17 186.6,155.92 v4(186.09,155.92) ; PC9807.1 191.33,49.87 v1(191.04,49.87) ; v1(268.02,60.71) 268.01,60.71 267.57,61.16 R9078.1 ; R9121.2 261.8,82.28 v3(262.19,82.67) ; R9150.2 266.48,59.14 v1(266.49,59.14) ; U2000.E7 v1(224.26,103.02) 224.25,103.02 U2000.F7 ; C7102.1 363.66,135.17 v1(363.81,135.32) ; VRAM2501.R14 226.88,147.75 v1(226.95,147.83) ; v1(269.43,19.97) 269.92,19.49 R6075.1 ; R2066.2 243.22,115.44 243.84,116.06 v1(243.84,116.54) ; v1(183.67,103.88) 183.7,103.85 184.18,103.85 184.94,104.61 PR17020.2 ; v1(337.55,31.43) 337.55,31.56 338.74,32.75 C534.2 ; Q2501.1 236.13,91.07 236.58,90.62 v1(236.58,90.41) ; C7108.1 363.84,118.65 v1(363.81,118.68) ; PC25001.1 PR25016.2 296.17,33.62 296.2,33.64 v1(296.2,33.67) ; v1(140.88,25.36) 140.67,25.57 140.67,25.6 140.49,25.77 R1008.2 ; U4200.2 341.28,23.21 341.79,23.72 v1(341.79,23.8) ; v1(312.71,11.14) 312.86,11.29 CON4200.17 ; v1(197.52,48.99) PR9809.2 ; R9212.1 269.04,62.8 269.63,63.39 v1(269.65,63.44) ; v1(331.1,51.75) 331.1,51.7 330.65,51.26 C505.2 C510.2 ; PC15007.1 205.64,23.93 v1(205.21,23.93) ; R2125.1 234.86,90.13 v1(234.6,90.38) ; PR11015.1 255.05,12.94 v1(255.86,12.13) ; R535.1 350.81,44.02 v1(350.3,43.5) ; v1(204.97,108.05) 204.98,108.05 U2000.AH13 v1(204.98,108.85) ; PC25003.1 299.47,39 v1(299.24,38.78) ; R550.2 349.35,39.77 349.01,39.77 348.94,39.84 v1(348.77,39.84) ; PC16011.1 295.37,14.24 v4(295.79,14.24) ; C2616.1 193.2,149.07 193.2,149.82 193.71,150.33 193.71,150.43 193.73,150.46 v1(193.76,150.43) ; v1(341.43,61.58) 341.43,61.13 341.61,60.95 342.24,60.95 342.76,60.43 Q4105.1 343.57,60.43 343.7,60.57 R4120.2 ; R2091.1 R2094.1 222.19,94.12 v1(222.19,93.53) ; v1(364.65,55.34) 364.27,55.72 C12064.2 ; R3094.2 18.57,62.7 v1(18.94,62.32) ; Q9003.1 129.71,104.24 v1(129.39,103.93) ; v1(173.62,115.35) 174,115.73 U9001.J22 U9001.H22 ; R9206.2 270.34,52.36 v1(270.34,52.24) ; R9594.2 270.69,70.6 v1(271.18,71.08) R9593.2 ; C6012.2 269.7,34.82 v1(269.7,35.4) ; PR10031.2 336.84,150.25 v1(336.77,150.32) ; v1(204.38,45.94) 203.88,46.44 PC9042.2 ; C7315.2 v1(285.93,20.36) ; C504.2 330,60.81 v1(330,60.44) ; v1(199.68,16.65) 199.05,16.03 PC23018.1 ; U2000.T28 215.17,121.26 v1(215.17,121.64) ; v1(240.47,128.35) 240.47,130.29 C2568.2 ; PR10024.1 340.71,150.27 v1(340.65,150.33) ; R9159.1 264.93,57.65 v1(264.93,57.6) ; U2000.AG11 206.18,106.77 v1(205.78,106.37) 205.38,106.77 U2000.AH11 ; v1(207.16,148.58) 207.67,148.58 208.3,149.21 C2560.2 ; v1(364.65,59.91) 364.52,59.78 R18071.2 ; CON3002.1 12.33,58.35 v1(12.3,58.38) ; R2099.1 v1(223.04,93.53) ; C539.2 332.7,45.81 v1(332.95,45.56) ; R9152.2 266.78,60.39 v1(267.26,59.91) ; v1(212.51,124.7) 212.91,124.3 U2000.W32 ; v1(341.79,23.8) 341.79,23.81 340.89,24.71 R18045.1 ; v1(341.79,23.8) 341.93,23.65 U4200.3 ; v1(241.78,98.35) 241.78,96.76 C2575.2 ; v1(195.37,146.13) 195.23,145.99 193.48,145.99 193.03,146.44 C2168.2 ; C2562.2 213.52,146.53 213.74,146.31 215.21,146.31 v1(215.38,146.15) ; C9222.2 272.17,69.92 v1(272.17,70.04) ; v1(248.13,116.35) 248.13,115.73 248.48,115.37 C2570.2 ; C9221.1 272.47,69.39 v1(272.65,69.58) ; C6003.2 259.66,29.53 259.61,29.57 v1(259.61,30.39) ; CON10002.7 247.48,6.36 v1(247.48,7) ; v1(203.28,105.52) 203.28,105.55 U2000.AK10 ; R9248.2 266.1,78.22 v3(266.52,78.64) ; v1(209.99,122.26) U2000.AB30 ; R2524.1 v1(239.3,92.67) ; C2567.2 192.95,136.25 193.25,136.55 v1(195.45,136.55) ; C9213.1 234.86,77.69 234.47,77.69 v1(234.22,77.94) 234.75,78.47 Y9000.2 ; v1(355.73,148.99) 355.48,148.73 355.48,147.56 353.6,145.68 PC10002.1 ; v1(353.98,30.44) R10001.2 R10002.1 R10003.1 ; R2087.1 221.21,90.39 v1(221.77,89.82) ; Q2006.1 195.37,88.98 v1(195.23,89.11) ; C509.2 v1(319.56,53.3) ; C2605.1 v1(254.66,103.99) ; v1(332.65,144.97) 332.65,145.45 332.81,145.62 PR10026.2 ; C9233.1 274.07,67.78 C9234.1 ; v1(218.35,123.9) 218.33,123.9 U2000.N32 217.91,124.3 v1(217.51,124.7) 217.9,125.1 U2000.N33 ; PC25005.2 270.03,40.1 v1(270.67,39.46) ; C1110.2 150.65,44.42 v1(150.1,44.97) ; v3(355,53.94) C12055.1 ; 307.25,45.13 v1(306.79,44.67) ; PR10032.2 338.15,150.25 v1(338.22,150.32) ; R2112.1 231.51,84.59 v1(231.5,84.6) ; PC17006.2 189.02,151.18 v1(188.63,150.79) ; v1(183.88,128.36) 184.51,128.36 184.78,128.62 R9049.1 R9050.1 ; v1(204.95,106.4) 204.95,106.38 U2000.AH10 ; R2150.2 228.33,85.85 PC25014.2 227.76,85.44 227.29,85.92 v1(227.29,86.22) ; R9195.2 262.29,49.62 v1(262.54,49.62) 262.69,49.77 R9369.1 ; v1(341,132.58) 341.03,132.58 341.15,132.7 341.15,133.04 341.15,133.05 341.15,133.76 341.15,133.76 Q7120.1 341.69,134.75 341.74,134.7 PR26014.1 ; R516.2 317.86,54.78 318.45,55.36 v1(318.45,55.56) ; C2566.2 193.21,138.91 193.96,138.16 v1(195.37,138.16) ; v1(329.98,65.24) 330.23,64.99 330.23,63.6 C513.2 ; v1(220.63,47.46) 220.51,47.34 PC13015.1 ; U2000.AE30 207.53,123.1 v1(207.51,123.1) ; Q2010.1 224.93,89.01 225.62,88.32 v1(225.62,87.69) ; v1(303.35,57.58) C6203.2 ; C2596.1 229.78,138.78 v1(229.7,138.86) ; D7307.1 39.73,66.05 v1(40.42,65.37) 40.09,65.04 C7331.2 ; v1(347.33,4) 346.31,4 345.68,4.64 C4215.2 345.68,5.54 R4225.2 ; PR9812.1 193.96,48.99 193.2,49.75 v1(193.2,50) ; v1(355.25,105.75) R8040.2 ; PR10021.2 348.76,135.83 v1(348.11,135.83) ; v1(195.29,139.9) 194.87,139.9 193.41,141.36 C2565.1 ; v1(227.51,116.38) U2000.B22 ; C6800.2 238.42,50.95 v1(238.92,51.45) ; v1(236.13,80.38) 235.77,80.74 235.38,80.74 Y9000.4 ; v1(349.92,104.23) 350.72,105.03 R8005.2 ; v3(258.31,83.92) R9236.2 ; R9599.2 v1(271.56,57.24) ; v3(361.19,132.48) 361.25,132.42 C7104.1 ; v1(35.74,68.97) 36.61,68.11 C7332.1 ; U2000.C7 226.68,103.05 v1(226.68,103.02) ; v1(249.08,6.97) 249.59,6.97 250.05,6.51 250.45,6.51 PC11023.2 ; v1(225.87,123.89) U2000.D31 ; PC23015.2 196.5,14.04 ; C6022.2 30.5,142.32 31.02,142.84 v1(31.27,142.84) ; U2000.T32 215.83,123.9 v1(215.86,123.9) ; R8031.2 v1(355.25,106.77) ; C3039.1 29.58,56.04 v1(30.08,55.54) 30.56,56.02 C3040.1 ; v1(269.65,64.09) 269.86,64.09 270.32,63.63 C9214.1 ; v1(326.04,79.47) 325.54,78.97 Q6300.1 ; C9195.2 239.18,78.47 v1(238.89,78.75) ; PC12003.2 210.06,5.55 209.66,5.15 v1(209.66,4.18) ; v1(198.08,104.18) 197.99,104.1 R2072.2 ; v1(238.05,108.01) 238.26,108.01 VRAM2503.A3 ; C12054.1 357.55,52.8 v3(357.54,52.8) ; v1(35.59,64.1) 35.51,64.18 C7330.2 ; v1(300.36,35.66) 300.35,35.65 PC25004.1 ; U2000.N30 v1(218.35,122.27) ; U2000.G13 v1(223.41,108.88) ; U2000.G32 222.9,124.3 v1(222.5,124.7) 222.9,125.1 U2000.G33 223.28,125.45 v1(223.28,125.61) ; v1(253.02,89.88) R9603.2 C9186.2 ; v1(203.13,23.97) 203.4,23.97 PR15008.1 ; v1(242.25,82.03) 242.63,81.65 R9272.1 ; v1(304.2,38.7) 304.46,38.97 304.46,39.96 305.09,40.58 C6503.1 ; PR10029.2 PR10030.2 337.33,147.96 337.6,148.22 v1(337.6,148.35) ; PR12003.2 PC12002.1 260.17,23.98 v1(259.94,24.21) ; v1(196.68,96.71) 196.65,96.75 R2079.2 ; v1(42.96,60.19) 42.97,60.17 R18046.1 C3028.2 ; R8032.2 356.91,106.26 357.94,106.26 358.48,106.8 v1(359.06,106.8) ; Q5101.1 309.16,39.48 v1(308.79,39.84) ; U6203.4 292.47,49.73 v1(292.23,49.49) ; VRAM2500.H13 v1(197.18,143.35) ; C3041.1 31.71,55.84 31.93,55.62 v1(31.93,55.41) ; C5113.1 312.73,45.68 v1(312.71,45.71) ; v3(361.19,115.84) 361.3,115.73 C7109.1 ; v1(226.68,106.37) 226.68,106.35 U2000.B10 ; v3(353.4,46.06) 353.22,45.89 R10050.2 ; C6309.2 323.84,72.66 v1(324.39,72.66) ; R2026.1 v1(232.06,92.39) ; U7300.12 v1(281.46,10.1) ; C2177.2 v1(254.63,105.28) ; C4100.1 v1(326.67,75.03) ; 175.55,86.07 175.55,89.42 176.05,89.93 U6401.5 ; R9167.1 R9058.2 232.38,74.57 v1(231.91,74.57) ; PC13003.2 202.1,40.99 202.85,41.75 v1(202.98,41.75) ; C2147.1 221.91,83.9 222.54,83.27 v1(222.54,82.84) ; CON4200.16 312.86,4.77 v1(312.85,4.76) ; v1(33.23,63.49) 33.41,63.67 R7314.2 33.57,64.48 33.71,64.48 33.99,64.76 33.99,66.09 C7322.1 ; R2022.1 v1(231.05,92.39) ; R2083.2 v1(224.06,93.53) ; R18078.2 v1(364.65,54.7) ; v1(204.22,48.55) 204.11,48.66 PC9033.2 PR9220.2 ; C2610.1 v1(254.66,101.43) ; 271.45,65.37 v1(271.48,65.34) 271.87,65.34 C9215.1 ; v4(186.09,156.68) 186.23,156.82 PU24000.3
  BOTTOM w0.4: VRAM2502.N12 241.37,126.57 v1(241.37,126.61)
  BOTTOM w0.406: v1(250.92,117.01) 250.92,116.39 251.31,116 C2571.2 ; v1(215.4,144.12) 212.78,144.12 R2062.2 ; v1(249.78,128.38) 249.78,128.51 251.35,130.07 C2569.2 ; VRAM2500.H14 195.65,143.42 v1(195.38,143.42) ; v1(247.97,128.4) 247.97,129.02 248.71,129.75 C2172.2 ; C7012.3 355.38,75.91 v1(355.51,75.78) ; C2171.2 244.81,129.26 245.5,128.57 245.5,128.32 v1(245.49,128.32)
  BOTTOM w0.457: v1(14.89,88.86) U7000.8 U7000.3 v1(17.18,88.86) ; v1(17.43,107.15) U7001.3 U7001.8 15.17,107.15 v1(15.12,107.1) ; v1(19.46,106.77) 19.84,107.15 C618.2 ; R601.1 24.54,102.71 24.8,102.45 v1(24.9,102.45) ; R613.1 v1(23.78,111.47)
  BOTTOM w0.508: v1(257.74,11.93) 257.74,12.16 257.84,12.26 JCN9000.31 257.84,15.35 257.2,16 R9383.2 ; v1(229.76,92.29) Y2000.4 ; C2623.1 247.56,96.48 247.71,96.32 C2181.2 248.35,95.85 248.86,95.34 v1(249.08,95.34) ; v1(301.91,17.87) 302.94,16.85 CON4200.10 ; v1(357.66,107.66) 357.41,107.66 357.03,108.04 R8006.2 ; v1(353.35,83.76) 352.43,83.76 352.33,83.66 Q4103.1 ; v1(219.37,39.38) 219.5,39.51 PR13008.1 ; v1(289.34,24.37) 289.3,24.33 Y7300.2 ; C7303.2 284.26,21.55 v1(284,21.81) 283.72,22.09 282.45,22.09 281.85,21.48 C7306.2 C7309.2 C7310.2 ; PC11009.2 PC11010.1 v1(252.64,15.33) ; PC9002.2 206.4,57.77 v1(206.05,58.12) ; v1(68.61,64.58) 68.46,64.73 R3041.2 ; PC19003.1 v1(124.37,155.03) ; C7110.1 365.66,136.11 v1(366.43,136.11) ; v1(224.19,91.37) 224.19,91.87 R2084.2 ; R2063.2 209.75,141.49 207.9,143.34 v1(207.31,143.34) ; v1(131.22,152) 131.8,152 PC19005.2 ; R8512.2 339.25,100.04 v1(338.82,100.47) 338.38,100.91 C8506.1 ; v1(25.94,93.69) 25.81,93.82 C6303.1 ; R10009.1 v1(357.23,32.25) ; v1(218.13,93.53) 217.96,93.7 R2088.1 ; R6005.2 31.53,135.09 v1(31.66,134.96) ; v1(203.92,11.47) 203.9,11.45 PC23014.2 ; C3042.2 v1(10.44,57.24) ; v1(111.79,20.54) 111.79,22.84 JDIM1003.261 ; CON3002.11 v1(11.46,59.8) ; v1(58.99,52.34) 59.6,51.72 R3004.1 ; v1(342.32,31.84) 342.42,31.94 R544.2 ; v1(288.2,9.87) 289.08,9.87 289.58,10.37 R7203.1 ; R7141.2 338.57,134.21 338.28,133.92 338.28,133.11 v1(337.73,132.55) ; PR15001.1 v1(206.14,33.12) ; v1(96.3,61.69) 96.3,61.81 96.55,62.07 PR14001.1 ; v1(339.33,125.06) 339.26,124.98 Y8000.4 ; v1(200.31,43.65) 200.69,43.27 PC13014.1 ; C2555.2 235.84,95.91 v1(235.43,95.91) ; PC9031.2 v1(211.47,49.6) ; v1(265.84,11.9) 265.93,11.98 JCN9000.34 ; PC19012.2 120.94,143.47 v1(120.94,143.11) ; PC13000.1 197.25,36.24 v1(197.38,36.36) ; CON6300.1 27.43,100.68 27.16,100.95 27.16,101.44 27.67,101.94 v1(27.69,101.94) ; R505.1 316.26,65.11 v1(316.77,65.62) 317.28,65.11 R504.1 ; v1(344.08,150.71) 344.08,149.77 PR10025.2 ; v1(135.21,100.95) 135.11,100.95 134.32,100.16 134.32,99.33 R9319.1 ; v1(109.18,3.9) 109.32,4.04 CON6351.13 ; R4111.1 351.44,78.95 v1(351.44,78.06) ; v1(132.67,146.09) 132.67,146.48 PC19004.1 ; v1(37.37,59.55) 37.12,59.8 CON3001.14 ; v1(233.2,93.44) 233.2,92.86 C2148.2 233.84,92.73 v1(233.84,93.4) ; PR13021.2 211.11,31.2 v1(211.11,31.08) 210.73,31.46 210.73,31.58 PR13024.1 ; PR9212.2 212.75,52.12 v1(212.77,52.12) ; JCN9000.35 272.28,11.98 v1(272.07,11.77) ; v1(158.32,131.76) 157.76,131.19 R9048.2 ; CON401.20 v1(246.29,37.94) ; PR10018.2 v1(352.97,134.46) ; v1(17.72,129.8) Y4000.4 ; v1(26.57,145.24) C4016.2 C4014.2 C4012.2 v1(26.57,141.7) ; C6202.2 299.75,59.88 299.24,60.39 v1(299.24,60.78) ; C2574.2 239.87,95.47 v1(240.06,95.28) ; R1037.2 155.83,22.98 v1(156.12,22.98) ; v1(253.7,9.49) 253.32,9.87 PC11013.2 ; R2068.2 245.94,111.79 246.01,111.85 C2572.2 246.47,111.09 246.21,110.82 v1(246.21,109.92) ; v1(201.07,94.24) 201.07,94.71 201.42,95.05 R2105.2 ; C6305.2 v1(24.04,100.04) ; CON4201.77 v1(350.35,7.62) ; R519.2 316.99,57.72 316.54,57.72 v1(316.39,57.57) ; C7320.2 v1(23.5,67.58) ; PC10003.1 v1(350.4,139.4) ; PR26009.1 116.75,91.11 v1(117.24,91.11) ; v1(276.05,35.27) 275.74,35.27 VC6002.2 ; v1(84.49,53.02) 85.2,52.31 EC9044.2 ; v1(212,58.13) 212,58.98 PC9040.2 ; PC8001.2 235.65,144.97 v1(235.11,145.51) ; CON6351.14 101.28,2.68 v1(101.63,2.33) ; v1(336.81,121.3) 337.06,121.55 Y8000.2 ; v1(32.19,62.68) 31.72,63.14 C7326.1 31.72,63.83 32.07,64.18 32.07,64.76 32.08,64.77 32.08,64.86 C7324.1 32,64.91 C7327.2 ; v1(344.71,101.56) 344.46,101.31 C8580.1 ; PC11003.1 253.02,13.14 v1(253.02,13.3) 252.78,13.54 PC11005.2 ; v1(285.3,21.88) 285.27,21.86 R7301.1 ; 366.55,119.34 365.63,119.34 C7111.1 ; C1083.2 v1(154.21,21.43) ; v1(180.27,43.47) 179.6,44.14 C1052.2 ; v1(58.71,68.95) 58.37,69.29 EC9032.2 ; v1(55.33,58.59) 55.23,58.69 55.23,59.87 R3037.2 ; v1(117.89,90.92) 117.89,90.41 118.42,89.88 PQ26005.1 ; R9042.2 R9041.1 172.32,94.83 v1(171.28,94.83) ; CON4201.76 v1(329.65,7.58) ; R9596.2 279.31,64.56 v1(279.46,64.4) ; v1(303.94,17.87) 304.34,17.48 CON4200.8 ; v1(320.2,67.02) 320.2,66.63 C502.2 C511.2 C512.2 320.44,64.34 v1(319.95,63.84) 319.95,63.84 C503.2 ; Y7300.4 286.25,21.67 285.91,21.33 v1(285.91,21) ; v1(231.78,118.68) 231.93,118.83 C2052.1 ; EC9011.2 189.14,46.77 189.1,46.73 ; PR17015.2 189.65,149.1 v1(189.77,149.21) ; v1(202.27,51.68) 201.98,51.39 PC9015.2 ; R9307.1 v1(134.69,120.28) 134.69,119.72 134.77,119.65 R9306.1 ; C4104.2 v1(333.66,79.47) ; v1(102.74,69.68) 102.27,70.15 102.27,71.08 ; C501.2 v1(316.39,58.76) ; v1(258.5,11.93) 258.5,11.9 258.58,11.98 JCN9000.33 ; U3002.2 v1(30.49,52.24) ; PC9011.2 v1(219.62,58.37) ; v1(22.34,131.5) Y4000.2 ; v1(274.4,63.31) 274.65,63.56 274.65,64.24 C9187.2 ; R5104.1 319.69,49.38 319.69,48.48 v1(319.95,48.22) 319.95,47.59 320.78,46.75 CON5100.77 ; PC9035.2 206.95,49.46 207.17,49.24 v1(207.17,48.91) ; v1(248.19,85.18) 248.19,85.48 R9299.2 ; C7325.1 C7323.2 v1(28.34,64.01) ; v1(133.26,147.78) PC19000.2 ; v1(299.83,17.39) 300.28,16.94 CON4200.11 ; v1(359.04,31.61) 359.03,31.62 R10010.1 ; PC19014.1 PR19056.2 v1(134.91,145.63) ; v1(49.98,56.52) CON3000.44 49.98,58.35 ; C7317.1 v1(26.6,75.87) ; C1114.2 v1(152.69,21.43) ; v1(26.57,139.16) C4010.2 ; v1(209.33,48.32) 208.83,48.82 PC9024.2 ; R1035.2 175.04,26 v1(174.53,25.49) ; C8586.2 338.61,88.32 v1(337.79,87.51) C6300.1 C6308.2 ; C8507.1 347.77,88.98 348.39,88.36 v1(348.39,87.85) ; Q4102.1 v1(349.03,77.81) ; v1(348.14,139.41) 348.26,139.29 PR10020.2 ; R9595.2 v1(280.32,53.18) ; EC9029.2 47.63,51.35 v1(48.04,51.75) ; PC9013.1 209.33,46.32 209.58,46.57 v1(209.58,47.05) ; v1(333.23,57.61) 332.74,57.61 R523.2 ; C9233.1 273.71,66.7 v1(273.71,66.53) ; v1(111.16,87.85) 111.38,88.07 PR23018.2 ; v1(208.21,94.04) 207.93,94.32 R2077.1 R2075.2 ; PC8015.2 v1(234.73,149.65) ; C537.2 343.44,48.36 v1(343.44,48.73) 343.3,48.73 R548.1 ; v1(336.58,78.07) 336.71,77.94 C4108.1 ; v1(249.85,16.66) 249.63,16.87 PC11011.2 ; 266.73,10 267.62,10.89 v1(267.75,10.89) ; EC9046.2 124.63,98.43 v1(123.86,99.2) ; PC13029.1 217.71,39.59 v1(217.58,39.46) ; C4217.1 v1(350.13,17.45) ; PC11007.2 244.65,17.64 244.14,18.14 v1(243.96,18.14) ; EC9045.2 120.37,103.71 119.67,104.41 v1(119.31,104.41) ; v1(28.18,60.31) 27.39,60.31 26.99,59.91 26.99,58.35 CON3001.2 ; v1(289.72,14.06) 290.11,14.45 R7204.1 ; R9315.2 v1(130.54,106.23) ; C9003.2 185.71,125.24 185.65,125.19 v1(185.65,124.52) 185.65,124.05 185.71,123.99 C9303.2 ; R1007.2 v1(138.46,23.33) ; C5107.1 v1(312.33,32.36) ; PC9023.2 v1(198.92,58.24) ; PC9032.2 213.42,49.34 PR9027.2 214.4,49.34 v1(214.79,48.95) ; v1(234.86,123.76) 235.14,124.04 C2173.2 ; v1(222.28,8.85) 222.92,9.49 PD12000.2 ; PC23009.2 113.53,96.32 v1(113.75,96.1) ; C2573.2 250.34,111.21 249.95,110.82 v1(249.95,110.48) ; R603.1 v1(25.56,84.55) ; R533.1 v1(347.38,44.54) ; R614.1 25.94,92.56 v1(25.94,93.05) ; PC12007.1 221.14,8.22 v1(221.27,8.35) ; C2161.1 195.23,90.52 v1(195.23,89.11) ; C4018.2 26.57,136.83 v1(26.78,136.62) ; CON4200.18 v1(310.39,17.87) ; v1(66.61,49.82) 66.58,49.85 EC5104.2 ; C6302.2 v1(25.31,95.72) ; JDIM1003.261 v1(113.18,20.55) ; JDIM1003.261 114.82,22.59 v1(114.82,20.54) ; C2053.2 232.99,123.39 v1(232.63,123.76) ; U4101.2 v1(328.3,75.05) ; v1(66.58,47.97) 66.39,47.78 EC9034.2 ; v1(25.66,75.61) 25.56,75.5 C7318.2 ; C6301.2 27.12,94.32 v1(27.64,94.83) ; v1(333.25,33.06) 333.36,33.16 C538.2 ; R507.1 v1(319.31,65.62) ; Q2013.1 223.06,90.88 v1(223.55,91.37) ; C4105.1 335.69,79.47 335.06,80.1 v1(334.68,80.1) ; v1(33.2,61.43) 34.19,60.45 34.19,58.35 CON3001.11 ; PC17004.2 v1(181.27,156.81) ; v1(181.26,27.01) 181.26,24.71 JDIM1003.262 180.15,24.86 v1(180.15,27.01) ; EC9024.2 40.76,62.47 40.42,62.81 v1(40.42,63.46) ; v1(111.77,61.72) 111.77,62.63 113.18,64.04 JDIM1000.261 113.18,67.38 112.74,67.82 v1(112.27,67.82) ; JCN9000.32 v1(277.14,12) ; v1(353.73,87.47) U3201.2 355.89,87.47 v1(356.01,87.34) ; PC9211.2 v1(212.49,53.53) ; v1(78.24,60.09) 78.7,60.54 C400.1 ; C9501.2 256.06,10.43 v1(255.81,10.68) ; v1(149,21.43) 148.75,21.68 R1041.2 ; R9028.2 v1(132.54,106.52) ; C6020.2 v1(36.09,141.31) ; C6306.2 v1(317.79,72.35) ; CON3000.43 59.72,57.95 v1(59.52,58.16) ; v1(351.39,16.98) 351.4,16.99 Q9010.1 ; PR26004.1 116.69,98.66 v1(117.75,98.66) ; PR17007.1 v1(180.01,152.37) ; v1(195.87,85.02) 195.87,85.9 195.88,85.91 Q2000.1 ; v1(201.33,51.78) 201.07,52.03 PC9805.2 ; v1(135.44,103.94) 134.55,103.06 Q9004.1 ; v1(22.34,128.87) 22.34,128.33 R4009.2 22.25,128.23 C4009.1 ; EC9013.2 171.15,93.43 v1(171.28,93.56) 171.84,93.56 172.37,93.02 R9040.2 ; v1(235.87,151.7) 235.87,151.32 PR8009.2 ; v1(180.78,61.75) JDIM1000.262 180.78,67.5 v1(180.75,67.53) ; C4002.2 31.44,126.96 v1(31.91,126.96) ; C506.2 316.79,61.28 v1(316.39,61.28) ; PQ8002.1 233.59,147.38 v1(233.2,147.76) 232.95,148.01 PR8012.2 ; v1(329.6,80.61) 329.85,80.35 C4101.2 ; PC19007.2 PR19034.2 132.92,153.84 132.29,154.47 v1(131.99,154.47) ; R3202.1 v1(349.03,86.58) ; EC9019.2 EC9020.1 39.4,63.34 v1(39.53,63.46) ; C4019.1 v1(26.89,133.06) ; R6003.1 276.62,31.17 276.91,31.17 v1(276.99,31.26) ; PC14016.1 97.28,65.89 v4(96.94,66.23) ; U3007.62 66.2,61.46 C3044.2 C3045.2 ; R9013.2 134.77,115.98 v1(135.16,116.37) 134.77,116.76 R9310.2 ; v1(298.49,60.77) 298.49,60.05 298.74,59.81 C6204.2 ; CON3001.13 26.03,59.8 v1(26.04,59.81) ; v1(224.91,133.82) 225.49,133.24 C2169.2 ; R1034.2 156.5,25.74 v1(156.88,25.36) ; C6304.1 26.58,96.36 v1(25.94,95.72) ; v1(29.37,45.81) 28.59,46.59 C3034.2 ; v1(225.94,94.42) C2182.2 ; C4205.1 343.11,22.46 v1(343.11,22.9) 343.34,23.13 EC9039.2 ; v1(113.06,98.77) 112.9,98.61 PC23010.2 ; R2065.1 200.83,127.05 v1(200.84,127.04) ; v1(261.65,10.56) 261.15,10.06 C9500.2 ; R509.1 v1(318.29,65.62) ; C3032.2 v1(26.97,54.34) ; C3025.2 47.78,62.24 v1(47.66,62.37) ; PC9044.2 219.61,57.47 219.9,57.18 v1(219.9,56.67) ; R17906.2 126.8,87.75 127.08,87.47 v1(128.2,87.47) ; PR10007.2 v1(333.43,133.85) ; PR13001.1 198.81,42.64 198.28,42.1 v1(198.28,41.62) ; U3005.2 v1(14.21,55.59) ; C4008.1 v1(18.69,127.6) ; v4(125.89,130.14) 126.17,130.14 126.74,130.71 EC9005.2 ; CON3000.42 43.43,54.29 43.03,53.89 v1(43.03,52.92) ; R8506.2 v1(341.92,99.28) ; CON5101.77 323.26,23.75 324.14,24.63 v1(324.14,25.24) 324.14,25.74 323.83,26.05 CON5100.76 ; C9224.1 v1(232.7,71.48) ; v1(333.66,80.1) 332.4,80.1 C4103.1 ; EC9049.2 D7302.1 33.7,52.58 v1(33.23,52.11) ; PR19050.2 170.97,131.04 v1(170.85,131.15) ; EC3602.2 v1(352.38,8.96) ; R2076.1 205.02,94.28 v1(204.76,94.55) 204.76,94.56 R2103.2 ; v1(16.42,97.4) 16.91,97.89 EC9023.2 ; PR19031.2 122.83,152.1 122.49,151.75 v1(122.21,151.75) ; v1(335.77,52.69) 335.96,52.51 R512.2 ; PC12006.1 219.11,8.22 v1(218.98,8.35) ; R8557.2 342.17,88.51 v1(342.45,88.23) ; PC21029.1 v1(180.38,146.63) ; C4106.1 v1(334.68,79.47) ; PC9006.2 v1(225.08,58.37) ; R522.2 v1(316.39,60.03) ; v1(333.66,36.06) 334.31,36.06 R538.2 ; C533.2 R547.2 v1(340.39,48.73) ; C6307.1 v1(318.42,73.62) ; v1(328.96,80.61) 328.84,80.48 C4102.2 ; v1(349.03,87.85) C3201.1 ; v1(234.47,145.51) 234.47,145.79 234.92,146.24 PC8016.2 ; R2081.1 v1(219.23,93.53) ; v1(333.41,144.3) 333.03,143.93 PR10009.1 ; v1(338.26,48.78) 338.33,48.71 R543.2 ; ESD7200.2 v1(292.89,11.77) ; C7316.2 v1(29.46,75.56) ; v1(218.98,8.98) 218.98,9.62 219.11,9.74 PD12001.2 ; C2046.2 232.99,125.2 v1(233.71,125.92) ; C3033.2 v1(26.19,56.3) ; R6027.1 257.95,26.47 v1(257.82,26.34) ; CON6301.1 333.76,92.17 v1(333.51,92.55) ; C619.2 v1(21.11,88.74) ; CON3002.12 v1(22.47,61.42) ; C2183.2 v1(228.62,94.42) ; C8052.2 v1(314.61,66.64) ; CON5101.76 v1(320.62,3.05) ; R1036.2 v1(177.07,25.49) ; R9015.2 v1(134.77,113.88)
  vias: v1(5.77,98.24) v1(9.3,138.01) v1(10.19,138.01) v1(13.37,41.49) v1(13.6,106.44) v1(13.8,89.93) v1(14.15,109.74) v1(14.21,91.23) v1(14.21,90.54) v1(14.51,100.67) v1(14.51,100.04) v1(14.51,99.4) v1(14.51,98.77) v1(14.97,97.37) v1(15.07,109.46) v1(15.22,96.74) v1(15.68,97.37) v1(16.06,98.64) v1(16.11,96.76) v1(16.82,96.79) v1(18.42,107.02) v1(23.02,101.06) v1(23.02,100.04) v1(23.15,131.15) v1(23.53,100.55) v1(23.78,115.79) v1(23.91,131.15) v1(24.04,101.06) v1(24.42,115.79) v1(24.54,51.3) v1(24.67,132.55) v1(24.67,130.52) v1(24.8,125.06) v1(24.8,124.04) v1(24.8,122.9) v1(25.94,125.06) v1(25.94,124.04) v1(25.94,122.9) v1(26.19,129.63) v1(26.96,125.06) v1(26.96,124.04) v1(26.96,122.9) v1(26.96,112.99) v1(27.97,142.97) v1(27.97,140.93) v1(28.07,114.09) v1(28.23,148.05) v1(28.23,146.01) v1(28.28,70.42) v1(28.28,69.41) v1(28.28,68.39) v1(28.78,116.5) v1(29.29,70.42) v1(29.29,69.41) v1(29.29,68.39) v1(30.31,70.42) v1(30.31,69.41) v1(30.31,68.39) v1(31.02,88.84) v1(31.02,86.93) v1(31.83,79.31) v1(35.57,82.95) v1(38.64,50.13) v1(39.02,48.86) v1(39.02,48.22) v1(39.1,49.87) v1(39.22,75.78) v1(39.22,73.75) v1(39.53,51.02) v1(39.66,48.86) v1(39.66,48.22) v1(40.29,48.86) v1(40.29,48.22) v1(40.67,74.13) v1(40.98,47.74) v1(41.31,63.46) v1(41.31,49.09) v1(41.61,72.53) v1(43.47,65.34) v1(43.48,64.71) v1(43.57,61.2) v1(43.85,47.46) v1(47.07,51.75) v1(50.5,51.53) v1(53.78,68.32) v1(53.78,68.19) v1(55.76,71.92) v1(56.01,71.19) v1(60.23,65.34) v1(60.99,50.51) v1(60.99,49.24) v1(61.63,70.7) v1(61.63,49.87) v1(62.26,50.51) v1(62.26,49.24) v1(62.77,56.24) v1(64.07,55.16) v1(67.47,70.19) v1(68.79,70.22) v1(70.14,70.19) v1(71.43,50.81) v1(72.3,69.31) v1(72.68,51.08) v1(73.31,51.08) v1(73.95,51.08) v1(74.28,64) v1(74.58,62.55) v1(75.6,65.04) v1(75.6,60.29) v1(76.11,69.18) v1(77.25,57.22) v1(97.85,16.55) v1(102.06,84.7) v1(102.06,84.01) v1(102.27,5.74) v1(102.7,84.95) v1(102.7,84.29) v1(102.78,74.77) v1(103.03,68.42) v1(103.28,28.56) v1(103.28,27.9) v1(103.28,27.19) v1(103.38,84.98) v1(103.66,81.37) v1(103.66,68.42) v1(103.84,87.54) v1(106.08,32.04) v1(106.56,36.03) v1(106.56,35.02) v1(106.56,34.38) v1(107.35,94.96) v1(107.73,96.1) v1(107.98,5.45) v1(108.11,70.96) v1(108.11,68.42) v1(108.11,65.24) v1(109.53,39.11) v1(112.5,113.02) v1(113.44,50.65) v1(114.13,47.08) v1(114.13,46.45) v1(114.13,45.81) v1(114.13,43.02) v1(114.13,42.38) v1(114.13,41.75) v1(114.21,36.11) v1(114.21,34.2) v1(114.9,59.87) v1(114.9,59.23) v1(114.9,58.6) v1(114.9,57.96) v1(115,54.44) v1(115,52.53) v1(115.8,35.53) v1(116.12,53.19) v1(116.12,51.28) v1(116.07,46.06) v1(116.07,45.43) v1(116.07,43.02) v1(116.07,42.38) v1(117.09,36.48) v1(117.09,35.21) v1(117.53,98.04) v1(117.76,84.34) v1(117.76,3.65) v1(117.99,133.87) v1(118.11,58.6) v1(118.11,57.96) v1(118.11,53.21) v1(118.11,51.31) v1(118.07,46.7) v1(118.07,46.06) v1(118.07,45.43) v1(118.07,43.14) v1(118.07,42.51) v1(118.07,41.87) v1(118.23,84.82) v1(118.69,85.26) v1(118.68,36.92) v1(118.68,35.02) v1(118.9,47.13) v1(118.9,46.5) v1(118.9,45.86) v1(118.9,43.14) v1(118.9,42.51) v1(118.9,41.87) v1(119.29,85.87) v1(119.46,108.24) v1(119.72,46.7) v1(119.72,46.06) v1(119.72,45.43) v1(119.72,42.89) v1(119.72,42.25) v1(119.72,41.62) v1(119.75,58.6) v1(119.75,57.96) v1(119.75,53.93) v1(119.75,52.03) v1(119.75,50.76) v1(120.1,123.41) v1(120.1,122.52) v1(120.36,37.03) v1(120.36,35.13) v1(120.73,123.41) v1(120.73,122.52) v1(120.94,111.34) v1(120.94,110.45) v1(121.37,123.41) v1(121.37,122.52) v1(121.42,53.39) v1(121.42,51.48) v1(121.57,111.34) v1(121.57,110.45) v1(121.78,46.49) v1(121.78,45.86) v1(121.78,43.55) v1(121.78,42.91) v1(121.78,42.28) v1(121.83,25.24) v1(121.89,36.74) v1(121.89,34.84) v1(122.21,111.34) v1(122.21,110.45) v1(122.99,127.57) v1(122.97,58.72) v1(122.97,58.09) v1(123.39,53.91) v1(123.39,52.64) v1(123.39,51.37) v1(123.42,37.31) v1(123.42,35.4) v1(123.76,115.51) v1(123.73,25.24) v1(123.86,157.32) v1(124.15,46.7) v1(124.15,46.06) v1(124.15,45.43) v1(124.15,43.14) v1(124.15,42.51) v1(124.15,41.87) v1(124.75,25.24) v1(125.06,36.66) v1(125.06,34.75) v1(125.25,125.59) v1(125.39,47.13) v1(125.39,46.5) v1(125.39,45.86) v1(125.39,43.02) v1(125.39,42.38) v1(125.39,41.75) v1(125.64,58.7) v1(125.64,58.06) v1(125.64,53.34) v1(125.64,51.41) v1(125.76,25.24) v1(125.91,125.59) v1(126.02,113.88) v1(126.14,149.57) v1(126.14,148.3) v1(126.14,3.65) v1(126.52,150.2) v1(126.52,148.93) v1(126.52,147.66) v1(126.51,36.65) v1(126.51,35.38) v1(126.59,84.42) v1(126.65,113.88) v1(126.78,25.24) v1(126.91,149.57) v1(126.91,148.3) v1(126.85,46.5) v1(126.85,45.86) v1(126.85,42.94) v1(126.85,42.31) v1(127.14,58.7) v1(127.14,58.06) v1(127.16,53.5) v1(127.16,52.23) v1(127.29,150.2) v1(127.29,148.93) v1(127.67,149.57) v1(127.79,25.24) v1(128.02,85.86) v1(128.05,150.2) v1(128.12,147.84) v1(128.04,36.72) v1(128.04,35.45) v1(128.39,58.7) v1(128.39,58.06) v1(128.39,53.58) v1(128.39,52.31) v1(128.81,25.24) v1(128.91,150.81) v1(129.61,46.7) v1(129.61,46.06) v1(129.61,45.43) v1(129.61,43.65) v1(129.61,43.02) v1(129.61,42.38) v1(129.61,41.75) v1(129.63,53.17) v1(129.63,51.25) v1(129.83,25.24) v1(130.25,37.15) v1(130.25,35.17) v1(130.74,47.11) v1(130.74,46.47) v1(130.74,45.84) v1(130.79,42.97) v1(130.79,42.33) v1(130.84,25.11) v1(131.08,53.1) v1(131.08,51.83) v1(131.6,36.11) v1(131.6,34.2) v1(131.73,25.11) v1(132.88,46.32) v1(132.88,45.68) v1(132.89,43.07) v1(133.28,53.33) v1(133.28,51.42) v1(133.42,34.96) v1(133.43,36.88) v1(134.19,84.32) v1(134.4,59.36) v1(134.4,58.72) v1(134.4,58.09) v1(134.43,53.47) v1(134.43,51.56) v1(134.4,46.7) v1(134.4,46.06) v1(134.4,45.43) v1(134.45,43.19) v1(134.45,42.56) v1(134.65,84.77) v1(134.73,41.98) v1(134.78,3.65) v1(135.11,85.23) v1(135.41,25.24) v1(135.65,36.65) v1(135.65,34.74) v1(136.43,25.24) v1(136.55,102.32) v1(136.68,101.1) v1(136.81,106.39) v1(136.78,100.16) v1(136.9,36.52) v1(136.9,35.25) v1(137.07,105.12) v1(137.15,59.37) v1(137.15,58.74) v1(137.15,58.1) v1(137.2,53.43) v1(137.19,46.32) v1(137.19,45.68) v1(137.24,50.87) v1(137.45,148.27) v1(137.7,96.66) v1(138.21,148.27) v1(138.84,147.89) v1(138.84,147.12) v1(139.09,98) v1(139.29,37.3) v1(139.29,35.39) v1(139.4,59.38) v1(139.4,58.75) v1(139.4,58.11) v1(139.4,53.95) v1(139.4,52.05) v1(139.4,47) v1(139.4,46.32) v1(139.4,45.68) v1(139.4,45.05) v1(139.4,44.41) v1(139.4,43.78) v1(139.61,148.65) v1(139.61,147.89) v1(139.61,147.12) v1(139.78,95.56) v1(140.19,36.14) v1(140.37,148.65) v1(140.37,147.89) v1(140.37,147.12) v1(140.43,53.26) v1(140.44,99.37) v1(141.13,148.65) v1(141.13,147.89) v1(141.11,37) v1(141.15,96.93) v1(141.41,35.81) v1(141.9,53.26) v1(141.9,51.36) v1(142.47,98.33) v1(142.66,153.48) v1(142.73,42.51) v1(142.63,37.34) v1(142.63,36.07) v1(142.63,34.8) v1(142.91,3.65) v1(143.16,25.36) v1(143.4,53.38) v1(143.4,52.11) v1(143.46,96.53) v1(143.8,25.36) v1(144.42,51.7) v1(144.43,146.78) v1(144.43,25.36) v1(144.62,37.36) v1(144.62,35.46) v1(144.81,97.87) v1(145.02,146.04) v1(145.09,96.4) v1(145.46,53.96) v1(145.57,44.92) v1(145.77,51.55) v1(145.93,34.77) v1(145.96,25.36) v1(146.34,148.27) v1(146.59,45.3) v1(146.59,42.97) v1(146.84,94.27) v1(146.97,25.36) v1(147.1,148.27) v1(147.1,38.35) v1(147.1,36.44) v1(147.1,34.54) v1(147.73,148.65) v1(147.73,147.89) v1(147.73,147.12) v1(148,54.37) v1(148,52.46) v1(147.99,25.36) v1(148.22,97.57) v1(148.22,95.67) v1(148.15,50.56) v1(148.16,36.42) v1(148.16,34.51) v1(148.5,148.65) v1(148.5,147.89) v1(148.5,147.12) v1(148.84,122.79) v1(148.84,122.14) v1(148.88,118.84) v1(149,117.57) v1(149,116.93) v1(149,25.36) v1(149.26,148.65) v1(149.26,147.89) v1(149.26,147.12) v1(149.51,120.23) v1(149.51,116.17) v1(149.51,115.53) v1(149.51,114.9) v1(149.51,112.74) v1(149.45,37.56) v1(149.45,35.66) v1(149.66,54.69) v1(149.65,52.78) v1(149.65,50.87) v1(150.02,148.65) v1(150.02,147.89) v1(150.02,147.12) v1(150.02,42.25) v1(149.94,33.79) v1(150.02,25.36) v1(150.58,153.46) v1(150.81,97.47) v1(150.81,95.56) v1(150.81,94.29) v1(150.81,53.54) v1(150.81,52.27) v1(151.04,25.36) v1(151.29,3.65) v1(151.49,34.33) v1(151.67,148.5) v1(151.65,97.87) v1(151.99,122.79) v1(151.99,122.14) v1(151.97,120.52) v1(152.03,36.71) v1(152.05,25.36) v1(152.39,52.97) v1(152.39,51.02) v1(152.43,95.56) v1(152.43,94.29) v1(152.62,34.83) v1(152.69,25.36) v1(153.08,37.2) v1(153.7,96.88) v1(153.68,94.89) v1(153.75,156.78) v1(153.91,53.3) v1(153.91,51.25) v1(154.13,34.64) v1(155.14,122.14) v1(155.38,51.2) v1(155.54,36.69) v1(155.54,34.5) v1(156.12,119.72) v1(156.12,119.09) v1(156.12,118.45) v1(156.12,116.68) v1(156.12,116.04) v1(156.12,115.03) v1(156.21,97.93) v1(156.21,96.03) v1(156.21,94.12) v1(156.21,92.21) v1(156.5,113.37) v1(156.5,112.74) v1(156.5,111.6) v1(156.62,148.65) v1(156.62,147.89) v1(156.62,147.12) v1(156.75,119.72) v1(156.75,119.09) v1(156.75,118.45) v1(156.97,53.39) v1(156.97,52.12) v1(157,36.04) v1(157,33.94) v1(157.39,148.65) v1(157.39,147.89) v1(157.39,147.12) v1(157.36,41.95) v1(157.79,42.43) v1(157.95,53.39) v1(157.95,51.22) v1(158.15,148.65) v1(158.15,147.89) v1(158.15,147.12) v1(158.22,46.85) v1(158.22,46.22) v1(158.29,122.79) v1(158.29,122.14) v1(158.33,59.23) v1(158.33,58.6) v1(158.33,57.96) v1(158.25,42.89) v1(158.5,153.46) v1(158.72,98.57) v1(158.72,96.66) v1(158.72,94.72) v1(158.73,43.32) v1(158.74,37.05) v1(158.74,35.78) v1(158.91,148.65) v1(158.91,147.89) v1(158.91,105.27) v1(159.19,43.78) v1(159.23,41.72) v1(159.42,46.19) v1(159.54,3.65) v1(159.67,53.25) v1(159.67,51.98) v1(159.86,122.79) v1(160.1,42.69) v1(160.15,37.37) v1(160.15,35.46) v1(160.53,43.17) v1(160.98,53.27) v1(160.98,51.37) v1(161.17,46.67) v1(161.17,46.03) v1(161.23,96.66) v1(161.23,94.76) v1(161.23,92.85) v1(161.23,91.58) v1(161.78,37.18) v1(161.78,35.91) v1(162.21,116.68) v1(162.21,116.04) v1(162.21,115.03) v1(162.21,114.39) v1(162.21,113.76) v1(162.19,113.12) v1(162.24,146.24) v1(162.47,119.72) v1(162.47,119.09) v1(162.47,118.45) v1(162.57,47.08) v1(162.57,46.45) v1(162.57,45.81) v1(162.59,45.18) v1(162.64,146.14) v1(162.77,59.97) v1(162.77,59.33) v1(162.77,58.7) v1(162.77,58.06) v1(162.77,53.02) v1(162.77,50.78) v1(163,37.09) v1(163,35.82) v1(163.61,47.08) v1(163.61,46.45) v1(163.61,45.81) v1(163.8,122.79) v1(163.8,122.14) v1(163.76,97.93) v1(163.74,25.36) v1(163.99,53.53) v1(163.99,52.26) v1(164.12,41.72) v1(164.31,36.92) v1(164.31,35.02) v1(164.37,25.36) v1(165.01,25.36) v1(165.03,42.66) v1(165.13,19.9) v1(165.31,53.51) v1(165.31,52.24) v1(165.31,50.33) v1(165.64,25.36) v1(165.77,148.65) v1(165.77,147.89) v1(165.77,147.12) v1(165.77,46.06) v1(166.02,36.29) v1(166.02,34.38) v1(166.15,19.9) v1(166.27,97.72) v1(166.28,25.36) v1(166.53,148.65) v1(166.53,147.89) v1(166.53,147.12) v1(166.63,153.43) v1(166.91,25.36) v1(167.16,58.87) v1(167.16,58.24) v1(167.16,53.34) v1(167.16,52.07) v1(167.16,46.7) v1(167.16,46.06) v1(167.16,19.9) v1(167.29,148.65) v1(167.29,147.89) v1(167.29,147.12) v1(167.55,25.36) v1(167.72,96.43) v1(167.72,94.52) v1(167.8,35.93) v1(167.8,34.03) v1(167.93,3.65) v1(168.05,148.65) v1(168.05,147.89) v1(168.18,25.36) v1(168.18,19.9) v1(168.92,52.45) v1(168.92,51.18) v1(168.92,46.7) v1(168.92,46.06) v1(168.92,45.43) v1(169.32,115.03) v1(169.32,114.39) v1(169.32,113.76) v1(169.3,113.1) v1(169.37,148.05) v1(169.36,36.44) v1(169.36,34.54) v1(169.68,98.05) v1(169.96,118.2) v1(169.96,117.57) v1(170.39,59) v1(170.39,58.37) v1(170.39,53.34) v1(170.39,51.43) v1(170.59,42.51) v1(171.07,96.71) v1(171.1,43.02) v1(171.34,36.43) v1(171.34,34.53) v1(171.48,46.29) v1(171.48,45.66) v1(171.98,58.87) v1(171.98,58.24) v1(171.95,53.53) v1(171.95,51.62) v1(172.65,98.26) v1(173.46,145.51) v1(173.48,35.78) v1(173.73,58.75) v1(173.73,58.11) v1(173.73,52.92) v1(174.02,96.91) v1(174.82,52.99) v1(174.81,35.83) v1(175.16,98.23) v1(175.22,46.07) v1(175.22,45.43) v1(175.22,43.39) v1(175.22,42.75) v1(175.83,150.45) v1(175.83,149.82) v1(175.83,149.18) v1(176.04,36.56) v1(176.04,34.66) v1(176.56,3.65) v1(176.66,53.21) v1(176.66,51.31) v1(177.22,152.06) v1(177.15,148.35) v1(177.58,35.78) v1(177.78,46.57) v1(177.78,45.94) v1(177.78,42.92) v1(177.78,42.28) v1(177.78,41.65) v1(178.11,145.3) v1(178.11,144.67) v1(178.09,59.26) v1(178.09,58.62) v1(178.09,57.99) v1(178.09,52.26) v1(178.77,142.81) v1(178.91,148.17) v1(178.85,35.78) v1(179.33,52.19) v1(180.27,42.84) v1(181.62,126.27) v1(181.83,124.72) v1(181.9,104.1) v1(182.53,102.07) v1(183.72,124.52) v1(184.97,85.89) v1(185.6,85.89) v1(185.85,83.14) v1(186.14,160.8) v1(186.62,85.89) v1(186.6,83.76) v1(186.53,83.02) v1(187.36,120.96) v1(187.36,119.97) v1(187.36,118.91) v1(187.36,117.94) v1(187.36,116.87) v1(187.36,115.91) v1(187.36,114.84) v1(187.36,113.88) v1(187.36,112.81) v1(187.36,111.84) v1(187.36,110.78) v1(187.36,109.81) v1(187.36,108.75) v1(187.36,107.78) v1(187.36,106.71) v1(187.36,105.72) v1(187.41,44.47) v1(187.38,43.65) v1(187.48,54.62) v1(187.48,53.99) v1(187.48,47.87) v1(187.48,47.23) v1(187.48,46.6) v1(187.75,85.83) v1(187.75,83.92) v1(187.74,81.78) v1(188.16,100.45) v1(188.73,59.15) v1(188.68,23.59) v1(189.06,45.81) v1(189.36,66.21) v1(189.36,65.57) v1(189.34,64.94) v1(189.36,64.3) v1(189.36,23.59) v1(190.33,24.45) v1(190.91,75.05) v1(191.07,121.32) v1(191.07,120.23) v1(191.04,118.88) v1(191.04,117.94) v1(191.04,116.75) v1(191.04,115.65) v1(191.04,114.46) v1(191.04,113.37) v1(191.04,112.17) v1(191.04,111.08) v1(191.04,109.76) v1(191.04,108.8) v1(191.04,107.73) v1(191.04,106.51) v1(191.04,104.71) v1(191.68,104.71) v1(191.93,144.08) v1(191.93,143.31) v1(191.93,142.55) v1(191.93,141.79) v1(192.44,94.71) v1(192.56,85.94) v1(192.56,85.31) v1(192.95,70.91) v1(193.06,159.6) v1(193.22,82.46) v1(193.2,80.48) v1(193.45,15.71) v1(193.7,159.6) v1(194.22,150.89) v1(194.33,159.6) v1(194.6,85.02) v1(194.72,13.78) v1(194.97,159.6) v1(195.18,24.53) v1(195.23,85.02) v1(195.6,159.6) v1(195.74,53) v1(195.76,51.48) v1(196.09,52.24) v1(196.91,154.47) v1(197.24,113.93) v1(197.29,53) v1(197.47,154.78) v1(197.47,154.14) v1(197.49,115.68) v1(197.58,111.89) v1(197.67,108.34) v1(197.77,119.31) v1(197.73,117.6) v1(197.74,109.99) v1(198.03,123.03) v1(198.1,154.78) v1(198.1,154.14) v1(198.51,43.27) v1(198.76,8.47) v1(198.84,160.87) v1(199.16,113.91) v1(199.14,43.27) v1(199.4,115.68) v1(199.57,108.29) v1(199.68,119.31) v1(199.64,111.91) v1(199.66,109.98) v1(199.68,44.21) v1(199.78,117.61) v1(199.78,43.27) v1(199.9,123.86) v1(200.06,156.69) v1(200.06,156.06) v1(200.33,144.77) v1(200.75,135.39) v1(201.12,152.08) v1(201.31,133.23) v1(201.71,94.24) v1(201.99,62.52) v1(202.47,80.83) v1(202.54,126.97) v1(202.55,96.35) v1(202.7,152.06) v1(202.98,42.76) v1(204.96,127.66) v1(205.16,34.51) v1(205.9,155.74) v1(206.66,84.56) v1(206.79,54.16) v1(206.79,52.64) v1(207.3,84.56) v1(207.42,87.52) v1(207.55,53.4) v1(207.93,84.56) v1(207.93,16.6) v1(208.03,117.69) v1(208.06,117.06) v1(208.06,106.14) v1(208.21,93.4) v1(208.21,92.77) v1(208.21,92.13) v1(208.21,91.5) v1(208.31,54.16) v1(208.31,52.64) v1(208.57,84.56) v1(208.69,89.97) v1(208.69,16.6) v1(209.12,110.07) v1(209.13,108.2) v1(209.07,106.14) v1(209.1,86.96) v1(209.18,114.98) v1(209.28,111.19) v1(209.46,21.53) v1(209.46,20.06) v1(209.71,118.33) v1(209.96,106.06) v1(209.96,45.43) v1(210.01,26.48) v1(210.1,116.09) v1(210.1,114.12) v1(210.09,21.53) v1(210.14,111.3) v1(210.19,110.43) v1(210.32,157.77) v1(210.73,21.53) v1(211.11,105.63) v1(211.16,117.01) v1(211.19,115.08) v1(211.21,113.13) v1(211.21,110.12) v1(211.18,108.25) v1(211.44,21.53) v1(211.54,37.73) v1(212.08,114.22) v1(212.12,107.28) v1(212.5,127) v1(212.98,115.19) v1(213.18,117.01) v1(213.24,24.09) v1(213.49,90.74) v1(213.52,89.47) v1(214.15,31.21) v1(214.28,89.96) v1(214.49,105.63) v1(214.92,94.7) v1(214.92,94.06) v1(214.92,93.43) v1(214.92,92.79) v1(215.04,85.46) v1(215.22,111.32) v1(215.2,31) v1(215.32,114.26) v1(215.45,62.68) v1(215.78,85.46) v1(215.91,106.14) v1(216.01,64.45) v1(216.18,117.09) v1(216.14,115.36) v1(216.21,113.35) v1(216.16,108.1) v1(217.08,55.94) v1(217.18,118.02) v1(217.61,47.89) v1(217.79,49.04) v1(217.91,85.46) v1(217.94,86.15) v1(217.99,53.76) v1(218.2,117.25) v1(218.17,115.36) v1(218.2,113.3) v1(218.17,110.21) v1(218.27,47.89) v1(218.34,107.21) v1(218.6,85.45) v1(218.65,80.91) v1(218.85,53.78) v1(218.93,47.87) v1(218.97,108.21) v1(219.18,103.8) v1(219.26,116.2) v1(220.05,128.28) v1(220.22,109.46) v1(220.53,114.04) v1(220.5,112.74) v1(221.27,159.4) v1(221.29,55.13) v1(221.49,14.31) v1(221.77,158.76) v1(221.9,159.4) v1(222.41,158.76) v1(222.54,159.4) v1(222.62,129.65) v1(222.6,106.37) v1(222.67,130.28) v1(223.37,159.58) v1(223.37,156.1) v1(223.72,156.82) v1(224.01,159.58) v1(224.36,156.82) v1(224.99,156.82) v1(225.79,159.63) v1(225.86,119.7) v1(225.9,104.71) v1(227.59,40.93) v1(227.59,40.3) v1(227.59,39.64) v1(227.59,39) v1(228.17,40.68) v1(228.26,118.18) v1(228.72,149.41) v1(229.01,116.41) v1(228.97,115.52) v1(229.14,52.54) v1(229.14,51.91) v1(229.37,144.97) v1(229.52,137.96) v1(229.59,142.34) v1(229.58,141.7) v1(229.59,118.08) v1(229.55,50.89) v1(229.55,50.26) v1(229.55,49.37) v1(229.55,48.73) v1(229.55,48.1) v1(229.55,47.46) v1(229.55,46.83) v1(229.55,46.19) v1(229.55,45.56) v1(229.55,44.92) v1(229.55,44.29) v1(229.55,43.65) v1(229.55,43.02) v1(229.55,42.38) v1(229.69,139.63) v1(229.71,103.02) v1(230.87,102.8) v1(231.93,53.35) v1(232.77,140.55) v1(232.82,57.49) v1(232.96,102.8) v1(233.84,36.79) v1(234.27,3.16) v1(234.98,47.36) v1(234.98,46.73) v1(234.98,41.87) v1(234.98,39.82) v1(234.98,38.83) v1(235.43,66.93) v1(236.38,95.16) v1(236.89,67.3) v1(237.27,72.43) v1(237.51,63.29) v1(237.67,71.72) v1(237.85,67.71) v1(238,73.17) v1(238.67,57.88) v1(238.87,54.85) v1(239.2,58.76) v1(239.53,20.08) v1(239.81,145.85) v1(240.29,138.11) v1(240.32,67.12) v1(240.24,63.06) v1(240.44,68.54) v1(240.59,49.66) v1(240.82,64.89) v1(240.95,67.17) v1(241.08,75.66) v1(241.07,49.18) v1(241.2,69.45) v1(241.33,20.08) v1(241.87,154.32) v1(241.89,70.96) v1(242.32,57.88) v1(242.35,68.16) v1(242.86,63.59) v1(242.83,58.87) v1(243.03,47.36) v1(243.31,64.25) v1(243.31,50.17) v1(243.87,73.47) v1(244.08,64.35) v1(244.13,46.19) v1(244.25,62.32) v1(244.41,73.04) v1(244.63,45.68) v1(244.76,74.7) v1(244.84,14.57) v1(245.24,70.27) v1(245.78,71.97) v1(245.88,67.59) v1(246.03,44.29) v1(246.16,73.17) v1(246.56,66.77) v1(246.55,59.96) v1(246.54,43.78) v1(246.65,74.64) v1(247.08,72.22) v1(247.05,46.65) v1(247.29,63.55) v1(247.26,59.03) v1(247.68,61.62) v1(247.94,73.5) v1(248.77,57.53) v1(249.13,61.67) v1(249.21,93.87) v1(249.21,93.23) v1(249.91,65.69) v1(249.84,60.86) v1(250.7,56.47) v1(250.81,96.12) v1(250.98,64.59) v1(250.98,57.81) v1(251.25,96.57) v1(251.39,84.55) v1(251.45,61.12) v1(251.72,59.36) v1(251.75,50.89) v1(252.38,72.66) v1(252.38,60.1) v1(252.76,55.68) v1(253.04,77.19) v1(253.34,77.79) v1(253.65,56.67) v1(254.05,61.98) v1(254.39,78.6) v1(255.81,104.48) v1(255.81,103.85) v1(255.81,103.21) v1(255.81,102.58) v1(255.81,101.94) v1(256.45,104.48) v1(256.45,103.85) v1(256.45,103.21) v1(256.45,102.58) v1(256.45,101.94) v1(257.97,49.37) v1(257.97,48.73) v1(259.15,67.04) v1(260.66,72.4) v1(260.74,63.2) v1(261.52,68.31) v1(262.67,41.37) v1(263.68,41.24) v1(263.73,88.25) v1(263.73,66.54) v1(264.18,66.09) v1(264.32,41.24) v1(264.57,68.1) v1(264.95,41.24) v1(265.59,85.61) v1(265.77,7.03) v1(265.97,41.32) v1(267.19,44.24) v1(269.25,81.47) v1(270.29,35.78) v1(271.3,79.59) v1(271.33,35.27) v1(271.38,6.19) v1(271.56,62.45) v1(271.84,6.72) v1(272.06,63.27) v1(272.52,6.72) v1(273.69,77.69) v1(276,76.14) v1(278.04,50.13) v1(278.92,74.49) v1(280.07,39.21) v1(280.04,37.66) v1(280.55,35.27) v1(280.7,39.21) v1(281.16,36.21) v1(281.72,73.22) v1(283.75,35.02) v1(284.08,63.39) v1(284.39,72.23) v1(284.39,35.02) v1(284.82,63.39) v1(284.77,13.4) v1(285.02,35.02) v1(286.49,46.57) v1(287.92,22.6) v1(288.7,67.86) v1(289.06,69.76) v1(289.34,46.45) v1(291.5,60.87) v1(292.13,60.87) v1(292.26,60.03) v1(294.21,21.71) v1(294.44,68.11) v1(295.56,50.97) v1(296.25,50.97) v1(296.4,9.97) v1(296.81,11.04) v1(296.98,50.97) v1(297.03,9.97) v1(297.62,50.97) v1(298.25,50.97) v1(299.19,49.72) v1(299.78,68.19) v1(303.56,54.95) v1(303.94,18.51) v1(304.55,9.13) v1(305.24,9.11) v1(305.31,5.4) v1(305.82,56.15) v1(305.92,9.11) v1(306.36,55.79) v1(307.88,27.52) v1(307.88,26.89) v1(307.88,26.25) v1(307.88,25.62) v1(308.39,28.97) v1(308.52,71.54) v1(308.46,56.2) v1(309.12,22.49) v1(309.64,17.21) v1(310.17,20.28) v1(310.17,19.65) v1(310.8,18.63) v1(310.95,72.02) v1(311.21,22.19) v1(311.92,54.62) v1(312.63,70.4) v1(314.87,1.23) v1(316.77,32.98) v1(317.35,34.2) v1(318.17,35.78) v1(318.68,32.98) v1(318.68,30.7) v1(319.03,18.53) v1(319.06,17.74) v1(319.06,16.98) v1(319.03,16.25) v1(319.89,34.56) v1(320.12,76.43) v1(320.12,35.7) v1(320.38,50.51) v1(321.85,58.13) v1(321.85,56.86) v1(321.85,55.59) v1(322.36,49.65) v1(322.87,67.6) v1(322.84,65.11) v1(323.63,58.13) v1(323.63,56.86) v1(323.63,55.59) v1(323.55,47.79) v1(324.67,67.73) v1(324.82,49.82) v1(324.9,65.72) v1(325.41,58.13) v1(325.41,56.86) v1(325.41,55.59) v1(325.66,5.04) v1(326.04,47.67) v1(326.22,45.81) v1(326.3,14.7) v1(326.3,7.96) v1(326.42,33.24) v1(326.63,44.11) v1(326.73,39.46) v1(326.96,65.14) v1(327.03,67.65) v1(327.18,58.13) v1(327.18,56.86) v1(327.18,55.59) v1(327.31,23.59) v1(327.44,49.77) v1(327.54,33.24) v1(327.57,17.44) v1(327.57,8.47) v1(327.69,30.82) v1(327.69,13.93) v1(327.82,12.92) v1(327.95,23.59) v1(328.68,39.51) v1(328.96,65.75) v1(328.96,58.13) v1(329.39,12.74) v1(329.47,31.97) v1(329.77,37) v1(329.93,12.31) v1(330.03,67.05) v1(330.49,12.66) v1(331.07,12.41) v1(331.25,68.16) v1(331.78,18.71) v1(332.14,11.68) v1(332.14,3.27) v1(332.57,28.26) v1(332.57,27.55) v1(332.65,18.79) v1(332.77,87.85) v1(332.98,59.53) v1(333.03,41.49) v1(333.2,27.65) v1(333.28,73.62) v1(333.28,66.89) v1(333.51,60.01) v1(333.99,15.99) v1(334.17,72.1) v1(334.17,70.07) v1(334.17,66.77) v1(334.26,68.89) v1(334.37,2.58) v1(334.93,3.52) v1(334.93,2.88) v1(335.19,71.08) v1(335.19,67.78) v1(335.16,56.22) v1(335.44,73.62) v1(335.57,3.52) v1(335.57,2.88) v1(335.69,6.22) v1(335.69,5.58) v1(335.82,117.69) v1(335.82,116.55) v1(335.82,114.64) v1(335.82,113.5) v1(335.82,111.6) v1(335.82,110.45) v1(335.82,108.55) v1(336.2,66.77) v1(336.46,151.32) v1(336.46,105.37) v1(337.47,72.1) v1(337.6,12.31) v1(337.93,23.84) v1(338.79,23.84) v1(338.89,115.58) v1(339.12,97.75) v1(339.25,151.32) v1(339.5,72.1) v1(339.5,43.4) v1(339.5,41.62) v1(339.5,39.84) v1(339.5,38.06) v1(339.5,36.29) v1(339.63,12.31) v1(339.76,24.47) v1(339.76,23.84) v1(340.19,108.07) v1(340.27,151.22) v1(340.77,72.1) v1(340.77,66.77) v1(340.77,43.4) v1(340.77,41.62) v1(340.77,39.84) v1(340.77,38.06) v1(340.77,36.29) v1(341.79,71.08) v1(341.92,104.61) v1(342.04,151.32) v1(342.04,126.2) v1(342.04,96.59) v1(342.04,43.4) v1(342.04,41.62) v1(342.04,39.84) v1(342.04,38.06) v1(342.04,36.29) v1(342.14,74.13) v1(342.68,96.59) v1(342.81,126.96) v1(342.81,72.1) v1(342.81,70.19) v1(342.81,66.77) v1(342.91,50.13) v1(343.31,96.59) v1(343.54,50.13) v1(343.69,104.23) v1(344.08,66.77) v1(344.2,72.1) v1(344.2,70.07) v1(344.2,68.8) v1(344.84,151.32) v1(345.09,150.46) v1(345.09,71.08) v1(345.09,67.78) v1(345.35,149.82) v1(345.35,43.53) v1(345.73,150.46) v1(345.78,19.37) v1(345.78,18.71) v1(345.78,17.49) v1(345.85,104.23) v1(346.11,72.1) v1(346.11,70.07) v1(346.11,68.8) v1(346.11,66.77) v1(346.36,150.46) v1(346.49,95.21) v1(346.87,151.32) v1(347.5,33.75) v1(347.58,31.41) v1(347.58,30.77) v1(347.89,104.23) v1(348.01,85.43) v1(348.01,84.8) v1(348.01,84.16) v1(348.11,136.46) v1(348.11,135.19) v1(348.11,134.56) v1(349.03,88.48) v1(349.66,88.48) v1(349.65,43.48) v1(349.84,76.75) v1(350.3,46.32) v1(350.81,96.74) v1(351.57,69.69) v1(351.72,134.08) v1(351.72,133.11) v1(351.7,124.42) v1(352.46,75.78) v1(352.74,137.96) v1(352.74,137.33) v1(352.84,97.12) v1(353.09,126.38) v1(353.35,94.58) v1(353.35,93.31) v1(353.73,126.38) v1(353.73,88.1) v1(353.85,135.9) v1(353.85,135.27) v1(353.98,128.03) v1(354.24,76.82) v1(354.36,126.38) v1(354.46,90.01) v1(354.62,128.03) v1(354.54,86.81) v1(354.64,137.58) v1(354.69,42.89) v1(354.74,95.47) v1(355,126.38) v1(355.25,141.57) v1(355.25,128.03) v1(355.25,94.45) v1(355.25,92.42) v1(355.25,91.78) v1(355.63,40.73) v1(355.89,141.57) v1(356.01,41.37) v1(356.14,99.15) v1(356.14,97.12) v1(356.14,90.9) v1(356.52,60.54) v1(356.52,58.76) v1(356.52,56.99) v1(356.65,111.98) v1(357.33,38.75) v1(357.54,137.63) v1(357.66,114.8) v1(357.92,92.42) v1(358.3,60.54) v1(358.3,58.76) v1(358.3,56.99) v1(358.63,87.44) v1(358.93,127.32) v1(359.19,104.61) v1(359.19,85.18) v1(359.32,66.61) v1(359.7,138.14) v1(359.95,107.79) v1(359.95,86.2) v1(360.08,60.54) v1(360.08,58.76) v1(360.08,56.99) v1(360.33,105.12) v1(360.46,87.59) v1(361.09,87.59) v1(361.6,68.16) v1(361.6,66.13) v1(361.73,87.59) v1(362.24,33.36) v1(362.59,38.32) v1(362.64,32.12) v1(362.82,46.8) v1(363,66.13) v1(363.76,32.86) v1(365.46,85.43) v1(365.67,128.87) v1(365.67,112.1) v3(145.78,88.33) v3(256.09,76.98) v3(340.94,117.18) v3(340.99,116.52) v3(340.96,113.93) v3(340.99,113.25) v3(340.99,112.63) v3(340.99,111.98) v3(341.41,94.35) v3(341.43,94.88) v3(341.59,113.92) v3(341.59,112.63) v3(342.25,122.14) v3(342.24,113.92) v3(342.24,112.63) v3(342.24,111.98) v3(342.24,111.33) v3(342.89,116.53) v3(342.89,113.92) v3(343.54,115.23) v3(343.54,114.58) v3(343.54,113.93) v3(343.54,113.28) v3(343.54,111.33) v3(343.54,110.68) v3(343.54,110.03) v3(344.19,110.68) v3(344.19,110.05) v3(344.8,118.43) v3(344.83,110.68) v3(344.84,111.33) v3(344.84,110.05) v3(345.29,121.63) v3(345.45,118.43) v3(345.48,114.58) v3(345.48,113.93) v3(345.48,113.28) v3(345.48,112.63) v3(345.48,110.68) v3(345.48,110.05) v3(345.47,49.47) v3(346.1,118.43) v3(346.13,110.08) v3(346.14,111.33) v3(346.14,110.68) v3(346.23,49.47) v3(346.79,117.18) v3(346.79,116.53) v3(346.78,114.58) v3(346.78,113.28) v3(346.78,110.03) v3(347.17,121.58) v3(347.15,97.8) v3(347.25,101.56) v3(347.25,47.72) v3(347.4,118.43) v3(347.63,49.47) v3(348.01,47.72) v3(348.05,118.43) v3(348.08,116.53) v3(348.39,49.47) v3(348.7,118.43) v3(349.18,124.32) v3(349.35,118.43) v3(350.32,124.42) v3(350.58,48.63) v3(350.58,47.69) v3(352.61,116.75) v3(353.6,55.59) v3(353.6,54.45) v3(353.6,53.3) v3(353.6,52.16) v3(353.6,51.02) v3(353.6,49.87) v3(353.6,48.73) v3(353.6,47.59) v3(354.24,64.48) v3(355.25,64.48) v3(356.32,63.21) v3(357.08,135.46) v3(357.21,131.28) v3(357.21,130.65) v3(357.18,64.43) v3(357.66,135.98) v3(358.3,63.31) v3(358.55,124.55) v3(359.37,135.47) v3(359.37,64.48) v3(360.31,135.14) v3(360.84,135.17) v3(361.02,120.08) v3(361.02,119.54) v3(361.14,64.48) v3(361.42,135.19) v3(361.35,118.99) v3(361.47,128.69) v3(361.58,120.1) v3(361.58,119.52) v3(362.87,118.15) v3(362.87,116.07) v3(362.9,114.52) v3(362.9,112.51) v4(1.05,116.55) v4(1.05,114.52) v4(1.05,112.74) v4(2.32,83.4) v4(3.46,112.61) v4(3.72,101.18) v4(3.72,95.09) v4(4.86,93.94) v4(4.86,83.66) v4(5.87,102.33) v4(6.26,76.16) v4(6.38,73.37) v4(6.38,70.58) v4(6.38,67.78) v4(6.38,64.99) v4(6.38,62.19) v4(6.38,59.4) v4(6.38,56.61) v4(6.38,53.81) v4(6.38,51.02) v4(6.38,48.22) v4(6.38,45.43) v4(6.53,112.03) v4(6.64,109.82) v4(6.64,107.41) v4(6.64,90.51) v4(6.64,87.85) v4(7.02,104.48) v4(7.02,93.05) v4(7.14,85.31) v4(9.05,139.16) v4(11.84,139.16) v4(13.44,38.7) v4(14.64,139.16) v4(15.78,40.86) v4(17.43,139.41) v4(18.32,40.88) v4(18.7,149.44) v4(18.7,147.16) v4(18.7,144.36) v4(18.7,141.57) v4(20.99,40.98) v4(21.5,149.49) v4(24.29,149.49) v4(27.08,149.49) v4(29.88,149.49) v4(30.64,111.98) v4(30.64,109.31) v4(30.77,106.77) v4(30.89,115.53) v4(31.17,118.07) v4(31.91,120.61) v4(32.67,149.49) v4(32.65,123.03) v4(33.33,125.57) v4(34.07,127.98) v4(34.45,93.56) v4(34.98,130.77) v4(34.96,39.97) v4(35.47,149.49) v4(35.59,91.4) v4(35.72,133.31) v4(36.61,136.23) v4(36.86,39.97) v4(36.99,89.12) v4(37.5,138.9) v4(38.26,149.49) v4(38.26,141.44) v4(38.51,86.96) v4(39.15,144.11) v4(39.66,39.97) v4(39.91,146.65) v4(40.29,84.8) v4(40.67,149.44) v4(41.05,81.75) v4(41.94,76.54) v4(42.45,39.97) v4(42.63,78.93) v4(42.58,74.13) v4(44.61,72.86) v4(45.24,39.97) v4(47.66,39.97) v4(50.45,39.97) v4(53.25,39.97) v4(56.04,73.88) v4(56.04,39.97) v4(58.71,72.99) v4(58.83,39.97) v4(61.63,39.97) v4(62.39,72.23) v4(64.42,39.97) v4(65.44,71.85) v4(68.61,71.59) v4(70.01,40.1) v4(71.41,71.59) v4(72.04,40.98) v4(74.2,40.98) v4(74.96,71.97) v4(76.11,45.43) v4(76.11,43.14) v4(76.11,41.11) v4(77.38,47.21) v4(77.88,72.48) v4(79.79,47.21) v4(81.06,73.24) v4(82.07,47.21) v4(83.98,74.39) v4(84.87,47.21) v4(86.52,75.53) v4(87.28,47.21) v4(89.06,76.8) v4(89.31,45.43) v4(89.31,43.14) v4(89.31,40.98) v4(91.22,78.2) v4(91.73,40.86) v4(93.25,39.33) v4(93.38,79.85) v4(94.39,48.76) v4(94.47,49.62) v4(95.03,49.14) v4(94.98,48.3) v4(95.28,37.94) v4(95.51,68.54) v4(95.54,67.78) v4(95.54,67.02) v4(95.66,81.75) v4(95.92,35.65) v4(95.92,33.75) v4(95.92,31.71) v4(95.92,29.55) v4(95.92,27.27) v4(95.92,25.24) v4(95.92,22.95) v4(95.92,20.28) v4(95.92,17.87) v4(95.92,8.22) v4(95.92,5.88) v4(96.04,14.7) v4(96.16,68.91) v4(96.17,68.16) v4(96.17,67.4) v4(96.17,66.64) v4(96.43,1.01) v4(96.81,67.78) v4(96.81,67.02) v4(97.82,83.78) v4(99.22,1.01) v4(99.6,85.82) v4(101.38,88.1) v4(102.01,1.01) v4(102.9,90.39) v4(103.16,48.76) v4(103.16,48.02) v4(103.92,48.76) v4(103.92,48.02) v4(104.3,93.05) v4(104.81,1.01) v4(105.57,95.85) v4(106.59,98.64) v4(107.22,101.06) v4(107.6,1.01) v4(110.4,1.01) v4(113.19,1.01) v4(115.86,118.71) v4(115.86,117.95) v4(115.98,1.01) v4(118.78,1.01) v4(119.54,147.03) v4(119.62,120.23) v4(119.92,138.52) v4(119.92,137.76) v4(119.92,137) v4(119.92,136.23) v4(120.05,121.25) v4(120.3,149.57) v4(120.28,119.75) v4(120.3,110.07) v4(120.3,108.8) v4(120.68,120.74) v4(120.68,109.44) v4(121.06,120.11) v4(121.06,119.34) v4(121.19,108.8) v4(121.44,120.74) v4(121.57,108.17) v4(121.57,1.01) v4(121.7,154.65) v4(121.83,120.11) v4(121.83,119.34) v4(121.95,108.8) v4(122.21,120.74) v4(122.33,156.81) v4(122.33,108.17) v4(122.59,120.11) v4(122.71,108.8) v4(122.84,159.09) v4(122.97,120.74) v4(123.1,108.17) v4(123.48,108.8) v4(123.73,120.74) v4(123.86,108.17) v4(124.11,161) v4(124.11,121.38) v4(124.24,108.8) v4(124.37,1.01) v4(124.49,120.74) v4(124.62,109.44) v4(124.62,108.17) v4(124.75,158.97) v4(125,108.8) v4(125.76,157.44) v4(125.89,129.38) v4(125.89,128.61) v4(125.89,127.85) v4(126.32,115.53) v4(127.08,115.53) v4(127.16,1.01) v4(127.92,117.97) v4(127.84,115.53) v4(129.95,1.01) v4(132.75,1.01) v4(135.54,1.01) v4(138.34,1.01) v4(141.13,1.01) v4(142.91,147.38) v4(142.91,146.62) v4(143.47,134.08) v4(143.92,1.01) v4(145.45,148.3) v4(145.45,147.54) v4(145.57,144.2) v4(145.57,142.93) v4(145.96,143.57) v4(146.34,144.2) v4(146.34,142.93) v4(146.72,143.57) v4(146.72,1.01) v4(149.51,1.01) v4(151.8,147.25) v4(151.8,146.49) v4(152.31,1.01) v4(152.43,156.17) v4(152.56,146.49) v4(152.56,145.73) v4(153.45,148.27) v4(153.83,158.59) v4(153.83,157.82) v4(154.21,148.27) v4(154.21,147.51) v4(154.46,143.44) v4(154.59,158.59) v4(154.85,144.08) v4(154.85,142.81) v4(155.1,1.01) v4(155.23,143.44) v4(155.61,144.08) v4(155.61,142.81) v4(156.62,134.84) v4(156.62,134.08) v4(157.89,1.01) v4(160.69,1.01) v4(160.81,147.63) v4(160.81,146.87) v4(161.07,146.11) v4(163.35,144.71) v4(163.35,143.95) v4(163.35,142.68) v4(163.48,148.27) v4(163.48,147.51) v4(163.48,1.01) v4(163.74,143.31) v4(164.12,143.95) v4(164.12,142.68) v4(164.5,143.31) v4(165.77,158.33) v4(165.77,157.57) v4(166.28,1.01) v4(169.07,1.01) v4(169.7,158.59) v4(169.7,157.82) v4(170.31,147.46) v4(170.34,158.21) v4(170.34,157.44) v4(170.34,146.01) v4(170.34,135.6) v4(170.59,146.78) v4(171.1,147.39) v4(171.1,135.6) v4(171.48,146.73) v4(171.89,147.36) v4(171.86,1.01) v4(172.63,134.53) v4(172.63,133.77) v4(172.63,133.01) v4(172.63,132.25) v4(174.53,154.62) v4(174.53,153.86) v4(174.53,153.09) v4(174.53,152.33) v4(174.53,151.58) v4(174.66,1.01) v4(174.78,150.43) v4(174.78,149.66) v4(174.78,148.9) v4(175.17,155.76) v4(175.17,155) v4(175.17,154.24) v4(175.17,153.47) v4(175.17,152.71) v4(175.17,151.96) v4(175.17,151.2) v4(175.83,155.41) v4(177.45,1.01) v4(180.12,0.98) v4(180.22,132.55) v4(180.78,131.61) v4(181.52,131.61) v4(183.29,0.98) v4(184.74,3.75) v4(185.91,153.13) v4(185.83,1.11) v4(186.01,5.27) v4(185.96,3.65) v4(186.54,153.51) v4(186.54,152.74) v4(191.57,23.59) v4(191.8,64.32) v4(191.8,63.56) v4(191.8,62.8) v4(192.06,130.87) v4(192.06,130.11) v4(192.06,36.79) v4(192.06,36.03) v4(192.34,23.59) v4(192.56,64.32) v4(192.56,63.56) v4(192.56,62.8) v4(193.07,23.59) v4(193.33,64.32) v4(193.33,63.56) v4(193.33,62.8) v4(193.83,23.59) v4(194.6,23.59) v4(195.74,63.56) v4(195.74,62.8) v4(196.88,64.32) v4(196.88,63.56) v4(196.88,62.8) v4(197.21,11.11) v4(197.14,6.57) v4(197.14,3.01) v4(197.26,9.49) v4(197.64,64.32) v4(197.64,63.56) v4(197.64,62.8) v4(198.41,64.32) v4(198.41,63.56) v4(198.41,62.8) v4(198.66,0.98) v4(199.17,64.32) v4(199.17,63.56) v4(199.17,62.8) v4(201.71,66.38) v4(201.96,34.76) v4(202.47,66.38) v4(202.47,65.5) v4(202.47,64.73) v4(202.47,63.97) v4(202.6,35.14) v4(202.6,34.38) v4(203.22,63.99) v4(203.23,66.35) v4(203.23,65.59) v4(203.23,64.83) v4(203.23,35.52) v4(203.23,34.76) v4(203.49,63.3) v4(203.49,62.54) v4(203.87,35.9) v4(203.87,35.14) v4(203.87,34.38) v4(204.5,64.32) v4(204.5,63.56) v4(204.5,62.8) v4(204.5,35.52) v4(204.5,34.76) v4(204.76,1.11) v4(205.26,158.96) v4(205.26,158.21) v4(205.26,64.32) v4(205.26,63.56) v4(205.26,62.8) v4(206.03,64.32) v4(206.03,63.56) v4(206.03,62.8) v4(206.51,153.29) v4(207.27,9.36) v4(207.3,0.98) v4(208.01,9.36) v4(208.41,27.45) v4(208.41,26.71) v4(208.74,9.36) v4(208.95,63.97) v4(209.15,27.45) v4(209.15,26.71) v4(209.58,39.08) v4(209.58,38.32) v4(209.58,37.56) v4(209.71,0.98) v4(209.96,64.32) v4(209.96,63.56) v4(209.96,62.8) v4(210.22,38.7) v4(210.22,37.94) v4(210.73,64.32) v4(210.73,63.56) v4(210.73,62.8) v4(210.85,39.84) v4(210.85,39.08) v4(210.85,38.32) v4(211.49,64.32) v4(211.49,63.56) v4(211.49,62.8) v4(211.49,39.46) v4(211.49,38.7) v4(212.07,45.35) v4(212.25,64.32) v4(212.25,63.56) v4(212.25,62.8) v4(212.25,38.7) v4(212.81,45.35) v4(213.01,62.8) v4(213.01,46.09) v4(213.6,45.35) v4(213.65,0.85) v4(213.75,46.09) v4(214.41,45.35) v4(214.54,73.75) v4(214.54,72.99) v4(214.54,72.23) v4(214.54,46.12) v4(215.2,45.35) v4(215.3,73.75) v4(215.3,72.99) v4(215.3,72.23) v4(215.35,46.09) v4(216.06,45.15) v4(217.58,0.85) v4(217.71,64.32) v4(217.71,63.56) v4(217.71,62.8) v4(218.47,64.32) v4(218.47,63.56) v4(218.47,62.8) v4(219.23,64.32) v4(219.23,63.56) v4(219.23,62.8) v4(220.38,35.65) v4(220.89,0.85) v4(221.06,13.76) v4(221.14,35.65) v4(221.52,151.75) v4(221.9,55.59) v4(221.9,13.73) v4(222.03,63.56) v4(222.03,62.8) v4(222.28,54.95) v4(222.54,151.75) v4(223.04,64.32) v4(223.04,63.56) v4(223.04,62.8) v4(223.55,151.73) v4(223.81,64.32) v4(223.81,63.56) v4(223.81,62.8) v4(224.06,0.85) v4(224.57,151.75) v4(224.57,64.32) v4(224.57,63.56) v4(224.57,62.8) v4(225.33,64.32) v4(225.33,63.56) v4(225.33,62.8) v4(225.46,151.73) v4(225.74,0.83) v4(226.35,151.75) v4(227.24,0.85) v4(227.72,3.32) v4(228.86,0.83) v4(230.13,3.29) v4(230.13,2.4) v4(230.54,0.98) v4(231.55,140.55) v4(231.55,139.78) v4(231.6,139.03) v4(233.46,0.98) v4(234.86,143.44) v4(236.02,1.86) v4(238.54,19.39) v4(238.54,18.12) v4(238.92,18.76) v4(238.94,1.86) v4(239.3,19.39) v4(239.3,18.12) v4(239.43,143.44) v4(239.43,142.68) v4(239.68,18.76) v4(240.06,19.39) v4(240.06,18.12) v4(240.21,135.37) v4(240.21,134.63) v4(240.21,133.9) v4(240.24,152.24) v4(240.24,151.47) v4(240.24,133.16) v4(240.44,18.76) v4(240.82,19.39) v4(240.82,18.12) v4(240.95,155.95) v4(240.95,154.27) v4(240.95,153.51) v4(240.95,152.71) v4(240.95,151.95) v4(240.95,151.19) v4(240.95,150.43) v4(240.98,133.16) v4(241.08,132.42) v4(241.21,18.76) v4(241.59,152.33) v4(241.59,151.57) v4(241.59,150.81) v4(241.59,150.05) v4(241.59,149.28) v4(241.59,148.52) v4(241.59,19.39) v4(241.59,18.07) v4(241.94,18.73) v4(242.22,151.19) v4(242.22,150.43) v4(242.22,149.66) v4(242.22,148.9) v4(242.35,18.1) v4(242.88,1.86) v4(243.24,156.68) v4(245.4,159.73) v4(245.93,1.86) v4(247.56,161) v4(248.29,158.59) v4(248.72,1.86) v4(248.83,155.54) v4(249.33,152.74) v4(249.79,150.2) v4(250.25,147.16) v4(250.73,144.49) v4(251.24,142.08) v4(251.52,1.86) v4(251.62,139.79) v4(252.13,137.12) v4(252.51,134.71) v4(253.02,132.17) v4(254.31,1.86) v4(255.3,119.09) v4(255.68,116.68) v4(257.1,1.86) v4(257.21,108.04) v4(257.72,105.12) v4(258.1,102.45) v4(259.9,1.86) v4(262.69,1.86) v4(265.46,0.98) v4(268.13,0.98) v4(271.43,1.87) v4(274.1,1.87) v4(276.69,1.88) v4(279.48,1.88) v4(282.28,1.88) v4(285.78,1.87) v4(288.32,1.87) v4(288.65,70.88) v4(289.08,68.92) v4(289.85,68.92) v4(290.61,68.92) v4(290.86,70.45) v4(290.86,1.87) v4(291.29,22.06) v4(291.37,68.92) v4(291.57,21.3) v4(292.06,22.06) v4(292.34,21.3) v4(292.82,22.06) v4(292.89,68.16) v4(293.02,70.32) v4(293.4,1.87) v4(294.04,69.18) v4(295.43,70.19) v4(295.56,68.16) v4(295.69,12.77) v4(295.82,13.5) v4(295.94,1.74) v4(296.42,12.77) v4(296.83,69.31) v4(297.59,1.01) v4(298.1,68.16) v4(298.23,70.19) v4(299.63,69.18) v4(300.77,70.45) v4(300.77,0.98) v4(300.9,69.31) v4(300.9,68.54) v4(300.9,67.78) v4(300.9,67.02) v4(300.9,66.26) v4(301.53,70.45) v4(301.66,69.31) v4(301.66,68.54) v4(302.29,70.45) v4(302.42,69.31) v4(303.05,70.7) v4(303.18,69.31) v4(303.31,0.98) v4(303.82,70.83) v4(304.58,71.08) v4(305.34,71.21) v4(305.85,0.98) v4(307.25,71.72) v4(308.39,0.98) v4(309.15,72.35) v4(310.93,0.98) v4(313.98,0.98) v4(314.95,73.21) v4(316.52,0.98) v4(317.69,74.92) v4(319.06,0.98) v4(321.6,0.98) v4(324.14,0.98) v4(326.68,0.98) v4(329.22,0.98) v4(331.76,0.98) v4(334.3,0.98) v4(336.58,0.98) v4(356.52,150.97) v4(359.19,151.22) v4(361.98,153.25) v4(362.74,78.7) v4(362.87,71.97) v4(363.28,76.42) v4(363.25,74.13) v4(363.63,154.78) v4(363.63,70.19) v4(364.14,80.23) v4(364.78,29.01) v4(364.9,99.91) v4(364.88,92.42) v4(365.03,101.82) v4(365.16,97.12) v4(365.16,94.71) v4(365.54,90.26) v4(365.88,69.84) v4(365.98,81.99) v4(366.12,84.55) v4(366.05,64.84) v4(366.05,63.6) v4(366.05,61.19) v4(366.05,59.03) v4(366.05,56.75) v4(366.12,52.32) v4(366.12,50.22) v4(366.13,86.75) v4(366.55,154.78) v4(367.32,129) v4(367.32,112.36) v4(367.44,152.62) v4(367.44,150.08) v4(367.44,147.41) v4(367.44,145) v4(367.44,142.71) v4(367.44,140.17) v4(368.46,120.87) v4(369.42,128.5) v4(369.35,118.58) v4(369.44,135.54) v4(369.48,111.98)

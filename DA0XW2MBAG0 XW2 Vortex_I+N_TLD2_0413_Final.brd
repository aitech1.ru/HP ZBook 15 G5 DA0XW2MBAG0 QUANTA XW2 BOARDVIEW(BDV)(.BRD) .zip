# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2CC_SDA: length 3.7
  BOTTOM w0.203: PR9822.1 199.44,48.55 198.52,48.55 198.14,48.94 PR9815.1 198.14,49.25 197.48,49.92 PU9802.5
I2CC_SDA_GFX: length 85.3
  TOP w0.114: Q2020.1 208.42,49.02 v1(208.24,48.83) 208.03,48.63 208.03,48.58 207.32,47.87 v1(206.43,47.87)
  IN2 w0.089: v1(215.93,97.27) 215.81,97.14 215.81,94.71 216.34,94.17 216.34,92.38 216.07,92.1 216.07,90.91 214.96,89.8 214.96,88.02 217.08,85.9 217.08,85.34 218.17,84.24 218.17,82.69 224.95,75.91 224.95,68.98 225.43,68.5 225.43,67.89 225.89,67.43 227.62,67.43 228.56,66.48 228.56,55.5 226.7,53.64 226.7,52.7 223.93,49.93 215.83,49.93 214.91,50.84 213.45,50.84 212.63,50.03 208.95,50.03 207.85,48.94 207.85,48.45 207.27,47.87 v1(206.43,47.87)
  BOTTOM w0.102: 215.85,97.19 v1(215.93,97.27)
  BOTTOM w0.114: 215.85,97.19 215.51,96.85 215.51,96.37 215.93,95.94 R2073.2 ; U2000.R3 215.86,99.68 215.86,99.13 215.51,98.78 215.51,97.8 215.93,97.37 v1(215.93,97.27)
I2S1_BCLK: length 4.2
  TOP w0.114: R3614.1 346.54,11.24 v1(346.16,10.86) 345.58,10.28 U3600.53
I2S1_CODEC_RX_DAT: length 4.2
  TOP w0.114: R3617.2 345.52,13.58 345.12,13.98 v1(344.99,13.98) 344.61,13.6 344.61,12.49 344,11.88 U3600.57
I2S1_CODEC_TX_CLK: length 2.8
  TOP w0.114: R3655.2 349.35,12.05 v1(348.85,12.05) 348.81,12.02 R3613.2 R3614.2
I2S1_CODEC_TX_DAT: length 3.1
  TOP w0.114: R3616.2 345.17,12.82 v1(345.04,12.69) 345.04,12.59 343.93,11.48 U3600.56
I2S1_CODEC_TX_WS: length 1.9
  TOP w0.114: R3615.2 344.42,10.79 v1(344.38,10.84) 344.23,10.68 U3600.54
I2S1_MCLK: length 6.2
  TOP w0.114: v1(348.16,10.4) 347.99,10.58 R3613.1 347.76,11.24 346.8,10.28 345.98,10.28 345.58,9.88 U3600.52
I2S1_RX_DAT: length 330.3
  TOP w0.114: R3652.2 200.94,157.1 200.31,157.72 200.31,158.59 199.92,158.98 U3606.4 197.49,158.98 v1(196.87,159.6) ; v1(187.41,40.73) 187.74,40.73 189.67,38.8 189.67,27.42 191.54,25.55 196.08,25.55 198.18,23.45 198.18,17.5 197.57,16.88 197.57,14.1 201.21,10.45 203.82,10.45 208.74,5.53 v1(208.74,4.18) ; v1(346.74,13.58) R3617.1
  IN2 w0.089: v1(196.87,159.6) 196.87,158.32 195.46,156.91 195.46,152.94 195.18,152.67 195.18,152.41 193.3,150.52 193.3,149.9 193.49,149.71 193.49,133.02 195.34,131.17 195.34,130.04 195.06,129.76 195.06,118.93 193.96,117.83 193.96,103.69 192.85,102.58 192.85,97.42 191.78,96.35 191.78,95.32 191.15,94.68 191.15,92.65 189.22,90.73 189.22,88.92 188.11,87.81 187.67,87.81 187.22,87.36 187.22,85.29 186.98,85.04 186.22,85.04 184.94,83.76 184.94,71.24 187.67,68.51 187.67,60.94 188.21,60.39 188.21,59.73 187.98,59.5 187.98,57.67 188.27,57.38 188.27,53.68 187.88,53.29 187.88,50.46 188.27,50.07 188.27,46.35 187.87,45.95 187.87,41.19 v1(187.41,40.73)
  IN3 w0.089: v1(208.74,4.18) 208.9,4.33 208.9,4.61 209.81,5.53 234.09,5.53 235.11,4.5 238.61,4.5 239.57,5.46 240.68,5.46 240.84,5.3 242.23,5.3 243.33,4.21 250.37,4.21 251.12,4.96 252.95,4.96 253.54,4.36 296.66,4.36 299.74,7.44 314.44,7.44 316.23,9.23 318.18,9.23 318.81,8.6 321.72,8.6 323.25,10.12 325.79,10.12 326.55,10.89 328.49,10.89 329.12,11.51 330.78,11.51 331.35,12.08 332.56,12.08 333.01,12.54 336.06,12.54 336.68,13.17 346.32,13.17 v1(346.74,13.58)
I2S1_SFRM: length 9.1
  BOTTOM w0.102: 254.71,86.45 254.71,86.29 v1(254.69,86.27) 254.69,85.67 255.51,84.86 255.51,81.57 254.67,80.74 254.67,80.26 254.07,79.66 U9002.BD12
  BOTTOM w0.114: 254.71,86.45 254.71,86.9 254.92,87.11 R9605.1
I2S1_TX_CLK: length 356.4
  TOP w0.114: v1(348.77,11.43) 348.88,11.32 R3655.1 ; TP3606.1 221.72,158.08 221.19,158.61 v3(221.19,158.76) ; v1(187.41,39.46) 187.44,39.46 188.73,38.17 188.73,27.18 191.19,24.72 195.73,24.72 197.35,23.11 197.35,17.84 196.73,17.23 196.73,13.75 201.01,9.46 203.44,9.46 207.26,5.65 207.26,4.32 208.45,3.13 208.45,2.44 v1(208.39,2.38)
  IN1 w0.076: v3(221.19,158.76) 221.19,156.35 219.67,154.83 205.54,154.83 204.3,153.58 204.3,152.29 203.23,151.22 198.66,151.22 197.25,152.63 v3(197.25,153.58)
  IN2 w0.089: v1(187.41,39.46) 188.65,40.71 188.65,44.56 189.45,45.36 189.45,47.39 189.05,47.79 189.05,50.39 188.67,50.78 188.67,52.96 189.24,53.53 189.24,60.62 188.46,61.4 188.46,68.99 185.73,71.73 185.73,77.26 188.66,80.2 188.66,87.17 190.06,88.56 190.06,89.81 194.08,93.82 194.08,102.69 194.74,103.36 194.74,117.36 195.84,118.46 195.84,129.43 196.13,129.71 196.13,131.5 194.28,133.35 194.28,149.6 197.25,152.57 v3(197.25,153.58)
  IN3 w0.089: v1(208.39,2.38) 208.45,2.31 209.21,2.31 211.25,4.36 233.39,4.36 234.67,3.08 296.97,3.08 300.21,6.31 313.85,6.31 315.4,4.76 320.05,4.76 320.33,5.04 323.37,5.04 324.7,6.38 327.37,6.38 328.77,7.78 328.77,9.53 329.62,10.38 336.46,10.38 336.84,10.76 347.12,10.76 347.79,11.43 v1(348.77,11.43)
  BOTTOM w0.102: v3(221.19,158.76) 221.22,158.74 U3603.B1
  BOTTOM w0.114: U3602.B1 198.49,153.55 198.33,153.71 197.37,153.71 v3(197.25,153.58)
I2S1_TX_DAT: length 349
  TOP w0.114: v1(187.41,38.83) 188.26,37.98 188.26,26.93 190.99,24.2 195.59,24.2 196.88,22.91 196.88,18.04 196.26,17.42 196.26,13.56 200.82,8.99 203.24,8.99 206.79,5.45 206.79,4.13 v1(207.98,2.94) ; TP3604.1 219.84,157.87 v3(220.16,158.18) ; R3616.1 v1(346.74,12.82)
  IN1 w0.076: v3(220.16,158.18) 220.25,158.18 220.73,157.7 220.73,156.54 219.48,155.28 205.39,155.28 203.87,153.76 203.87,152.57 202.98,151.68 198.91,151.68 v3(198.15,152.44)
  IN2 w0.089: v3(198.15,152.44) 197.75,152.44 194.72,149.42 194.72,133.53 196.57,131.69 196.57,129.53 196.29,129.25 196.29,118.27 195.19,117.17 195.19,103.18 194.52,102.51 194.52,93.64 190.51,89.63 190.51,88.33 189.11,86.93 189.11,80.02 186.17,77.08 186.17,72.02 188.9,69.29 188.9,61.58 189.7,60.78 189.7,51.15 189.5,50.95 189.5,47.97 189.9,47.57 189.9,45.18 189.1,44.38 189.1,40.52 v1(187.41,38.83)
  IN3 w0.089: v1(346.74,12.82) 336.83,12.82 335.17,11.17 329.26,11.17 328.63,10.54 326.69,10.54 325.93,9.78 323.39,9.78 321.83,8.22 318.56,8.22 317.94,8.84 316.39,8.84 314.65,7.1 299.88,7.1 296.8,4.02 253.4,4.02 252.81,4.61 251.26,4.61 250.51,3.86 243.19,3.86 242.09,4.96 240.7,4.96 240.54,5.12 239.71,5.12 238.76,4.16 234.85,4.16 233.84,5.17 209.94,5.17 209.25,4.48 209.25,3.95 208.24,2.94 v1(207.98,2.94)
  BOTTOM w0.102: U3603.A2 220.49,158.18 v3(220.16,158.18)
  BOTTOM w0.114: v3(198.15,152.44) 198.15,152.49 198.52,152.86 198.72,152.86 198.98,153.13 U3602.A2
I2S1_TX_WS: length 362.2
  TOP w0.114: R3615.1 345.49,11.3 v1(345.57,11.37) ; v3(196.81,153.9) 196.81,153.32 197.1,153.04 197.73,153.04 198.53,153.84 198.53,154.27 199.3,155.03 199.63,155.03 200.48,155.88 200.48,157.02 199.82,157.68 U3606.6 ; TP3605.1 220.66,158.43 v3(220.66,158.76) ; v1(209.02,2.76) 209.02,3.22 207.83,4.42 207.83,5.74 203.63,9.93 201.21,9.93 197.2,13.94 197.2,17.03 197.82,17.65 197.82,23.3 195.93,25.19 191.38,25.19 189.2,27.37 189.2,38.64 187.74,40.1 v1(187.41,40.1)
  IN2 w0.089: v1(187.41,40.1) 188.21,40.9 188.21,45.8 188.61,46.2 188.61,50.21 188.22,50.6 188.22,53.15 188.61,53.53 188.61,57.53 188.32,57.81 188.32,59.35 188.56,59.59 188.56,60.54 188.01,61.08 188.01,68.78 185.28,71.51 185.28,77.45 188.22,80.39 188.22,87.35 189.62,88.75 189.62,90.64 191.49,92.51 191.49,94.54 192.13,95.17 192.13,96.21 193.19,97.28 193.19,102.44 194.3,103.54 194.3,117.54 195.4,118.64 195.4,129.61 195.68,129.9 195.68,131.32 193.83,133.17 193.83,149.79 196.65,152.61 196.65,153.73 v3(196.81,153.9)
  IN3 w0.089: v1(345.57,11.37) 345.04,11.9 344.08,11.9 343.57,11.39 335.88,11.39 335.31,10.82 329.4,10.82 328.33,9.75 328.33,7.96 327.18,6.82 324.52,6.82 323.18,5.49 320.83,5.49 320.58,5.74 315.05,5.74 314.03,6.76 300.03,6.76 296.79,3.52 243.05,3.52 242.41,4.15 241.46,4.15 240.95,3.65 234.73,3.65 233.56,4.82 211.08,4.82 v1(209.02,2.76) ; v3(220.66,158.76) 220.89,158.54 220.89,156.68 220.38,156.17 219.62,156.17 218.98,156.81 205.01,156.81 204.04,157.77 196.81,157.77 196.52,157.49 196.52,154.19 v3(196.81,153.9)
  BOTTOM w0.102: U3603.A1 220.82,158.6 v3(220.66,158.76)
  BOTTOM w0.114: U3602.A1 197.64,153.15 197.49,153 197.14,153 196.81,153.32 v3(196.81,153.9)
I_ADP_ADC0: length 33.5
  TOP w0.114: R6241.2 258.39,21.26 v1(258.71,20.94)
  IN2 w0.089: v1(254.13,7.74) 262.01,7.74 262.67,7.07 264.31,7.07 264.95,7.71 264.95,10.44 264.63,10.76 264.63,10.79 264.44,10.98 264.44,11.53 263.8,12.16 263.8,13.3 262.94,14.16 261.76,14.16 259.62,16.31 259.62,18.65 259.32,18.95 259.32,20.33 v1(258.71,20.94)
  BOTTOM w0.114: PR11028.1 251.3,6.61 251.27,6.64 251.27,7.11 251.52,7.36 253.75,7.36 v1(254.13,7.74)
I_ADP_ADC0_R: length 14
  TOP w0.114: v3(266.29,25.32) 265.76,24.79 265.76,22.21 265.52,21.97 265.17,21.97 264.24,22.9 262.95,22.9 v1(261.69,21.64) 261.06,21.01 260.72,21.01 260.14,20.42 259.4,20.42 259.15,20.67 259.15,21.02 259.17,21.05 R6241.1 C6038.2
  BOTTOM w0.102: U6001.D3 v3(266.29,25.32)
I_DCHG_ADC1: length 47.6
  TOP w0.114: PR11029.1 251.62,7.35 v1(250.01,5.95) ; v1(264.45,17.49) 264.01,17.92 258.99,17.92 257.72,19.19 257.72,24.37 257.39,24.69 257.39,26.54 257.89,27.04 R6023.2
  IN2 w0.089: v1(264.45,17.49) 264.45,16.27 265.34,15.38 265.34,13.25 266.3,12.28 266.3,8.13 264.62,6.45 262.42,6.45 261.84,7.02 251.08,7.02 v1(250.01,5.95)
I_DCHG_ADC1_R: length 10.8
  TOP w0.114: v3(266.29,25.97) 265.8,25.97 265.52,26.25 264.05,26.25 263.81,26.01 262.22,26.01 261.83,26.4 261.14,26.4 260.78,26.76 259.63,26.76 R6023.1 259.35,27.33 259.54,27.52 v1(260.66,27.52)
  BOTTOM w0.114: U6001.E3 v3(266.29,25.97) ; v1(260.66,27.52) 260.66,27.15 C6009.2
I_SET: length 64
  TOP w0.114: PQ12009.3 297.77,31.89 296.07,30.19 v1(296.07,29.17) v1(296.07,27.78)
  IN1 w0.076: v1(296.07,27.78) 290.74,27.78 289.03,26.08 286.54,26.08 286.23,25.77 285.88,25.77 284.69,24.58 284.69,23.6 281.04,19.95 280.13,19.95 277.15,16.97 277.15,16.12 271.54,10.52 264.36,10.52 262.87,12 260.11,12 258.08,14.04 256.11,14.04 253,10.92 252.47,10.92 251.62,11.77 v1(251.62,13.68)
  BOTTOM w0.114: PR11006.2 251.4,13.46 v1(251.62,13.68)
ICCINSERTN: length 14.9
  IN1 w0.076: v1(282.2,17.39) 281.55,17.39 278.67,14.51 278.67,9.67 v1(280.5,7.84)
  BOTTOM w0.114: v1(282.2,17.39) 282.76,17.95 U7300.19 ; CON7300.2 v1(280.5,7.84)
IFPC_RSET: length 10.8
  BOTTOM w0.102: 206.41,97.19 206.41,97.75 205.9,98.26 205.9,98.67 206.13,98.9 206.43,98.9 206.71,99.18 206.71,101.87 206.92,102.07 207.09,102.07 207.42,102.41 207.42,103.86 U2000.AF8
  BOTTOM w0.114: R2077.2 207.55,95.82 206.41,96.97 206.41,97.19
IFPC_SCL: length 11.6
  BOTTOM w0.102: U2000.AG3 206.28,99.79 205.9,99.4 205.9,99.25 205.48,98.83 205.48,97.89 205.57,97.8 205.57,97.19
  BOTTOM w0.114: 205.57,97.19 205.57,95.24 R2076.2 205.85,94.61 205.85,93.37 R2139.2 206.33,92.89 206.33,91.2 205.25,90.12 Q2024.1
IFPC_SDA: length 11.6
  BOTTOM w0.102: 205.95,97.19 205.95,97.75 205.69,98.01 205.69,98.75 206.24,99.3 U2000.AG2
  BOTTOM w0.114: 205.95,97.19 205.95,95.22 206.08,95.1 R2075.1 206.11,94.67 206.11,93.94 206.24,93.82 207.58,93.82 207.7,93.69 207.7,93.44 207.58,93.32 R2138.2 206.7,93.32 206.57,93.19 206.57,91.55 206.7,91.42 Q2024.4
IFPEF_RSET: length 3.1
  TOP w0.114: R2124.2 210.31,104.83 209.61,104.13 209.61,103.38 v1(209.22,102.99)
  BOTTOM w0.114: U2000.AD6 v1(209.22,102.99)
ILIM_SEL: length 312
  TOP w0.114: R7022.1 27.22,96.09 27.85,95.47 v1(28.67,95.47)
  IN1 w0.076: v1(272.57,22.95) 272.12,22.49 272.12,22.06 272.57,21.6 272.57,21.17 272.07,20.66 271.69,20.66 269.74,18.72 267.61,18.72 267.2,18.32 265.5,18.32 264.17,19.65 262.28,19.65 261.15,20.78 261.15,22.45 259.09,24.51 259.09,25.62 257.8,26.9 256.27,26.9 254.25,28.92 253.94,28.92 252.28,30.58 231.95,30.58 228.05,26.68 218.04,26.68 214.03,22.67 207.14,22.67 205.1,24.72 189.99,24.72 189.67,24.4 187.18,24.4 186.27,23.49 176.54,23.49 175.94,24.09 137.37,24.09 137.06,24.4 110.47,24.4 106.71,28.16 106.19,28.16 105.82,28.53 105.82,30.53 104.48,31.88 104.48,35.09 103.21,36.36 103.21,43.22 102.4,44.03 101.76,44.03 93.41,52.38 90.76,52.38 89.75,53.39 68.51,53.39 67.49,52.37 65.78,52.37 64.63,53.53 63.27,53.53 63.1,53.71 60.12,53.71 58.99,54.83 58.99,58.87 56.42,61.45 56.42,62.42 52.2,66.64 45.96,66.64 44.91,67.68 39.88,67.68 38.35,69.22 38.35,71.38 36.63,73.09 36.63,75.08 37.01,75.47 37.01,77.79 29.95,84.85 29.95,92.2 28.67,93.48 v1(28.67,95.47)
  BOTTOM w0.114: v1(272.57,22.95) 272.47,23.06 U6001.A12
IM_5S_CLK: length 185.6
  TOP w0.114: R6353.1 101.88,6.36 102.32,6.36 103.87,7.91 104.53,7.91 104.96,8.35 v1(104.96,8.42)
  IN3 w0.089: v1(104.96,8.42) 104.96,8.35 105.24,8.07 176.47,8.07 184.6,16.2 197.05,16.2 204.77,8.48 217.09,8.48 218.96,10.35 223.25,10.35 224.4,9.2 234.1,9.2 235.46,10.55 238.21,10.55 240.23,8.53 243.98,8.53 244.46,8.05 250.17,8.05 253.48,11.36 253.48,11.97 254.8,13.3 254.8,14.44 254.46,14.77 254.46,15.75 255.8,17.08 256.45,17.08 v1(258.93,19.57)
  BOTTOM w0.114: U6001.C1 265.23,24.91 264.24,24.91 262.41,23.08 R6133.1 262.26,23.36 262.03,23.59 261.65,23.59 261.42,23.36 261.42,20.83 260.83,20.24 260,20.24 259.34,19.57 v1(258.93,19.57)
IM_5S_DATA: length 186.5
  TOP w0.114: v1(104.31,8.35) 104.18,8.22 103.85,8.22 102.24,6.61 100.84,6.61 100.62,6.39 R6354.1
  IN3 w0.089: v1(259.19,18.38) 257.99,18.38 256.52,16.91 255.87,16.91 254.64,15.68 254.64,14.98 254.98,14.64 254.98,13.23 253.65,11.9 253.65,11.28 250.23,7.86 244.4,7.86 243.91,8.35 240.16,8.35 238.15,10.36 235.55,10.36 234.21,9.02 224.3,9.02 223.15,10.17 219.03,10.17 217.16,8.31 204.84,8.31 204.84,8.31 204.69,8.31 196.98,16.02 184.67,16.02 176.54,7.89 176.39,7.89 104.76,7.89 v1(104.31,8.35)
  BOTTOM w0.114: v1(259.19,18.38) 259.19,18.59 260.29,19.69 261.06,19.69 262.26,20.89 R6132.1 262.39,22.32 262.69,22.62 262.69,22.85 264.5,24.66 265.65,24.66 U6001.B2
IMON_INT#: length 98.7
  TOP w0.114: PR9824.1 199.55,53.05 v1(198.53,54.07) ; v1(212.12,48.99) 212.12,49.75 211.76,50.11 Q2021.3
  IN2 w0.089: v1(227.59,53.68) 227.36,53.45 227.36,52.85 224.08,49.57 215.91,49.57 215.7,49.37 212.5,49.37 v1(212.12,48.99) 211.69,48.55 210.09,48.55 209.91,48.73 209.07,48.73 207.78,47.44 206.03,47.44 204.12,49.34 204.12,52.16 203.61,52.67 202.98,52.67 202.6,52.29 200.44,52.29 198.66,54.07 v1(198.53,54.07) ; v1(239.88,66.64) 239.88,65.04 249.79,55.13 253.14,55.13 256.14,58.13 256.14,59.96 254.87,61.23 254.87,62.53 256.93,64.58 258.35,64.58 258.83,65.06 259.47,65.06 260.28,64.26 v1(260.28,63.66)
  IN3 w0.089: v1(239.88,66.64) 237.85,64.61 237.85,63.65 237.9,63.6 237.9,63.02 237.45,62.57 234.17,62.57 233.97,62.78 231.6,62.78 230.56,61.74 230.56,58.38 229.69,57.5 229.69,56.47 227.59,54.37 v1(227.59,53.68)
  BOTTOM w0.102: 261.18,63.59 260.99,63.78 260.4,63.78 v1(260.28,63.66)
IMON_SCL: length 129.6
  TOP w0.114: v1(260.59,89.65) 260.08,89.14 259.77,89.14 259.37,88.74 259.37,87.94 260.53,86.77 260.53,84.79 260.28,84.54 260.28,83.5 258.14,81.36 258.14,81.03 257.92,80.81 257.92,80.81 256.64,79.53 256.59,79.53 v3(256.57,79.52) ; v1(201.2,48.45) 201.43,48.22 203.21,48.22 203.34,48.1 204.65,48.1 205.54,48.99 205.54,49.72 205.9,50.07 205.9,51.18 206.22,51.51 207.31,51.51 207.74,51.08 Q2020.3 ; v1(228.4,53.63) 228.89,54.12 228.89,58.21 227.79,59.3 227.79,62.73 228.34,63.27 228.34,71.91 228.55,72.12 228.55,73.19 229.09,73.73 229.09,80 v1(229.42,80.33)
  IN2 w0.089: v1(201.2,48.45) 201.43,48.68 203.03,48.68 204.63,47.08 208.19,47.08 208.82,47.72 210.22,47.72 210.7,48.2 215.51,48.2 216.53,49.21 224.22,49.21 228.4,53.4 v1(228.4,53.63) ; v1(260.59,89.65) 260.48,89.65 257.84,92.29 252.76,92.29 252.07,91.61 251.11,91.61 250.34,90.85 249.11,90.85 246.24,87.97 234.59,87.97 234.32,88.24 230.35,88.24 229.44,87.33 228.53,87.33 227.88,86.68 227.14,86.68 226.75,86.29 226.75,83.57 229.42,80.9 v1(229.42,80.33)
  BOTTOM w0.102: v3(256.57,79.52) 256.57,79.51 256.54,79.48 256.54,78.88 256.45,78.78 256.45,78.55 U9002.BF17
  BOTTOM w0.114: v1(201.2,48.45) 201.2,49.74 PR9823.2
IMON_SDA: length 128.3
  TOP w0.114: v1(228.89,80.71) 228.89,80.2 228.86,80.18 228.86,73.83 228.32,73.29 228.32,72.22 228.11,72.01 228.11,63.38 227.56,62.82 227.56,59.21 228.66,58.11 228.66,54.95 228.07,54.37 v1(228.07,54.19) ; v1(200.57,48.4) 201,47.97 203.11,47.97 203.23,47.84 204.76,47.84 205.77,48.86 205.77,49.62 205.93,49.78 Q2020.6 ; v1(261.07,89.22) 261.04,89.22 260.69,88.86 259.82,88.86 259.59,88.64 259.59,88.03 260.76,86.87 260.76,84.65 260.51,84.39 260.51,83.4 258.37,81.26 258.37,80.82 257.44,79.89 257.44,78.88 257.28,78.73 v3(257.28,78.72)
  IN2 w0.089: v1(200.57,48.4) 201.02,48.86 203.1,48.86 204.7,47.26 208.11,47.26 208.75,47.89 210.14,47.89 210.63,48.38 215.44,48.38 216.46,49.39 224.15,49.39 227.74,52.98 227.74,53.2 228,53.46 228,54.12 v1(228.07,54.19) ; v1(228.89,80.71) 228.61,80.99 228.61,81.46 226.57,83.5 226.57,86.36 227.07,86.86 227.81,86.86 228.46,87.51 229.28,87.51 230.23,88.46 234.6,88.46 234.83,88.23 246.24,88.23 249.04,91.02 250.27,91.02 251.03,91.78 252,91.78 252.68,92.47 258.32,92.47 261.07,89.73 v1(261.07,89.22)
  BOTTOM w0.102: U9002.BE17 255.97,78.12 256.34,78.12 256.55,78.32 256.9,78.32 257.28,78.7 v3(257.28,78.72)
  BOTTOM w0.114: v1(200.57,48.4) 200.7,48.54 PR9822.2
IMVP_PSYS: length 304.1
  TOP w0.114: PC11026.1 PR11032.2 248.04,7.28 v1(248.34,6.97)
  TOP w0.203: v1(131.35,147.51) 131.07,147.79 PR19055.2 PC19013.2
  IN1 w0.076: v1(248.34,6.97) 247.53,7.79 244.47,7.79 243.87,8.39 241.08,8.39 240.35,9.12 238.67,9.12 238.05,9.74 237.15,9.74 236.65,9.23 234.36,9.23 233.6,8.47 225.99,8.47 225.46,7.94 218.75,7.94 216.19,10.5 208.49,10.5 207.68,11.32 207.12,11.32 205.82,12.61 205.82,14.57 205.01,15.38 204.45,15.38 200.8,19.04 181.97,19.04 179.28,16.35 111.25,16.35 v1(104.43,23.17)
  IN3 w0.089: v1(103.84,85.74) 103.87,85.77 104.02,85.77 105.49,87.24 105.49,89.1 106.28,89.89 106.28,90.58 108.02,92.32 108.02,93.03 109.56,94.57 109.56,96.67 116.81,103.93 116.81,109.37 114.19,111.99 114.19,116.65 115.42,117.88 115.42,121.45 116.4,122.42 116.4,127.89 121.83,133.32 121.83,143.45 122.41,144.03 122.55,144.03 122.55,144.03 127.21,144.03 130.69,147.51 v1(131.35,147.51)
  BOTTOM w0.114: v1(104.43,23.17) 104.43,23.97 103.72,24.67 103.72,45.37 102.14,46.95 102.14,48.41 104.47,50.75 104.47,84.83 103.84,85.46 v1(103.84,85.74)
  BOTTOM w0.203: v1(131.35,147.51) 131.33,147.53 PU19000.46
IN1_AEQ#_EDP: length 4.4
  TOP w0.114: U3007.59 66.33,59.78 66.53,59.58 68.19,59.58 R3062.2 69.37,58.9 v1(69.76,58.51)
IN1_PEQ_EDP: length 3.4
  TOP w0.114: R3067.2 v1(62.77,59.17) 63.01,59.17 63.28,58.9 R3075.2 63.79,59.4 63.53,59.66 U3007.52
IN2_AEQ#_EDP: length 3.6
  TOP w0.114: U3007.58 65.93,59.81 66.41,59.33 67.55,59.33 v1(67.85,59.03) R3063.2
IN2_PEQ_EDP: length 4.8
  TOP w0.114: v1(60.75,58.01) R3076.2 60.76,58.9 61.22,58.9 R3068.2 61.75,58.9 62.46,59.61 62.84,59.61 63.13,59.89 U3007.51
INT_EDP_AUXN: length 160.1
  IN3 w0.089: v1(180.42,119.57) 181.1,118.9 181.1,106.86 180.08,105.84 180.08,104.62 180.42,104.28 180.42,103.27 179.17,102.01 179.17,101.26 177.73,99.83 177.73,95.49 161.16,78.92 102.28,78.92 101.35,77.99 95.08,77.99 92.5,75.41 91.85,75.41 91.29,74.85 90.59,74.85 85.5,69.76 78.44,69.76 77.76,70.45 71.28,70.45 70.58,69.75 69.95,69.75 v1(69.5,70.19)
  BOTTOM w0.079: U9001.B26 178.42,118.88 178.36,118.94 178.36,119.04 178.54,119.22 179.61,119.22 180.12,119.72 180.27,119.72 v1(180.42,119.57)
  BOTTOM w0.102: v1(69.5,70.19) 69.07,69.76 69.07,69.42 68.94,69.29 68.94,67.71 68.08,66.84 64.14,66.84 62.44,68.54 62.44,69.05 62.57,69.18 62.89,69.18 C3067.2
INT_EDP_AUXN_C: length 3.4
  TOP w0.102: v1(62.9,70.7) 62.72,70.53 62.72,70.37 62.9,70.19 63.15,70.19 63.4,69.94 63.4,69.81 63.53,69.69 U3007.29
  BOTTOM w0.102: C3067.1 62.77,69.82 62.59,70 62.59,70.4 v1(62.9,70.7)
INT_EDP_AUXP: length 160.1
  IN3 w0.089: v1(181.06,119.59) 181.06,119.22 181.29,118.99 181.29,106.78 180.27,105.76 180.27,104.7 180.61,104.36 180.61,103.19 179.36,101.93 179.36,101.18 177.92,99.75 177.92,95.41 161.24,78.73 102.36,78.73 101.43,77.8 95.16,77.8 92.58,75.22 91.93,75.22 91.36,74.66 90.66,74.66 85.58,69.57 78.36,69.57 77.68,70.26 71.36,70.26 70.66,69.56 v1(69.5,69.56)
  BOTTOM w0.079: v1(181.06,119.59) 180.69,119.95 180.12,119.95 179.54,119.37 178.47,119.37 178.09,119 U9001.C26
  BOTTOM w0.102: v1(69.5,69.56) 69.15,69.2 69.15,67.62 68.16,66.64 v6(67.27,66.64) 64.05,66.64 62.24,68.46 62.24,68.81 C3066.2
INT_EDP_AUXP_C: length 3.3
  TOP w0.102: v1(62.26,70.7) 62.34,70.7 62.52,70.53 62.52,70.29 62.81,69.99 63.07,69.99 63.2,69.86 63.2,69.76 63.13,69.69 U3007.30
  BOTTOM w0.102: C3066.1 62.27,69.82 62.39,69.94 62.39,70.58 v1(62.26,70.7)
INT_EDP_TXN0: length 150
  TOP w0.102: C3077.2 72.9,65.71 72.9,65.51 73.01,65.4 73.49,65.4 74.04,65.95 75.51,65.95 78.48,68.92 80.93,68.92 81.31,69.31 85.22,69.31 85.68,69.77 85.68,70.7 85.55,70.83 v1(85.25,70.83)
  IN3 w0.089: v1(176.47,121.63) 176.66,121.83 176.66,121.99 176.97,122.3 178.66,122.3 179.58,121.37 179.58,106.06 179.29,105.76 179.29,102.8 178.4,101.91 178.4,101.19 177.34,100.12 177.34,95.85 160.86,79.37 102.17,79.37 101.19,78.39 94.92,78.39 92.34,75.81 91.69,75.81 91.12,75.24 90.35,75.24 85.93,70.83 v1(85.25,70.83)
  BOTTOM w0.102: v1(176.47,121.63) 176.47,121.56 U9001.E29
INT_EDP_TXN0_C: length 5.4
  TOP w0.102: C3077.1 72.01,65.6 69.91,65.6 69.53,65.22 v6(69.04,65.22) 68.09,65.22 67.98,65.33 U3007.12
INT_EDP_TXN1: length 147.9
  TOP w0.102: v1(84.66,70.58) 83.95,71.29 83.01,71.29 82.12,70.4 80.16,70.4 79.58,69.81 78.36,69.81 75.28,66.74 71.44,66.74 C3079.2
  IN3 w0.089: v1(177.12,120.85) 177.32,120.65 178.67,120.65 179,120.32 179,106.42 178.59,106.01 178.59,102.96 176.75,101.12 176.75,96.17 160.81,80.23 102.19,80.23 100.95,78.98 94.69,78.98 92.1,76.39 91.45,76.39 90.88,75.83 89.96,75.83 86.52,72.39 85.23,72.39 84.69,71.85 84.43,71.85 84.17,71.59 84.17,70.73 84.4,70.5 84.59,70.5 v1(84.66,70.58)
  BOTTOM w0.127: U9001.E28 177.12,120.78 v1(177.12,120.85)
INT_EDP_TXN1_C: length 3.1
  TOP w0.102: C3079.1 69.87,66.77 69.65,66.77 69.37,66.49 v6(68.89,66.49) 68.02,66.49 67.97,66.53 U3007.15
INT_EDP_TXN2: length 151.5
  TOP w0.102: v1(75.6,68.8) 74.71,67.91 74.71,67.65 74.53,67.48 73.45,67.48 72.94,67.99 C3081.2
  IN3 w0.089: v1(180.73,122.08) 180.99,121.82 180.99,121.63 182.97,119.66 182.97,103.02 182.66,102.71 182.2,102.71 181.78,102.29 181.78,101.47 178.9,98.58 178.9,94.9 161.52,77.52 102.53,77.52 101.84,76.82 97.96,76.82 97.36,76.23 95.37,76.23 92.88,73.73 91.88,73.73 88.58,70.43 88.58,69.96 88.33,69.71 87.76,69.71 86.62,68.57 76.74,68.57 76.54,68.77 75.62,68.77 v1(75.6,68.8)
  BOTTOM w0.079: v1(180.73,122.08) 180.86,122.08 181,121.94 181,121.77 180.89,121.66 179.93,121.66 179.8,121.79 179.21,121.79 178.99,121.57 178.99,121.48 U9001.B29
INT_EDP_TXN2_C: length 5.2
  TOP w0.102: U3007.17 67.98,67.33 68.06,67.25 68.46,67.25 69.07,67.86 v6(70.64,67.86) 71.83,67.86 C3081.1
INT_EDP_TXN3: length 151.4
  TOP w0.102: C3083.2 71.03,69.27 71.18,69.13 71.48,69.13 v1(71.66,69.31)
  IN3 w0.089: v1(180.73,120.56) 180.78,120.56 181.83,119.5 181.83,106.11 182.37,105.58 182.37,104.96 182.12,104.71 181.64,104.71 181.06,104.12 181.06,101.74 178.31,99 178.31,95.19 161.34,78.21 102.4,78.21 101.59,77.41 97.71,77.41 97.12,76.81 94.73,76.81 92.75,74.83 92.12,74.83 88.21,70.92 88.08,70.92 86.31,69.15 77.27,69.15 76.56,69.86 75.51,69.86 75.21,69.57 73.32,69.57 72.67,68.92 72.05,68.92 v1(71.66,69.31)
  BOTTOM w0.079: v1(180.73,120.56) 180.89,120.56 181,120.66 181,120.71 181.07,120.78 181.07,120.88 180.83,121.12 179.99,121.12 179.61,120.74 178.46,120.74 178.37,120.65 178.37,120.51 178.43,120.45 U9001.B28
INT_EDP_TXN3_C: length 3.4
  TOP w0.102: C3083.1 69.82,69.13 68.71,69.13 68.02,68.44 67.93,68.44 67.83,68.53 U3007.20
INT_EDP_TXP0: length 149.9
  TOP w0.102: v1(85.71,71.49) 85.55,71.34 85.55,71.16 85.88,70.83 85.88,69.69 85.3,69.1 81.4,69.1 81.02,68.72 78.57,68.72 75.6,65.75 74.12,65.75 73.36,64.99 C3076.2
  IN3 w0.089: v1(85.71,71.49) 85.27,71.49 85.2,71.41 85.2,71.29 85.27,71.22 85.41,71.22 85.61,71.02 85.86,71.02 90.27,75.43 91.04,75.43 91.61,76 92.26,76 94.84,78.58 101.11,78.58 102.09,79.56 160.78,79.56 177.15,95.93 177.15,100.2 178.21,101.27 178.21,101.99 179.1,102.88 179.1,105.84 179.39,106.14 179.39,121.29 178.58,122.11 177.05,122.11 176.86,121.91 176.86,121.72 176.94,121.63 v1(177.12,121.63)
  BOTTOM w0.102: U9001.D29 177.12,121.56 v1(177.12,121.63)
INT_EDP_TXP0_C: length 5.4
  TOP w0.102: C3076.1 72.01,65.39 v6(70.67,65.39) 69.99,65.39 69.61,65.01 68.08,65.01 68,64.93 U3007.11
INT_EDP_TXP1: length 147.9
  TOP w0.102: C3078.2 71.44,66.54 75.37,66.54 78.44,69.61 79.66,69.61 80.25,70.19 v6(80.65,70.19) 82.2,70.19 83.09,71.08 83.87,71.08 84.18,70.77 84.18,70.55 84.11,70.47 v1(83.88,70.47)
  IN3 w0.089: v1(176.47,120.85) 176.86,120.46 178.59,120.46 178.81,120.24 178.81,106.49 178.4,106.09 178.4,103.04 176.56,101.2 176.56,96.25 160.74,80.42 102.11,80.42 100.87,79.17 94.61,79.17 92.02,76.58 91.37,76.58 90.8,76.02 89.88,76.02 86.44,72.58 85.15,72.58 84.61,72.04 84.35,72.04 83.98,71.67 83.98,70.58 v1(83.88,70.47)
  BOTTOM w0.127: v1(176.47,120.85) 176.47,120.78 U9001.F28
INT_EDP_TXP1_C: length 3.2
  TOP w0.102: C3078.1 69.82,66.56 69.73,66.56 69.45,66.28 68.12,66.28 67.97,66.13 U3007.14
INT_EDP_TXP2: length 151.5
  TOP w0.102: v1(75.6,68.16) 75.25,68.16 74.91,67.82 74.91,67.57 74.61,67.27 v6(74.12,67.27) 73.04,67.27 C3080.2
  IN3 w0.089: v1(181.42,122.08) 181.36,122.08 181.18,121.9 181.18,121.71 183.16,119.73 183.16,102.94 182.74,102.52 182.28,102.52 181.97,102.21 181.97,101.39 179.09,98.5 179.09,94.82 161.6,77.33 102.61,77.33 101.92,76.63 98.04,76.63 97.44,76.04 95.45,76.04 92.95,73.54 91.96,73.54 88.77,70.35 88.77,69.88 88.41,69.52 87.84,69.52 86.7,68.38 76.66,68.38 76.46,68.58 76.02,68.58 v1(75.6,68.16)
  BOTTOM w0.079: v1(181.42,122.08) 181.16,121.82 181.16,121.7 180.96,121.5 179.86,121.5 179.74,121.63 179.27,121.63 179.15,121.5 179.15,121.32 179.22,121.24 U9001.A29
INT_EDP_TXP2_C: length 5.3
  TOP w0.102: U3007.16 67.9,66.93 68.01,67.05 68.54,67.05 69.15,67.65 71.68,67.65 C3080.1
INT_EDP_TXP3: length 151.4
  TOP w0.102: v1(71.66,68.67) 71.41,68.92 71.18,68.92 71.03,68.78 C3082.2
  IN3 w0.089: v1(71.66,68.67) 71.72,68.73 72.75,68.73 73.4,69.38 75.29,69.38 75.58,69.67 76.48,69.67 77.19,68.96 86.39,68.96 88.16,70.73 88.29,70.73 92.2,74.64 92.82,74.64 94.81,76.62 97.2,76.62 97.79,77.22 101.67,77.22 102.48,78.02 161.42,78.02 178.51,95.11 178.51,98.92 181.25,101.66 181.25,104.04 181.72,104.52 182.2,104.52 182.56,104.88 182.56,105.66 182.02,106.19 182.02,119.58 181.37,120.23 v1(181.37,120.56)
  BOTTOM w0.079: v1(181.37,120.56) 181.24,120.69 181.24,120.93 180.89,121.27 179.93,121.27 179.55,120.89 178.39,120.89 178.09,120.6 U9001.C28
INT_EDP_TXP3_C: length 3.3
  TOP w0.102: C3082.1 69.87,68.92 v6(69.25,68.92) 68.79,68.92 68.1,68.24 67.93,68.24 67.82,68.13 U3007.19
INT_HPD_PIN13: length 2.3
  TOP w0.114: U3007.13 v1(68.59,65.73)
  BOTTOM w0.114: R3055.1 68.33,65.75 68.34,65.73 v1(68.59,65.73)
INV_PWM: length 255.7
  TOP w0.114: v1(205.17,13.39) 206.61,14.82 210.48,14.82 221.17,25.52 227.45,25.52 233.98,32.04 235.76,32.04 237.94,31.14 238.99,30.93 240.07,30.93 241.13,31.14 241.4,31.26 245.3,31.26 245.73,30.82 250.98,30.82 251.81,31.65 R908.2 251.81,33.61 252.61,34.41 255.05,34.41 255.35,34.11 255.86,34.11 255.87,34.1 257.1,34.1 257.31,34.31 257.31,34.37 257.35,34.41 257.35,37.29 R3051.1 257.21,38.18 257.21,38.83 258.22,39.84 258.22,41.25 257.86,41.62 U3010.4
  IN1 w0.076: v1(72.7,49.24) 73.91,50.45 89.08,50.45 93.84,45.68 94.17,45.68 99.71,40.14 99.71,31.82 101.34,30.19 101.34,24.81 103.8,22.34 104.82,22.34 112.35,14.81 178.18,14.81 182.1,18.73 200.65,18.73 204.63,14.75 204.63,13.93 v1(205.17,13.39)
  BOTTOM w0.114: R3021.1 56.22,49.24 55.79,48.81 55.79,46.19 56.52,45.46 70.68,45.46 72.7,47.49 v1(72.7,49.24)
IO_VDD: length 10.2
  IN1 w0.508: v1(261.09,8.65) 260.26,9.49 258.22,9.49 257.7,10.01 v1(257.7,10.67) 256.26,9.23 255.15,9.23 254.93,9.01 v1(254.93,8.65)
  BOTTOM w0.254: R9504.1 v1(257.7,10.67) ; CON9500.15 v1(254.93,8.65)
ISET_EN: length 5.7
  TOP w0.076: 271.94,26 271.91,26 271.62,26.29 271.16,26.29 v3(270.84,25.97)
  TOP w0.114: R6082.2 273.49,24.4 272.85,25.03 TP22040.1 272.29,25.64 271.94,26
  BOTTOM w0.102: U6001.E9 v3(270.84,25.97)
ISH_ACCEL_INT1#: length 7.4
  BOTTOM w0.102: U9002.BF35 262.55,71.89 263.91,73.24 263.95,73.24 264.65,73.94 265.11,73.94
  BOTTOM w0.114: R9352.1 267.62,74.62 v1(267.57,74.56) 267.19,74.18 266.09,74.18 265.85,73.94 265.11,73.94
ISH_ALS_INT#: length 411.9
  TOP w0.102: 263.94,73.75 264.19,74
  TOP w0.114: v3(272.37,76.46) 272.29,76.38 269.44,76.38 269.28,76.54 268.97,76.54 268.67,76.24 268.52,76.24 268.35,76.07 R9353.1 267.09,75.46 265.74,74.11 264.78,74.11 264.75,74.08 264.27,74.08 264.19,74 ; 263.94,73.75 263.89,73.7 263.89,73.24 262.92,72.28 262.21,72.28 261.21,71.28 260.73,71.28 260.4,70.94 259.91,70.45 v1(259.75,70.45)
  IN1 w0.076: v1(285.71,26.89) 285.53,26.89 272.29,13.65 267.81,13.65 267.35,13.2 265.14,13.2 264.69,13.65 261.38,13.65 256.8,18.22 256.8,22.6 254.64,24.75 252.76,24.75 249.39,28.12 233.27,28.12 229.29,24.14 219.8,24.14 214.27,18.61 205.44,18.61 201.86,22.19 191.55,22.19 191,21.64 180.63,21.64 179.4,20.41 137.19,20.41 136.05,21.55 107.49,21.55 103.97,25.08 103.97,29.18 100.86,32.29 100.86,42.45 96.43,46.88 94.26,46.88 89.3,51.84 80.98,51.84 80.54,52.29 69.04,52.29 68.05,51.29 63.28,51.29 62.59,51.98 60.33,51.98 57.8,54.51 57.8,57.33 50.12,65.01 46.72,65.01 46.2,65.53 44,65.53 42.49,67.05 39.58,67.05 37.74,68.89 37.74,71.08 35.85,72.98 35.85,77.1 v1(35.52,77.43)
  BOTTOM w0.102: v1(259.75,70.45) 259.99,70.69 U9002.BA33
  BOTTOM w0.114: U3011.4 18.94,71.58 25.31,77.94 34.98,77.94 35.49,77.43 v1(35.52,77.43) ; v1(285.71,26.89) 285.71,27.81 286.34,28.44 286.34,30.06 287.35,31.07 287.35,33.58 286.56,34.37 286.56,35.66 284.65,37.57 283.99,37.57 283.31,38.25 283.31,41.57 284.53,42.79 284.53,43.75 284.16,44.12 284.16,48.76 283.06,49.86 283.06,52.75 283.67,53.35 283.67,54.04 282.66,55.06 282.4,55.06 280.23,57.23 280.23,61.08 282.99,63.84 282.99,65.58 280.86,67.71 280.86,69.71 275.88,74.68 274.71,74.68 272.94,76.46 v3(272.37,76.46)
ISH_I2C0_COLOR_SCL: length 127.1
  TOP w0.114: U6004.6 236.07,5.3 235.36,4.59 214.99,4.59 v1(209.71,9.87)
  IN3 w0.089: v1(209.46,16.6) 209.46,17.85 216.39,24.78 233.44,24.78 239.26,30.6 250.07,30.6 251.72,32.25 253.48,32.25 253.92,32.69 258.6,32.69 v1(258.91,32.37)
  BOTTOM w0.114: R9349.1 261.17,54.43 261.63,53.96 R9354.1 261.64,53.33 261.64,52.56 262.41,51.78 262.67,51.78 265.81,48.64 266,48.64 266.47,48.17 268.62,48.17 269.17,47.62 269.17,47.19 267.46,45.48 266.64,45.48 265.3,44.13 263.97,44.13 262.01,42.17 262.01,41.1 262.69,40.42 262.69,38.31 262.06,37.67 262.06,36.41 261.54,35.9 261.54,35.39 258.91,32.76 v1(258.91,32.37) ; v1(209.71,9.87) 209.99,10.15 209.99,13.88 209.46,14.42 v1(209.46,16.6)
ISH_I2C0_COLOR_SDA: length 126.9
  TOP w0.114: U6004.7 236.15,4.95 235.56,4.36 214.59,4.36 v1(209.71,9.23)
  IN3 w0.089: v1(259.54,32.37) 259.16,31.99 257.1,31.99 256.92,31.81 251.53,31.81 250.14,30.42 239.33,30.42 233.51,24.6 217.2,24.6 210.04,17.44 v1(210.04,16.96)
  BOTTOM w0.114: v1(209.71,9.23) 210.22,9.74 210.22,14.04 210.04,14.21 v1(210.04,16.96) ; R9350.1 261.78,54.7 261.78,54.57 R9355.1 262.39,53.2 263.05,52.54 263.05,51.78 265.96,48.87 266.1,48.87 266.56,48.4 268.71,48.4 269.4,47.72 269.4,47.09 267.56,45.25 266.74,45.25 265.39,43.91 264.07,43.91 262.24,42.08 262.24,41.2 262.92,40.51 262.92,38.21 262.29,37.58 262.29,36.24 261.77,35.72 261.77,35.16 259.54,32.93 v1(259.54,32.37)
ISH_I2C1_COMBO_SCL: length 7.7
  BOTTOM w0.102: U9002.AH47 260.87,61.57 261.11,61.34 261.11,60.98 261.86,60.24 261.86,58.64
  BOTTOM w0.114: R9362.2 263.4,55.56 262.34,56.62 R9364.1 262.34,57.52 261.86,58 261.86,58.64
ISH_I2C1_COMBO_SDA: length 7.8
  BOTTOM w0.102: 261.53,58.26 261.53,58.83 260.99,59.36 260.99,60.43 260.74,60.68 260.74,60.9 260.85,61.01 U9002.AH48
  BOTTOM w0.114: R9363.2 262.6,54.85 261.63,55.81 R9365.1 261.83,56.7 261.83,57.7 261.53,58 261.53,58.26
ITP_PMODE: length 286.2
  TOP w0.114: v1(202.4,15.1) 202.73,15.43 202.73,16.09 205.82,19.18 211.83,19.18 220.38,27.73 226.32,27.73 230.25,31.66 230.25,33.98 229.54,34.69 229.54,37.14 230.28,37.88 230.28,58.37 228.91,59.75 228.91,62.27 229.45,62.81 229.45,70.53 230.45,71.53 230.45,72.59 231.41,73.55 231.41,75.78 232.03,76.4 232.03,79.58 234.55,82.1 239.76,82.1 243.03,78.83 243.58,78.83 244.25,79.5 v1(244.25,79.97)
  IN1 w0.076: v1(202.4,15.1) 202.4,15.9 200.34,17.96 182.4,17.96 178.33,13.88 111.97,13.88 104.66,21.2 103.08,21.2 102.17,20.28 101.51,20.28 101.29,20.5 v1(100.32,20.5)
  BOTTOM w0.102: U9002.AL3 246.04,77.83 245.2,78.67 245.2,78.7
  BOTTOM w0.114: v1(244.25,79.97) 244.25,79.65 245.2,78.7 ; R402.1 81.19,70.83 80.23,69.87 CON400.46 80.23,67.09 80.01,66.87 74.3,66.87 72.93,65.5 72.93,61.47 76.14,58.26 77.5,58.26 78.68,57.07 78.68,53.98 83.5,49.15 88.89,49.15 91.94,46.1 91.94,43.72 98.38,37.29 98.38,26.77 100.32,24.83 v1(100.32,20.5)
JSENSE: length 3.9
  TOP w0.114: v1(345.95,2.83) 345.7,3.09 Q3600.3 345.26,3.66 344.77,4.15 R3603.2 344.77,4.73 344.57,4.93 344.57,4.94 344.45,5.06 344.44,5.06 343.95,5.55 R3607.2
JTAG_SEL: length 16.6
  TOP w0.114: v1(204.11,106.4) 203.94,106.23 201.26,106.23 200.88,105.86 200.88,103.94 201.56,103.26 201.56,102.28 v1(199.19,99.91)
  BOTTOM w0.114: TP2007.1 R2079.1 195.87,97.88 196.12,98.13 197.13,98.13 198.91,99.91 v1(199.19,99.91)
  BOTTOM w0.127: U2000.AK11 204.08,106.4 v1(204.11,106.4)
JTAG_TCK: length 10
  BOTTOM w0.114: R2082.1 197.14,100.43 196.88,100.17 196.12,100.17 v1(195.74,99.79)
  BOTTOM w0.127: U2000.AM10 201.62,105.5 200.34,105.5 198.91,104.07 198.91,102.44 R2082.1
JTAG_TDI: length 8.6
  BOTTOM w0.114: R2070.1 196.6,101.78 v1(196.6,101.51)
  BOTTOM w0.127: R2070.1 198.53,103.71 198.53,105.04 198.65,105.16 199.66,106.17 200.74,106.17 200.96,106.38 201.66,106.38 U2000.AM11
JTAG_TDO: length 4.7
  BOTTOM w0.127: U2000.AP12 200,107.12 199.35,107.12 197.98,105.75 TP2004.1
JTAG_TMS: length 6.5
  BOTTOM w0.127: R2071.1 v1(195.61,104.87) 195.99,105.25 196.76,105.25 197.02,105.51 198.12,105.51 199.41,106.8 U2000.AP11
JTAG_TRST#: length 7
  BOTTOM w0.127: U2000.AN11 201.03,106.8 200.64,106.41 199.54,106.41 198,104.87 R2072.1 196.76,104.87 196.5,104.61 v1(196.5,103.29)
KBC_PWR_ON: length 90.2
  TOP w0.127: v1(275.26,36.54) 275.26,40.62 277.37,42.74 277.37,44.24 282.41,49.27 287.45,49.27 289.33,51.14 289.33,55.06 294.22,59.96 299.45,59.96 300.43,58.98 302.53,58.98 302.99,58.52 306.73,58.52 306.91,58.33 307.37,58.33 307.6,58.56 307.6,59.14 307.85,59.39 308.26,59.39 308.27,59.4 308.98,59.4 R9286.2 ; PR22010.2 270.68,37.29 v1(271.43,36.54) ; v3(269.54,27.92) 269.94,27.52 272,27.52 272.38,27.9 273.3,27.9 274.5,29.1 275.44,29.1 R6040.1 276.07,28.46 277.1,28.46 277.5,28.06 278.09,28.06 278.31,28.28 278.31,29.58 278.89,30.16 278.89,30.18 v1(279.05,30.34) ; v1(282.94,30.04) 282.47,30.5 PR22007.2
  IN1 w0.127: v1(275.26,36.54) 274.85,36.13 271.84,36.13 v1(271.43,36.54)
  IN2 w0.127: v3(269.54,27.92) 270.06,27.4 271.81,27.4 272.07,27.65 272.07,30.06 271.18,30.95 271.18,33.62 270.92,33.87 270.92,36.03 v1(271.43,36.54)
  IN4 w0.127: v1(282.94,30.04) 282.86,30.11 279.76,30.11 279.53,30.34 v1(279.05,30.34)
  BOTTOM w0.114: U6001.G7 v3(269.54,27.92)
KBD_SHARE_LED#: length 46.3
  TOP w0.114: R18076.1 246.41,51.78 246.79,51.4 Q9040.5 246.79,50.46 246.92,50.33 247.38,50.33 247.63,50.08 247.63,48.33 246.62,47.32 246.62,46.44 v1(247.58,45.48) 247.58,45.24 248.17,44.64 R17953.1 248.17,42.57 v1(248.06,42.46)
  IN1 w0.076: v1(248.06,42.46) 248.06,40.96 251.07,37.95 254.2,37.95 256.19,35.96 257.16,35.96 258.89,34.23 262.9,34.23 264.18,32.95 264.18,32.02 263.46,31.29 263.46,30.8 263.71,30.55 264.17,30.55 264.37,30.34 268.84,30.34 269.15,30.04 269.15,27.65 269.65,27.14 270.92,27.14 271.45,26.62 v3(271.49,26.62)
  BOTTOM w0.114: U6001.F10 v3(271.49,26.62)
KBD_SHARE_LED#_R: length 13.4
  TOP w0.114: Q9040.6 246.29,51.26 245.9,51.65 245.9,52.54 246.04,52.68 R18076.2 v1(246.41,53.56) 245.17,54.8 241.61,54.8 240.7,55.72 238.93,55.72 238.67,55.45 R6803.2 R6813.1
KBL_DET#: length 182
  TOP w0.114: v1(194.77,50) 194.83,49.95 CON6801.3
  IN2 w0.089: v1(178.59,19.52) 180.55,19.52 181.65,20.63 191.11,20.63 191.76,21.28 199,21.28 199.19,21.08 205.47,21.08 205.95,20.61 214.34,20.61 215.84,22.11 218.21,22.11 222.98,26.88 231.99,26.88 234.11,29 236.47,29 237.78,30.31 243.92,30.31 246.08,32.48 246.08,33.21 246.01,33.29 246.01,33.85 247.68,35.52 248.83,35.52 249.74,36.43 249.74,36.71 253.55,40.52 254.25,40.52 254.43,40.69 255.83,40.69 256.73,41.59 256.73,44.45 257.66,45.38 257.66,46.73 259.61,48.67 259.61,51.54 261.02,52.95 261.02,53.07 267.75,59.81 267.75,60.16 267.62,60.29 267.62,61.3 268.26,61.94 268.26,65.04 267.48,65.81 267.48,67.98 265.08,70.38 265.08,71.57 262.72,73.93 v3(262.72,74.92)
  IN4 w0.076: v1(178.59,19.52) 178.59,21.43 183.16,26 185.7,26 189.66,29.95 189.66,43.76 190.66,44.76 190.66,50.1 191,50.45 194.33,50.45 v1(194.77,50)
  BOTTOM w0.102: v3(262.72,74.92) 262.52,74.72 262.52,74.36 261.48,73.32 U9002.BF32
  BOTTOM w0.114: R9210.1 268.44,77.84 267.77,77.84 267.36,77.43 267.36,77.21 266.96,76.81 266.84,76.81 266.75,76.72 266.39,76.72 C9216.2 266.33,76.29 266.05,76.01 266.04,76.01 265.99,75.96 265.13,75.96 264.19,75.02 262.82,75.02 v3(262.72,74.92)
KSI0: length 40.6
  IN1 w0.076: v1(238.92,41.11) 239.15,41.34 241.46,41.34 241.7,41.1 241.7,40.29 244.33,37.66 244.33,36.97 245,36.3 245.25,36.05 245.38,35.92 245.99,35.92 246.82,35.09 252.22,35.09 258.01,29.3 258.78,29.3 260.1,27.98 261.22,27.98 261.69,27.51 261.69,26.38 262.44,25.63 262.44,24.83 262.97,24.3 264.55,24.3 265.31,23.54 v1(265.31,23.08)
  BOTTOM w0.114: D6801.6 237.95,40.79 238.13,40.61 238.42,40.61 v1(238.92,41.11) 238.92,41.24 239.68,42 RP6800.1 ; U6001.A2 265.35,23.08 v1(265.31,23.08)
KSI1: length 44.3
  IN1 w0.076: v1(238.92,41.9) 239.33,41.49 241.59,41.49 241.87,41.21 242.73,41.21 243.03,40.91 243.03,39.38 244.78,37.64 245.67,37.64 247.91,35.4 252.86,35.4 255.5,32.76 256.27,32.76 256.71,32.31 256.71,31.57 257.38,30.9 260.36,30.9 261.27,29.99 261.27,28.36 261.99,27.64 261.99,26.57 263.96,24.6 264.67,24.6 266.19,23.09 v1(266.19,22.82)
  BOTTOM w0.114: RP6800.2 239.66,42.64 v1(238.92,41.9) 238.31,42.51 236.87,42.51 236.46,42.09 D6801.3 ; v1(266.19,22.82) 266.19,23.04 266.62,23.47 U6001.A3
KSI2: length 43.4
  IN1 w0.076: v1(267.04,22.93) 266.36,23.61 265.88,23.61 264.74,24.75 264.03,24.75 262.15,26.63 262.15,27.7 261.42,28.42 261.42,30.09 260.46,31.05 257.45,31.05 256.86,31.64 256.86,32.37 256.33,32.91 255.57,32.91 252.93,35.55 252.2,35.55 252.2,35.55 247.97,35.55 245.73,37.79 244.84,37.79 243.67,38.97 243.19,39.45 243.19,40.97 242.79,41.37 241.93,41.37 240.08,43.22 238.94,43.22 v1(238.92,43.25)
  BOTTOM w0.114: U6001.A4 267.27,23.36 267.04,23.13 v1(267.04,22.93) ; RP6800.3 238.94,43.27 v1(238.92,43.25) 238.41,42.74 238.06,42.74 237.54,43.26 D6802.6
KSI3: length 44.3
  IN1 w0.076: v1(265.31,22.44) 264.79,22.96 264.42,22.96 263.79,23.6 263.38,23.6 262.29,24.69 262.29,25.37 258.51,29.15 257.94,29.15 252.15,34.94 246.75,34.94 245.93,35.77 245.32,35.77 244.89,36.19 244.18,36.91 244.18,37.59 241.24,40.53 240.94,40.53 v1(240.57,40.91)
  BOTTOM w0.114: U6001.B3 266.3,24.03 266.3,23.56 265.74,23 265.74,22.87 v1(265.31,22.44) ; v1(240.57,40.91) 240.82,41.16 240.82,43.78 240.7,43.91 RP6800.4 238.94,43.91 238.61,44.24 238.61,44.29 237.98,44.92 236.69,44.92 236.33,44.56 D6802.3
KSI4: length 55
  IN1 w0.076: v1(242.5,40.85) 242.5,39.7 244.72,37.49 245.61,37.49 247.85,35.24 252.31,35.24 258.05,29.5 258.79,29.5 260.16,28.13 261.28,28.13 261.84,27.57 261.84,26.51 263.9,24.45 264.61,24.45 265.68,23.38 265.68,22.7 v1(266.19,22.19)
  IN2 w0.089: v1(240.7,45.68) 241.05,46.04 242.91,46.04 244.19,44.76 244.19,41.68 243.35,40.85 v1(242.5,40.85)
  BOTTOM w0.114: v1(266.19,22.19) 266.61,22.61 266.61,23.11 266.95,23.45 266.95,24.03 U6001.B4 ; D6800.6 236.88,45.92 236.73,46.06 236.73,47.39 236.96,47.61 238.82,47.61 239.64,46.8 240.98,46.8 241.21,46.57 241.21,46.19 v1(240.7,45.68) 240.7,45.3 241.46,44.54 RP6800.6
KSI5: length 49.9
  IN1 w0.076: v3(266.29,24.67) 265.79,25.17 265.79,26.96 264.55,28.21 262.64,28.21 262.03,28.82 262.03,31.84 262.26,32.07 262.26,32.37 262.05,32.59 261.33,33.3 257.73,33.3 257.02,34.01 255.33,34.01 253.05,36.28 253.05,36.41 252.43,37.04 250.44,37.04 249.56,36.16 248.8,36.16 247.19,37.77 247.19,39.45 247.17,39.46 244.28,42.36 244.28,43.89 243.88,44.29 243.49,44.29 v1(243.11,43.91)
  BOTTOM w0.114: D6800.3 236.24,47.22 236.86,47.84 238.92,47.84 239.53,47.23 v1(240.58,47.23) 241.43,47.23 243.62,45.05 243.62,44.41 v1(243.11,43.91) RP6800.7 ; U6001.C3 v3(266.29,24.67)
KSI6: length 47.8
  IN1 w0.076: v1(243.75,43.91) 244.13,43.52 244.13,42.29 247.03,39.38 247.03,37.71 248.74,36.01 249.63,36.01 250.49,36.87 252.38,36.87 252.9,36.35 252.9,36.22 255.26,33.86 256.95,33.86 257.85,32.97 260.74,32.97 261.18,32.53 261.18,32.01 261.88,31.31 261.88,28.61 262.6,27.89 262.6,27.54 262.82,27.32 264.12,27.32 265.61,25.83 265.61,24.71 266.1,24.22 266.49,24.22 v3(266.94,24.67)
  BOTTOM w0.114: U6001.C4 v3(266.94,24.67) ; RP6800.8 242.48,43.27 242.6,43.4 243.24,43.4 v1(243.75,43.91) 243.87,44.03 243.87,45.18 240.75,48.3 239.17,48.3 239.01,48.46 D6803.6
KSI7: length 54
  TOP w0.114: v1(232.82,48.94) 232.88,48.99 CON6800.20
  IN1 w0.076: v3(267.59,24.67) 266.95,24.03 266.03,24.03 265.46,24.61 265.46,25.69 264,27.14 262.72,27.14 262.45,27.41 262.45,27.83 261.73,28.55 261.73,30.66 260.38,32.01 258.44,32.01 257.22,33.23 255.68,33.23 252.75,36.16 252.75,36.29 252.53,36.5 250.34,36.5 249.69,35.85 248.67,35.85 246.88,37.64 246.88,39.08 244.09,41.87 v1(243.75,41.87) 243.36,42.25 241.73,42.25 239.19,44.79 237.52,44.79 235.97,46.34 234.7,46.34 233.33,47.72 233.33,48.43 v1(232.82,48.94)
  BOTTOM w0.114: RP6800.9 242.48,42.64 242.73,42.38 243.24,42.38 v1(243.75,41.87) ; v1(232.82,48.94) 232.87,48.99 C6815.2 ; U6001.C5 v3(267.59,24.67)
KSI_D_0: length 6.4
  TOP w0.114: v1(235.74,40.6) 235,40.6 v1(234.98,40.59) ; v1(232.82,41.94) 232.88,41.99 CON6800.34
  IN4 w0.076: v1(232.82,41.94) 234.17,40.59 v1(234.98,40.59)
  BOTTOM w0.114: D6801.1 235.19,40.79 v1(234.98,40.59) ; C6801.2 232.89,41.87 v1(232.82,41.94)
KSI_D_1: length 11.4
  TOP w0.114: v1(237.65,41.11) v1(238.28,41.11) ; v1(232.19,42.94) 232.61,43.36 233.18,43.36 233.31,43.49 CON6800.31
  IN4 w0.076: v1(232.19,42.94) 232.74,42.38 235.49,42.38 236.76,41.11 v1(238.28,41.11)
  BOTTOM w0.114: C6803.2 232.14,42.89 v1(232.19,42.94) ; v1(238.28,41.11) 237.95,41.44 D6801.5
KSI_D_2: length 6.2
  TOP w0.114: v1(235.87,42.51) 235.6,42.51 v1(234.98,43.13) ; v1(232.82,42.94) 232.88,42.99 CON6800.32
  IN4 w0.076: v1(234.98,43.13) 234.79,42.94 v1(232.82,42.94)
  BOTTOM w0.114: v1(234.98,43.13) 235.11,43.26 D6802.1 ; v1(232.82,42.94) 232.87,42.89 C6805.2
KSI_D_3: length 9.4
  TOP w0.114: CON6800.30 232.93,43.99 v1(232.75,43.8)
  IN4 w0.076: v1(238.28,43.27) 237.52,43.27 236.63,44.16 234.39,44.16 234.16,43.94 232.93,43.94 232.75,43.75 v1(232.75,43.8)
  BOTTOM w0.114: D6802.5 237.73,43.91 238.28,43.35 v1(238.28,43.27) ; v1(232.75,43.8) 232.85,43.91 C6807.2
KSI_D_4: length 9.1
  TOP w0.114: v1(232.19,41.94) 232.74,42.49 CON6800.33
  IN3 w0.089: v1(232.19,41.94) 232.63,42.38 233.08,42.38 233.97,43.27 233.97,44.81 v1(234.98,45.82)
  BOTTOM w0.114: v1(234.98,45.82) 235.08,45.92 D6800.1 ; v1(232.19,41.94) 232.13,41.87 C6809.2
KSI_D_5: length 11.5
  TOP w0.114: CON6800.22 232.88,47.99 v1(232.82,47.94)
  IN4 w0.076: v1(238.28,45.73) 237.83,46.19 234.57,46.19 v1(232.82,47.94)
  BOTTOM w0.114: v1(232.82,47.94) 232.86,47.97 C6811.2 ; D6800.5 237.65,46.57 237.9,46.83 238.54,46.83 239.05,46.32 v1(239.05,45.81) 238.97,45.73 v1(238.28,45.73)
KSI_D_6: length 7.7
  TOP w0.114: CON6800.21 232.74,48.49 v1(232.19,47.94)
  IN4 w0.076: v1(235.34,48.43) 235.12,48.21 234.35,48.21 234.08,48.48 232.73,48.48 v1(232.19,47.94)
  BOTTOM w0.114: v1(232.19,47.94) 232.15,47.97 C6813.2 ; D6803.1 235.37,48.46 v1(235.34,48.43)
KSI_D_8: length 7.2
  TOP w0.114: CON6800.37 232.74,40.49 v1(232.19,39.94)
  IN1 w0.076: v1(232.19,39.94) 232.73,40.48 233.59,40.48 234.35,41.24 v1(234.98,41.24)
  BOTTOM w0.114: v1(232.19,39.94) 232.09,39.84 C6817.2 ; D6801.2 235.19,41.44 v1(234.98,41.24)
KSI_D_9: length 17.8
  TOP w0.114: v1(232.19,49.94) 232.74,50.49 CON6800.17
  IN4 w0.076: v1(238.28,41.87) 239.62,43.21 239.62,44.51 238.82,45.31 238.82,46.59 235.03,50.38 232.63,50.38 v1(232.19,49.94)
  BOTTOM w0.114: v1(232.19,49.94) 232.12,50 C6819.2 ; D6801.4 238.07,42.09 v1(238.28,41.87)
KSI_D_10: length 8.2
  TOP w0.114: v1(232.19,40.94) 232.74,41.49 CON6800.35
  IN3 w0.089: v1(234.98,43.78) 234.35,43.14 234.35,42.51 233.33,41.49 232.74,41.49 v1(232.19,40.94)
  BOTTOM w0.114: v1(232.19,40.94) 232.11,40.86 C6821.2 ; v1(234.98,43.78) 235.11,43.91 D6802.2
KSI_D_11: length 13
  TOP w0.114: v1(232.82,49.94) 232.88,49.99 CON6800.18
  IN4 w0.076: v1(232.82,49.94) 235.26,49.94 238.67,46.53 238.67,45.3 238.28,44.92 v1(238.28,43.96)
  BOTTOM w0.114: v1(238.28,43.96) 237.68,44.56 D6802.4 ; v1(232.82,49.94) 232.89,50 C6823.2
KSI_D_12: length 21.2
  TOP w0.114: CON6800.36 232.88,40.99 v1(232.82,40.94)
  IN4 w0.076: v1(232.82,40.94) 233.51,40.94 234.25,40.2 240.57,40.2 241.23,40.86 v1(241.23,40.91)
  BOTTOM w0.114: C6826.2 232.9,40.86 v1(232.82,40.94) ; D6800.2 236.25,46.57 236.51,46.32 236.51,45.56 236.91,45.15 238.07,45.15 238.35,44.87 240.75,44.87 241.05,44.57 241.05,41.09 v1(241.23,40.91)
KSI_D_13: length 17.9
  TOP w0.114: v1(232.19,48.94) 232.74,49.49 CON6800.19
  IN1 w0.076: v1(240.7,46.32) 239.33,44.95 237.62,44.95 235.87,46.7 235.87,47.21 235.34,47.74 234.83,47.74 233.2,49.37 232.62,49.37 v1(232.19,48.94)
  BOTTOM w0.114: D6800.4 238.65,47.22 239.43,46.45 240.57,46.45 v1(240.7,46.32) ; v1(232.19,48.94) 232.14,48.99 C6827.2
KSI_D_14: length 13.9
  TOP w0.114: v1(232.82,39.94) 232.88,39.99 CON6800.38
  IN3 w0.089: v1(235.36,49.09) 234.95,48.67 234.95,48.18 235.54,47.59 235.54,43.07 233.71,41.24 233.71,40.83 v1(232.82,39.94)
  BOTTOM w0.114: v1(232.82,39.94) 232.92,39.84 C6828.2 ; D6803.2 235.39,49.11 v1(235.36,49.09)
KSO0: length 57.7
  TOP w0.114: CON6800.41 232.74,38.49 v1(232.19,37.94)
  IN1 w0.076: v1(267.39,19.85) 266.81,19.85 266.25,20.41 262.81,20.41 261.91,21.31 261.91,23.26 261.07,24.1 261.07,24.86 258.15,27.79 257.58,27.79 255.69,29.68 254.26,29.68 252.57,31.37 251.19,31.37 250.51,32.04 248.47,32.04 248.33,31.9 247.87,31.9 247.38,31.41 245.41,31.41 244.91,31.9 239.38,31.9 232.98,38.31 232.56,38.31 v1(232.19,37.94)
  BOTTOM w0.114: v1(232.19,37.94) 232.57,37.56 C6802.2 ; U6001.B5 267.6,24.03 267.6,23.33 267.47,23.21 267.47,22.65 267.01,22.19 267.01,21.27 267.39,20.9 v1(267.39,19.85) 267.93,19.31 267.93,17.85 268.54,17.24 268.54,16.89 268.24,16.59 JCN9000.17
KSO1: length 61.3
  TOP w0.114: CON6800.23 232.74,47.49 v1(232.19,46.94)
  IN1 w0.076: v1(267.44,21.93) 267.44,23.26 266.88,23.81 266.03,23.81 264.94,24.91 264.16,24.91 262.3,26.77 262.3,27.76 261.58,28.49 261.58,30.6 260.32,31.85 258.38,31.85 257.16,33.07 255.62,33.07 252.99,35.7 248.61,35.7 246.72,37.59 246.72,38.02 244.14,40.6 243.86,40.6 242.94,41.52 242,41.52 239.89,43.63 239.2,43.63 238.41,44.41 237.27,44.41 235.49,46.19 233.74,46.19 233.43,46.5 232.62,46.5 v1(232.19,46.94)
  BOTTOM w0.114: JCN9000.18 268.74,16.58 268.77,16.6 268.77,17.33 268.15,17.95 268.15,19.47 267.9,19.73 267.9,20.89 267.44,21.35 v1(267.44,21.93) 268.13,21.93 268.34,22.14 268.34,23.33 268.25,23.42 268.25,24.03 U6001.B6 ; C6804.2 232.17,46.95 v1(232.19,46.94)
KSO2: length 56.9
  TOP w0.114: v1(232.82,38.94) 232.88,38.99 CON6800.40
  IN1 w0.076: v1(268.98,20.44) 268.96,20.42 266.45,20.42 266.31,20.56 262.87,20.56 262.06,21.37 262.06,23.33 261.22,24.17 261.22,24.93 258.21,27.94 257.64,27.94 255.75,29.83 254.32,29.83 251.96,32.2 248.41,32.2 248.27,32.06 247.71,32.06 247.24,31.59 245.5,31.59 245.03,32.06 239.7,32.06 v1(232.82,38.94)
  BOTTOM w0.114: v1(232.82,38.94) 232.93,38.83 C6806.2 ; JCN9000.20 269.74,18.92 268.98,19.69 v1(268.98,20.44) 268.81,20.62 268.81,23.38 268.9,23.48 268.9,24.03 U6001.B7
KSO3: length 65
  TOP w0.114: v1(232.24,44.19) 232.54,44.49 CON6800.29
  IN1 w0.076: v1(269.55,20.74) 269.48,20.81 267.11,20.81 266.76,21.16 266.34,21.16 266.21,21.03 262.83,21.03 262.37,21.5 262.37,23.45 261.53,24.29 261.53,25.05 258.34,28.25 257.77,28.25 255.85,30.16 254.45,30.16 252.11,32.5 248.22,32.5 248.08,32.36 247.52,32.36 247.25,32.63 246.51,32.63 246.08,33.06 245.33,33.06 244.63,32.36 240.03,32.36 235.95,36.44 235.95,41.43 235.12,42.25 234.47,42.25 233.41,43.32 232.42,43.32 232.24,43.5 v1(232.24,44.19)
  IN2 w0.089: v1(269.24,16.98) 269.91,17.64 269.91,20.39 v1(269.55,20.74)
  BOTTOM w0.114: JCN9000.19 v1(269.24,16.98) ; U6001.B8 269.55,24.03 269.55,23.23 269.41,23.09 269.41,21.77 269.7,21.48 269.7,20.89 v1(269.55,20.74) ; v1(232.24,44.19) 232.24,44.04 232.11,43.91 C6808.2
KSO4: length 53.3
  TOP w0.114: CON6800.27 232.73,45.49 v1(232.19,44.95)
  IN1 w0.076: v1(234.98,44.54) 237.22,42.31 237.22,41.66 238.58,40.3 240.57,40.3 245.26,35.61 245.87,35.61 246.69,34.79 250.78,34.79 254.77,30.8 256.08,30.8 257.88,29 258.17,29 258.45,29 262.14,25.31 262.14,24.62 263.79,22.98 264.19,22.98 264.36,22.81 264.73,22.81 264.94,22.6 264.94,22.29 265.16,22.07 265.58,22.07 265.84,21.81 266.73,21.81
  IN1 w0.089: 266.73,21.81 266.98,21.81 267.23,21.56 267.6,21.56 269.15,23.11 269.15,24.27 v3(269.54,24.67)
  IN4 w0.076: v1(232.19,44.95) 232.59,44.54 v1(234.98,44.54)
  BOTTOM w0.114: U6001.C7 v3(269.54,24.67) ; C6810.2 232.16,44.92 v1(232.19,44.95)
KSO5: length 53.4
  TOP w0.114: v1(232.19,38.94) 232.74,39.49 CON6800.39
  IN1 w0.076: v1(232.19,38.94) 232.56,39.31 232.98,39.31 235.77,36.51 235.77,36.41 239.97,32.21 245.61,32.21 246.02,32.62 246.29,32.62 246.46,32.45 247.2,32.45 247.44,32.21 248.2,32.21 248.34,32.35 252.05,32.35 254.41,29.99 255.81,29.99 257.7,28.09 258.27,28.09 261.38,24.99 261.38,24.23 262.21,23.39 262.21,21.44 262.86,20.79 v1(266.61,20.79)
  IN2 w0.089: v1(266.61,20.79) 266.86,21.05 266.86,22.21 267.49,22.84 267.49,23.92 v3(268.24,24.67)
  BOTTOM w0.114: C6812.2 231.55,38.3 v1(232.19,38.94) ; U6001.C6 v3(268.24,24.67)
KSO6: length 56
  TOP w0.114: CON6800.25 232.44,46.49 232.21,46.26 v1(232.21,46.22)
  IN1 w0.076: v1(232.21,46.22) 232.21,45.91 232.69,45.43 232.85,45.43 234.09,44.19 234.09,43.28 234.81,42.56 235.69,42.56 238.26,39.99 240.44,39.99 245.13,35.31 245.74,35.31 246.56,34.48 248.7,34.48 249.97,33.21 251.9,33.21 254.61,30.49 255.95,30.49 257.89,28.55 258.46,28.55 261.83,25.18 261.83,24.42 263.56,22.69 263.56,22.3 263.93,21.93 264.8,21.93 265.24,21.49 266.86,21.49 267.1,21.25 268.08,21.25 268.66,21.83 269.92,21.83 270.23,22.14 270.23,24.63 v3(270.19,24.67)
  BOTTOM w0.114: C6814.2 231.93,45.94 v1(232.21,46.22) ; U6001.C8 v3(270.19,24.67)

# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ50: length 88
  TOP w0.102: v1(171.34,37.07) 170.93,36.66 170.93,33.73 171.6,33.05 JDIM1003.225
  IN1 w0.076: v1(170.79,104.62) 170.79,104 171.28,103.51 171.28,100.19 174.43,97.04 174.43,92.9 177.63,89.7 177.63,89.63
  IN1 w0.102: v1(171.34,37.07) 172.14,37.88 172.29,37.88 172.29,37.87 172.43,37.87 172.63,38.07 172.63,38.21 172.63,38.22 172.63,38.36 172.83,38.56 172.97,38.56 172.97,38.56 173.12,38.56 173.31,38.75 173.31,38.9 173.31,38.9 173.31,39.04 173.51,39.24 173.65,39.24 173.66,39.24 173.8,39.24 174,39.44 174,39.58 174,39.58 174,39.73 174.19,39.92 174.34,39.92 174.34,39.92 174.48,39.92 174.68,40.12 174.68,40.26 174.68,40.27 174.68,40.41 175.13,40.86 175.58,40.86 176.4,41.68 176.4,50.73 176.54,50.87 176.79,50.87 177.04,51.12 177.04,54.07 176.75,54.36 176.75,54.6 177.04,54.89 177.04,55.12 176.94,55.22 176.86,55.22 176.75,55.32 176.75,55.55 176.86,55.65 176.94,55.65 177.04,55.75 177.04,55.98 176.94,56.08 176.86,56.08 176.75,56.18 176.75,56.41 176.86,56.51 176.94,56.51 177.04,56.62 177.04,56.84 176.94,56.95 176.86,56.95 176.75,57.05 176.75,57.28 176.86,57.38 176.94,57.38 177.04,57.48 177.04,57.71 176.94,57.81 176.86,57.81 176.75,57.91 176.75,58.14 176.86,58.24 176.94,58.24 177.04,58.34 177.04,58.57 176.94,58.67 176.86,58.67 176.75,58.78 176.75,59 176.86,59.11 176.94,59.11 177.04,59.21 177.04,59.44 176.94,59.54 176.86,59.54 176.75,59.64 176.75,59.87 176.86,59.97 176.94,59.97 177.04,60.07 177.04,60.3 176.94,60.4 176.86,60.4 176.75,60.5 176.75,60.73 176.86,60.83 176.94,60.83 177.04,60.93 177.04,61.16 176.94,61.26 176.86,61.26 176.75,61.37 176.75,61.59 176.86,61.7 176.94,61.7 177.04,61.8 177.04,62.03 176.94,62.13 176.86,62.13 176.75,62.23 176.75,62.46 176.86,62.56 176.94,62.56 177.04,62.66 177.04,62.98 176.75,63.27 176.75,71.21 176.97,71.42 176.97,72.02 176.75,72.24 176.75,74.56 177.63,75.44 177.63,89.63
  BOTTOM w0.076: U9001.P7 170.46,104.3 v1(170.79,104.62)
  BOTTOM w0.102: v1(171.34,37.07) 171.91,37.07 172.18,37.33 172.18,38.13 171.6,38.7 JDIM1002.225
M_B_DQ51: length 88.6
  TOP w0.102: v1(167.8,35.3) 168.36,35.86 JDIM1003.212
  IN1 w0.076: v1(169.88,105.27) 169.45,104.85 169.45,104.28 169.78,103.95 169.78,99.81 173.03,96.56 173.03,96.32
  IN1 w0.102: 173.03,96.32 173.03,92.85 176.03,89.85 176.03,76.04 175.15,75.16 175.15,73.95 175.05,73.85 174.94,73.85 174.83,73.75 174.83,73.52 174.94,73.42 175.08,73.42 175.18,73.31 175.18,73.08 175.08,72.98 174.94,72.98 174.83,72.88 174.83,72.65 174.94,72.55 175.08,72.55 175.18,72.45 175.18,72.22 175.08,72.12 174.94,72.12 174.83,72.02 174.83,71.79 174.94,71.69 175.08,71.69 175.18,71.59 175.18,71.36 175.08,71.26 174.94,71.26 174.83,71.15 174.83,70.93 174.94,70.82 175.08,70.82 175.18,70.72 175.18,70.49 174.83,70.15 174.83,58.6 175.21,58.23 175.21,52.2 174.49,51.49 174.49,42.44 169.6,37.55 169.07,37.55 168.46,36.94 168.46,35.96 v1(167.8,35.3)
  BOTTOM w0.076: v1(169.88,105.27) 169.55,104.95 U9001.R8
  BOTTOM w0.102: JDIM1002.212 168.36,33.39 168.13,33.62 167.62,33.62 167.37,33.87 167.37,34.87 v1(167.8,35.3)
M_B_DQ52: length 90.2
  TOP w0.102: JDIM1003.211 168.1,32.96 167.82,33.24 167.54,33.24 167.19,33.59 167.19,35.96 v1(167.8,36.57)
  IN1 w0.076: v1(169.88,106.57) 169.49,106.19 169.49,105.12 169.3,104.92 169.3,104.21 169.6,103.91 169.6,99.75 172.78,96.57 172.78,96.45
  IN1 w0.102: v1(167.8,36.57) 167.8,36.77 169.07,38.04 169.63,38.04 174.16,42.58 174.16,51.64 174.44,51.92 174.44,54.21 174.54,54.31 174.77,54.31 174.88,54.41 174.88,54.64 174.77,54.74 174.54,54.74 174.44,54.84 174.44,55.07 174.54,55.18 174.77,55.18 174.88,55.28 174.88,55.51 174.77,55.61 174.54,55.61 174.44,55.71 174.44,55.94 174.54,56.04 174.77,56.04 174.88,56.14 174.88,56.37 174.77,56.47 174.54,56.47 174.44,56.57 174.44,56.8 174.54,56.9 174.77,56.9 174.88,57 174.88,57.23 174.77,57.33 174.54,57.33 174.44,57.44 174.44,57.66 174.54,57.77 174.77,57.77 174.88,57.87 174.88,58.1 174.77,58.2 174.54,58.2 174.44,58.3 174.44,70.75 173.87,71.32 173.87,72.1 174.15,72.38 174.15,73.12 173.87,73.4 173.87,74.34 175.7,76.17 175.7,89.85 172.78,92.77 172.78,96.45
  BOTTOM w0.076: v1(169.88,106.57) 169.55,106.25 U9001.R10
  BOTTOM w0.102: JDIM1002.211 168.1,38.62 167.65,38.17 167.65,37.33 167.8,37.17 v1(167.8,36.57)
M_B_DQ53: length 91.2
  TOP w0.102: v1(171.34,35.16) 172.36,36.18 JDIM1003.228
  IN1 w0.076: v1(170.79,106.57) 171.17,106.19 171.17,105.55 171.43,105.29 171.43,104.05 171.79,103.69 171.79,100.11 174.91,96.99 174.91,92.97 178.29,89.59 178.29,89.03
  IN1 w0.102: 178.29,89.03 178.29,75.16 177.68,74.55 177.68,71.9 177.81,71.77 177.96,71.77 178.06,71.67 178.06,71.39 177.96,71.29 177.81,71.29 177.68,71.16 177.68,70.94 177.81,70.81 177.96,70.81 178.06,70.71 178.06,70.43 177.96,70.33 177.81,70.33 177.71,70.22 177.71,69.95 177.81,69.84 177.96,69.84 178.06,69.74 178.06,69.51 177.96,69.41 177.81,69.41 177.71,69.3 177.71,69.08 177.81,68.97 177.96,68.97 178.06,68.87 178.06,68.64 177.96,68.54 177.81,68.54 177.71,68.44 177.71,68.21 177.81,68.11 177.96,68.11 178.06,68.01 178.06,67.78 177.96,67.68 177.81,67.68 177.71,67.58 177.71,67.35 177.81,67.25 177.98,67.25 178.09,67.14 178.09,62.45 177.71,62.07 177.71,50.76 177.06,50.12 177.06,41.41 172.24,36.59 172.24,35.32 172.09,35.16 v1(171.34,35.16)
  BOTTOM w0.076: v1(170.79,106.57) 170.46,106.25 U9001.P10
  BOTTOM w0.102: JDIM1002.228 172.36,33 171.88,33.47 171.19,33.47 170.77,33.89 170.77,34.69 171.25,35.16 v1(171.34,35.16)
M_B_DQ54: length 87.8
  TOP w0.102: JDIM1003.216 169.36,39.33 169.53,39.16 169.53,38.9 169.35,38.73 168.79,38.73 168.69,38.63 168.69,38.35 168.79,38.25 170.44,38.25 170.57,38.12 170.57,37.84 170.42,37.68 169.96,37.68 v1(169.36,37.08)
  IN1 w0.076: v1(169.88,104.62) 169.88,104.07 169.96,103.98 169.96,99.88 173.26,96.58 173.26,96.45
  IN1 w0.102: 173.26,96.45 173.26,93 176.36,89.91 176.36,75.9 175.54,75.08 175.54,68.91 175.17,68.54 175.17,66.63 175.54,66.26 175.54,66 175.41,65.88 175.27,65.88 175.17,65.77 175.17,65.49 175.27,65.39 175.43,65.39 175.54,65.29 175.54,65.01 175.43,64.91 175.27,64.91 175.17,64.81 175.17,64.53 175.27,64.43 175.43,64.43 175.54,64.33 175.54,64.05 175.43,63.95 175.27,63.95 175.17,63.84 175.17,63.56 175.27,63.46 175.43,63.46 175.54,63.36 175.54,63.08 175.17,62.71 175.17,60.28 175.54,59.91 175.54,52.06 174.82,51.35 174.82,42.3 169.6,37.08 v1(169.36,37.08)
  BOTTOM w0.076: v1(169.88,104.62) 169.55,104.3 U9001.R7
  BOTTOM w0.102: JDIM1002.216 169.36,33.59 168.94,34 168.94,36.66 v1(169.36,37.08)
M_B_DQ55: length 89.1
  TOP w0.102: JDIM1003.224 171.36,37.76 171.56,37.56 171.86,37.56 172.12,37.31 172.12,36.29 171.63,35.8 v1(171.34,35.8)
  IN1 w0.076: v1(170.79,105.27) 171.23,104.83 171.23,103.9 171.53,103.59 171.53,100.15 174.66,97.02 174.66,92.93 177.96,89.63 177.96,89.23
  IN1 w0.102: 177.96,89.23 177.96,75.3 177.35,74.69 177.35,71.34 177.08,71.07 177.08,70.46 177.19,70.36 177.27,70.36 177.37,70.26 177.37,70.03 177.27,69.93 177.19,69.93 177.08,69.82 177.08,69.6 177.19,69.49 177.27,69.49 177.37,69.39 177.37,69.16 177.27,69.06 177.19,69.06 177.08,68.96 177.08,68.73 177.19,68.63 177.27,68.63 177.37,68.53 177.37,68.3 177.27,68.2 177.19,68.2 177.08,68.1 177.08,67.84 177.16,67.77 177.27,67.77 177.37,67.67 177.37,67.44 177.27,67.34 177.19,67.34 177.08,67.23 177.08,67 177.19,66.9 177.32,66.9 177.43,66.8 177.43,66.57 177.32,66.47 177.19,66.47 177.08,66.37 177.08,66.14 177.19,66.04 177.32,66.04 177.43,65.94 177.43,65.71 177.32,65.61 177.19,65.61 177.08,65.51 177.08,65.25 177.16,65.18 177.32,65.18 177.43,65.07 177.43,64.85 177.32,64.74 177.16,64.74 177.08,64.67 177.08,64.39 177.16,64.31 177.32,64.31 177.43,64.21 177.43,63.98 177.32,63.88 177.19,63.88 177.08,63.78 177.08,63.45 177.37,63.16 177.37,50.9 176.73,50.26 176.73,41.55 171.86,36.68 171.86,36.32 v1(171.34,35.8)
  BOTTOM w0.076: U9001.P8 170.46,104.95 v1(170.79,105.27)
  BOTTOM w0.102: JDIM1002.224 171.36,32.99 170.57,33.78 170.57,35.03 v1(171.34,35.8)
M_B_DQ56: length 93.3
  TOP w0.102: JDIM1003.245 176.6,34.86 176.78,35.04 177.04,35.04 177.17,34.91 177.17,33.75 177.3,33.62 177.5,33.62 177.65,33.77 177.65,34.41 177.75,34.51 178.21,34.51 v1(178.85,35.15)
  IN1 w0.076: 175.72,100.88 175.65,100.88 175.37,101.16 175.37,101.57 175.59,101.8 175.59,103.53 175.08,104.04 175.08,104.58 174.51,105.16 174.51,105.9 173.97,106.43 173.97,106.75 v1(173.5,107.22)
  IN1 w0.102: 175.72,100.88 177.96,98.64 177.96,93.49 182.3,89.15 182.3,81.17 182.47,81 182.47,68.84 182.91,68.4 182.91,55.37 184.08,54.2 184.08,51.29 181.64,48.86 181.64,39.5 179.48,37.34 179.48,35.27 179.24,35.03 178.97,35.03 v1(178.85,35.15)
  BOTTOM w0.076: v1(173.5,107.22) 173.18,106.9 U9001.L11
  BOTTOM w0.102: JDIM1002.245 176.6,38.41 178.34,36.67 178.34,35.65 v1(178.85,35.15)
M_B_DQ57: length 91.6
  TOP w0.102: JDIM1003.233 173.6,33.66 172.83,34.43 172.83,36.32 172.93,36.41 173.47,36.41 v1(173.48,36.42)
  IN1 w0.076: 179.1,89.24 179.1,89.35 175.45,93 175.45,96.99 172.35,100.09 172.35,103.76 171.86,104.25 171.86,105.27 171.86,105.49 172.09,105.72 172.09,106.99 172.32,107.22 v1(172.62,107.22)
  IN1 w0.102: 179.1,89.24 179.1,74.82 178.95,74.67 178.95,74.34 179.1,74.19 179.1,73.91 178.95,73.76 178.95,73.48 179.1,73.33 179.1,73.05 178.95,72.89 178.95,72.62 179.1,72.46 179.1,72.18 178.95,72.03 178.95,71.75 179.1,71.6 179.1,71.32 178.95,71.17 178.95,70.89 179.1,70.74 179.1,70.46 178.95,70.3 178.95,70.02 179.1,69.87 179.1,69.59 178.95,69.44 178.95,69.16 179.1,69.01 179.1,68.73 178.95,68.58 178.95,68.3 179.1,68.14 179.1,67.87 178.95,67.71 178.95,67.43 179.1,67.28 179.1,67 178.95,66.85 178.95,66.57 179.1,66.42 179.1,66.14 178.95,65.99 178.95,65.71 179.1,65.55 179.1,65.27 178.95,65.12 178.95,64.84 179.1,64.69 179.1,64.41 178.95,64.26 178.95,63.98 179.1,63.83 179.1,63.55 178.95,63.39 178.95,63.12 179.1,62.96 179.1,62.68 178.95,62.53 178.95,62.25 179.1,62.1 179.1,61.82 178.95,61.67 178.95,61.39 179.1,61.24 179.1,60.96 178.95,60.8 178.95,60.52 179.1,60.37 179.1,60.09 178.95,59.94 178.95,59.66 179.1,59.51 179.1,59.23 178.95,59.08 178.95,58.8 179.1,58.65 179.1,58.37 178.95,58.21 178.95,57.93 179.1,57.78 179.1,57.5 178.95,57.35 178.95,57.07 179.1,56.92 179.1,56.64 178.95,56.49 178.95,56.21 179.1,56.05 179.1,55.77 178.95,55.62 178.95,55.34 179.1,55.19 179.1,54.91 178.95,54.76 178.95,54.48 179.1,54.33 179.1,54.05 178.95,53.9 178.95,51.4 179.18,51.17 179.18,50.92 178.16,49.9 178.16,49.55 178.06,49.45 177.98,49.45 177.88,49.35 177.88,49.12 177.98,49.02 178.06,49.02 178.16,48.92 178.16,48.69 178.06,48.58 177.98,48.58 177.88,48.48 177.88,48.25 177.98,48.15 178.06,48.15 178.16,48.05 178.16,47.82 178.06,47.72 177.98,47.72 177.88,47.62 177.88,47.39 177.98,47.29 178.06,47.29 178.16,47.19 178.16,44.79 178.06,44.69 177.98,44.69 177.88,44.58 177.88,44.36 177.98,44.25 178.06,44.25 178.16,44.15 178.16,41.36 177.93,41.12 177.93,40.85 177.76,40.68 177.49,40.68 177.32,40.51 177.32,40.24 177.15,40.07 176.87,40.07 176.71,39.9 176.71,39.63 176.54,39.46 176.26,39.46 176.09,39.29 176.09,39.07 175.88,38.85 175.65,38.85 175.33,38.53 175.33,38.32 174.9,37.89 174.77,37.89 174.4,37.53 174.4,37.34 v1(173.48,36.42)
  BOTTOM w0.076: v1(172.62,107.22) 172.29,106.9 U9001.M11
  BOTTOM w0.102: JDIM1002.233 173.6,39.08 173.48,38.95 v1(173.48,36.42)
M_B_DQ58: length 88.6
  TOP w0.102: v1(177.58,36.42) 177.58,36.95 177.78,37.15 178.04,37.15 178.14,37.25 178.14,37.53 178.04,37.63 177.68,37.63 177.58,37.74 177.58,38.02 177.68,38.12 178.04,38.12 178.14,38.22 178.14,38.5 178.04,38.6 177.68,38.6 177.58,38.7 177.58,39.06 177.85,39.33 JDIM1003.250
  IN1 w0.076: 174.47,103.09 174.47,103.52 173.69,104.31 173.69,104.47 v1(173.5,104.65)
  IN1 w0.102: 174.47,103.09 174.47,100.96 176.94,98.48 176.94,93.51 181.31,89.14 181.31,68.58 181.92,67.97 181.92,54.96 183.09,53.79 183.09,51.7 180.5,49.11 180.5,48.73 180.65,48.58 180.65,48.23 180.55,48.12 180.45,48.12 180.37,48.05 180.37,47.77 180.45,47.69 180.55,47.69 180.65,47.59 180.65,47.36 180.55,47.26 180.45,47.26 180.37,47.18 180.37,46.9 180.45,46.83 180.55,46.83 180.65,46.73 180.65,46.5 180.55,46.4 180.47,46.4 180.37,46.29 180.37,46.04 180.45,45.96 180.55,45.96 180.65,45.86 180.65,45.63 180.55,45.53 180.47,45.53 180.37,45.43 180.37,45.2 180.47,45.1 180.55,45.1 180.65,45 180.65,44.77 180.55,44.67 180.47,44.67 180.37,44.57 180.37,44.34 180.47,44.24 180.55,44.24 180.65,44.14 180.65,42.29 180.55,42.18 180.47,42.18 180.37,42.08 180.37,41.88 180.47,41.78 180.55,41.78 180.65,41.68 180.65,41.47 180.55,41.37 180.47,41.37 180.37,41.27 180.37,41.07 180.47,40.96 180.55,40.96 180.65,40.86 180.65,40.4 177.67,37.41 177.67,37.04 177.96,36.74 177.96,36.29 177.88,36.21 177.71,36.21 177.58,36.34 v1(177.58,36.42)
  BOTTOM w0.076: U9001.L7 173.15,104.3 v1(173.5,104.65)
  BOTTOM w0.102: v1(177.58,36.42) 177.98,36.01 177.98,33.63 177.85,33.5 JDIM1002.250
M_B_DQ59: length 88.8
  TOP w0.102: v1(174.81,36.47) 173.98,37.3 172.88,37.3 172.75,37.43 172.75,37.68 172.88,37.81 173.41,37.81 173.64,38.04 173.64,38.79 173.36,39.08 JDIM1003.232
  IN1 w0.076: v1(172.58,105.27) 172.16,104.86 172.16,104.43 172.96,103.64 172.96,99.91 175.85,97.02 175.85,93.13 179.76,89.22 179.76,88.96
  IN1 w0.102: 179.76,88.96 179.76,65.32 180.25,64.84 180.25,62.96 179.76,62.47 179.76,58.82 179.94,58.64 179.94,58.33 179.76,58.16 179.76,57.67 179.86,57.57 180.14,57.57 180.25,57.47 180.25,57.19 180.14,57.09 179.86,57.09 179.76,56.99 179.76,56.71 179.86,56.61 180.14,56.61 180.25,56.51 180.25,56.23 180.14,56.12 179.86,56.12 179.76,56.02 179.76,55.74 179.86,55.64 180.14,55.64 180.25,55.54 180.25,55.26 180.14,55.16 179.86,55.16 179.76,55.06 179.76,53.4 180.04,53.12 180.04,50.85 178.82,49.63 178.82,40.76 174.81,36.75 v1(174.81,36.47)
  BOTTOM w0.076: v1(172.58,105.27) 172.25,104.95 U9001.M8
  BOTTOM w0.102: JDIM1002.232 173.36,34.45 174.15,35.24 174.15,35.81 v1(174.81,36.47)
M_B_DQ60: length 90.4
  TOP w0.102: v1(178.85,36.42) 179.35,36.42 179.51,36.26 179.51,35.05 177.6,33.14 JDIM1003.249
  IN1 w0.076: 175.55,100.67 175.22,101.01 175.22,101.63 175.44,101.86 175.44,103.47 174.91,103.99 174.91,104.54 174.15,105.3 174.15,105.93 v1(173.5,106.57)
  IN1 w0.102: v1(178.85,36.42) 178.85,36.82 178.62,37.04 178.62,37.41 178.85,37.64 179,37.64 179.08,37.55 179.23,37.55 179.41,37.74 179.41,37.83 179.3,37.94 179.3,38.09 179.46,38.25 179.61,38.25 179.69,38.16 179.84,38.16 180,38.33 180,38.47 179.91,38.55 179.91,38.7 180.08,38.86 180.22,38.86 180.3,38.78 180.45,38.78 180.61,38.94 180.61,39.08 180.5,39.19 180.5,39.31 180.7,39.51 181.08,39.51 181.31,39.74 181.31,48.99 183.75,51.43 183.75,54.06 182.58,55.23 182.58,68.25 181.97,68.85 181.97,71.8 182.11,71.94 182.11,72.26 181.97,72.4 181.97,72.66 182.14,72.83 182.14,73.1 181.97,73.26 181.97,73.53 182.14,73.69 182.14,73.96 181.97,74.12 181.97,74.39 182.14,74.56 182.14,74.82 181.97,74.99 181.97,75.25 182.14,75.42 182.14,75.69 181.97,75.85 181.97,76.12 182.14,76.28 182.14,76.55 181.97,76.71 181.97,76.98 182.14,77.15 182.14,77.41 181.97,77.58 181.97,77.85 182.14,78.01 182.14,78.28 181.97,78.44 181.97,78.71 182.14,78.87 182.14,79.14 181.97,79.31 181.97,79.57 182.14,79.74 182.14,80 181.97,80.17 181.97,80.44 182.14,80.6 182.14,80.87 181.97,81.03 181.97,89.15 177.52,93.61 177.52,98.7 175.55,100.67
  BOTTOM w0.076: v1(173.5,106.57) 173.18,106.25 U9001.L10
  BOTTOM w0.102: v1(178.85,36.42) 178.85,37.05 177.6,38.29 JDIM1002.249
M_B_DQ61: length 91.4
  TOP w0.102: v1(173.48,35.15) 173.62,35.15 173.88,35.41 173.88,36.05 173.99,36.16 174.27,36.16 174.34,36.08 174.34,34.73 174.12,34.51 173.77,34.51 173.64,34.38 173.64,34.13 173.77,34 174.35,34 174.6,33.75 JDIM1003.237
  IN1 w0.076: 179.43,89.12 179.43,89.3 175.64,93.08 175.64,97.01 172.8,99.85 172.65,100 172.65,103.73 172.01,104.37 172.01,105.2 172.01,105.2 172.01,105.39 172.24,105.62 172.24,106.2 v1(172.62,106.57)
  IN1 w0.102: v1(173.48,35.15) 173.82,34.81 174.04,34.81 174.15,34.91 174.15,36.6 178.49,40.95 178.49,49.77 179.71,50.99 179.71,52.99 179.43,53.27 179.43,89.12
  BOTTOM w0.076: v1(172.62,106.57) 172.29,106.25 U9001.M10
  BOTTOM w0.102: JDIM1002.237 174.6,38.96 173.88,38.24 173.88,35.55 v1(173.48,35.15)
M_B_DQ62: length 86.5
  TOP w0.102: v1(174.81,35.2) 175.24,35.63 175.24,36.72 174.35,37.61 JDIM1003.236
  IN1 w0.076: v1(172.58,104.61) 172.58,104.4 173.1,103.87 173.34,103.87 173.77,103.45 173.77,100.31 176.08,98 176.08,93.14 180.09,89.12 180.09,88.99
  IN1 w0.102: 180.09,88.99 180.09,65.78 180.7,65.17 180.7,62.8 180.37,62.47 180.37,61.18 180.7,60.85 180.7,54.64 180.17,54.12 180.17,53.46 180.37,53.26 180.37,50.71 179.15,49.49 179.15,40.62 175.19,36.66 175.19,35.58 v1(174.81,35.2)
  BOTTOM w0.076: v1(172.58,104.61) 172.26,104.3 U9001.M7
  BOTTOM w0.102: JDIM1002.236 174.35,33.19 174.81,33.64 174.81,34.02 174.71,34.12 174.17,34.12 174.05,34.25 174.05,34.45 174.2,34.6 174.66,34.6 174.81,34.75 v1(174.81,35.2)
M_B_DQ63: length 88.7
  TOP w0.102: v1(177.58,35.15) 177.11,35.62 177.11,37.52 176.85,37.77 JDIM1003.246
  IN1 w0.076: v1(173.5,105.27) 173.93,104.85 173.93,104.3 174.68,103.55 174.68,101.16 174.91,100.93
  IN1 w0.102: v1(177.58,35.15) 177.58,34.58 177.76,34.41 178.11,34.41 178.29,34.58 178.29,37.57 180.98,40.26 180.98,49.13 183.42,51.57 183.42,53.92 182.25,55.1 182.25,68.11 181.64,68.71 181.64,89.17 177.2,93.61 177.2,98.64 174.91,100.93
  BOTTOM w0.076: v1(173.5,105.27) 173.18,104.95 U9001.L8
  BOTTOM w0.102: JDIM1002.246 176.85,33.91 177.3,34.36 177.3,34.63 176.94,34.99 176.94,35.27 177.07,35.4 177.33,35.4 v1(177.58,35.15)
M_B_DQSN0: length 102.1
  TOP w0.102: JDIM1003.11 116.1,33.13 116.15,33.18 116.35,33.18 116.4,33.23 116.4,33.36 116.21,33.55 115.83,33.55 115.6,33.78 115.6,34.19 115.9,34.48 116.1,34.48 116.21,34.59 116.21,35.84 116.44,36.07 116.44,36.33 116.37,36.4 115.88,36.4 115.8,36.32 v1(115.8,36.16)
  IN1 w0.076: v1(141.04,106.44) 140.83,106.65 140.83,106.74 140.52,107.05 138.19,107.05 137.09,105.95 136.31,105.95 136.1,105.75 136.04,105.75 136.03,105.73
  IN1 w0.114: v1(115.8,36.16) 115.41,36.55 115.41,37.22 111.98,40.66 111.98,48.94 109.96,50.95 109.96,54.41 111.91,56.35 111.91,61.28 116.86,66.23 116.86,79.54 117.56,80.25 117.56,83.58 122.31,88.32 122.31,94.63 128.88,101.2 130.65,101.2 135.04,105.6 135.89,105.6 136.03,105.73
  BOTTOM w0.076: U9001.BN9 140.72,106.12 v1(141.04,106.44)
  BOTTOM w0.102: JDIM1002.11 116.1,38.91 115.12,37.92 115.12,36.43 115.39,36.16 v1(115.8,36.16)
M_B_DQSN1: length 99.4
  TOP w0.102: JDIM1003.32 121.35,39.28 120.97,38.9 120.14,38.9 119.62,38.38 119.62,36.11 119.84,35.88 120.24,35.88 v1(120.36,35.76)
  IN1 w0.076: 141.15,104.35 141.17,104.35 141.22,104.3 141.74,104.3 142.12,104.68 142.12,106.22 v1(142.47,106.57)
  IN1 w0.114: 141.15,104.35 140.93,104.35 138.97,102.38 138.97,100.52 136.66,98.2 131.09,98.2 125.99,93.1 125.99,86.79 121.65,82.45 121.65,77.86 121.25,77.45 121.25,66.97 120.54,66.26 120.54,64.71 116.66,60.82 116.66,50 116.29,49.63 116.29,47.67 116.49,47.46 116.49,41.36 119.55,38.3 119.55,36.25 119.85,35.96 120.17,35.96 v1(120.36,35.76)
  BOTTOM w0.076: v1(142.47,106.57) 142.02,106.12 U9001.BL9
  BOTTOM w0.102: v1(120.36,35.76) 120.36,35.84 120.55,36.03 120.78,36.03 120.86,35.95 120.86,34.36 121.65,33.57 121.65,33.22 121.6,33.16 121.4,33.16 121.35,33.12 JDIM1002.32
M_B_DQSN2: length 100
  TOP w0.102: v1(125.06,35.39) 125.06,35.46 125.27,35.68 125.45,35.68 125.67,35.46 125.67,34.63 125.37,34.33 124.7,34.33 124.5,34.13 124.5,33.77 124.81,33.45 125.97,33.45 126.24,33.72 126.6,33.72 126.9,33.42 126.9,33.16 126.84,33.1 126.66,33.1 126.6,33.04 JDIM1003.53
  IN1 w0.076: v1(145.19,105.92) 145.57,105.54 145.57,104.45 144.23,103.11 144.23,100.97 143.33,100.08 143.2,100.08 143.03,99.9 142.97,99.9 142.95,99.89
  IN1 w0.114: 142.95,99.89 137.99,94.93 136.05,94.93 135.81,95.17 133.27,95.17 130.27,92.17 130.27,85.46 126.46,81.65 126.46,77.08 125.76,76.38 125.76,66.22 124.23,64.69 124.23,63.18 121.81,60.76 121.81,47.82 122.17,47.46 122.17,40.89 124.28,38.78 124.28,36.12 124.69,35.71 124.74,35.71 v1(125.06,35.39)
  BOTTOM w0.076: v1(145.19,105.92) 144.86,105.6 U9001.BG9
  BOTTOM w0.102: JDIM1002.53 126.6,39.41 125.25,38.06 124.92,38.06 124.39,37.54 124.39,35.72 124.61,35.5 124.87,35.5 124.94,35.5 v1(125.06,35.39)
M_B_DQSN3: length 97.5
  TOP w0.102: v1(130.25,35.8) 130.17,35.89 129.54,35.89 129.27,36.16 129.27,37.13 130.02,37.89 131.04,37.89 131.48,38.33 131.48,38.83 131.85,39.2 JDIM1003.74
  IN1 w0.076: 147.36,101.53 147.36,101.55 147.41,101.6 147.41,102.17 147.69,102.45 147.69,103.54 148.31,104.17 148.31,105.54 v1(147.93,105.92)
  IN1 w0.114: v1(130.25,35.8) 129.83,35.8 129.82,35.81 129.67,35.81 129.38,36.1 129.38,38.89 127.26,41.01 127.26,47.43 126.51,48.18 126.51,49.78 126.79,50.06 126.79,50.55 126.51,50.83 126.51,54.73 126.79,55.01 126.79,55.49 126.51,55.77 126.51,56.46 126.79,56.74 126.79,57.22 126.51,57.5 126.51,60.25 127.91,61.65 127.91,63.16 130.16,65.41 130.16,66.12 130.05,66.23 129.7,66.23 129.45,66.49 129.45,67.08 129.7,67.33 130.05,67.33 130.16,67.45 130.16,67.84 130.05,67.96 129.7,67.96 129.45,68.21 129.45,68.81 129.7,69.06 129.99,69.06 130.16,69.23 130.16,79.54 144.81,94.19 145.35,94.19 147.36,96.2 147.36,101.53
  BOTTOM w0.076: U9001.BC9 147.6,105.6 v1(147.93,105.92)
  BOTTOM w0.102: JDIM1002.74 131.85,32.97 131.96,33.08 132.04,33.08 132.15,33.19 132.15,33.27 131.85,33.57 131.37,33.57 130.77,34.17 130.77,36.1 130.69,36.18 130.52,36.18 130.25,35.91 v1(130.25,35.8)
M_B_DQSN4: length 89.6
  TOP w0.102: v1(160.15,36.73) 160.05,36.63 159.63,36.63 159.42,36.41 159.42,34.5 159.31,34.39 158.97,34.39 158.73,34.15 158.73,33.72 158.96,33.49 159.54,33.49 159.6,33.43 JDIM1003.177
  IN1 w0.076: 164.99,103.51 164.99,103.53 165.04,103.58 165.04,104.13 164.77,104.4 164.77,105.6 164.83,105.66 164.83,105.82 164.73,105.92 v1(164.39,105.92)
  IN1 w0.114: v1(160.15,36.73) 160.15,36.67 160.43,36.4 160.59,36.4 160.67,36.48 160.67,38.24 160.43,38.47 160.43,39 160.98,39.55 161.46,39.55 161.76,39.85 161.76,40.33 162.2,40.77 162.68,40.77 162.98,41.07 162.98,41.55 166.53,45.1 166.53,47.51 166.81,47.8 166.81,48.27 166.43,48.66 166.43,49.35 166.81,49.74 166.81,50.26 166.53,50.55 166.53,75.81 169.48,78.76 169.48,89.22 166.14,92.57 166.14,96.63 164.99,97.77 164.99,103.51
  BOTTOM w0.076: U9001.AC9 164.06,105.6 v1(164.39,105.92)
  BOTTOM w0.102: v1(160.15,36.73) 160.15,36.71 160.51,36.35 160.58,36.35 160.66,36.44 160.66,38.09 159.9,38.84 159.9,39.21 159.82,39.3 159.71,39.3 159.6,39.4 JDIM1002.177
M_B_DQSN5: length 89.2
  TOP w0.102: v1(164.31,36.29) 164.74,35.86 165.05,35.86 165.41,36.22 165.41,36.98 165.33,37.07 164.95,37.07 164.75,37.26 164.75,37.86 164.97,38.08 165.11,38.08 165.15,38.12 165.15,39.02 165.07,39.11 165.01,39.11 164.85,39.26 JDIM1003.198
  IN1 w0.076: v1(167.13,105.92) 167.44,105.92 167.54,105.82 167.54,105.63 167.51,105.6 167.51,99.06 170.14,96.43 170.14,96.07 170.1,96.03 170.1,96.01
  IN1 w0.114: v1(164.31,36.29) 164.31,36.21 164.63,35.9 164.78,35.9 164.85,35.97 164.85,37.72 170.78,43.65 170.78,50.03 171.27,50.51 171.27,75.32 173.16,77.22 173.16,89.74 170.1,92.8 170.1,96.01
  BOTTOM w0.076: v1(167.13,105.92) 166.81,105.6 U9001.W9
  BOTTOM w0.102: JDIM1002.198 164.85,33.25 163.61,34.5 163.61,36.03 163.8,36.22 164.24,36.22 v1(164.31,36.29)
M_B_DQSN6: length 91.5
  TOP w0.102: v1(169.36,35.81) 169.27,35.72 168.61,35.72 168.26,35.37 168.26,34.77 169.11,33.92 169.62,33.92 169.97,34.27 169.97,34.41 170.1,34.53 170.31,34.53 170.44,34.41 170.44,33.89 170.1,33.55 JDIM1003.219
  IN1 w0.076: v1(169.88,105.92) 170.16,105.92 170.3,105.78 170.3,105.65 170.26,105.6 170.26,104.41 170.2,104.36 170.2,99.93 173.62,96.51 173.62,96.28 173.58,96.24 173.58,96.22
  IN1 w0.114: v1(169.36,35.81) 169.36,35.73 169.67,35.41 169.95,35.41 170,35.47 170,36.77 174.86,41.62 175.31,41.62 175.65,41.96 175.65,51.48 176.02,51.86 176.02,74.86 176.9,75.74 176.9,89.69 173.58,93.01 173.58,96.22
  BOTTOM w0.076: v1(169.88,105.92) 169.55,105.6 U9001.R9
  BOTTOM w0.102: v1(169.36,35.81) 169.36,35.75 169.73,35.38 169.83,35.38 169.91,35.45 169.91,38.27 170.4,38.76 170.4,39.03 170.1,39.33 JDIM1002.219
M_B_DQSN7: length 89.5
  TOP w0.102: v1(176.04,35.93) 176.04,35.87 176.41,35.49 176.52,35.49 176.6,35.57 176.6,36.59 175.65,37.55 175.65,39.06 175.35,39.36 JDIM1003.240
  IN1 w0.076: v1(172.63,105.92) 172.63,105.92 172.88,105.92 173.03,105.78 173.03,105.66 172.97,105.6 172.97,104.38 173.25,104.1 173.41,104.1 174.03,103.48 174.03,102.14 173.98,102.1 173.98,102.08
  IN1 w0.114: 173.98,102.08 173.98,100.57 176.37,98.18 176.37,93.3 180.58,89.09 180.58,68.27 181.18,67.67 181.18,54.66 182.36,53.48 182.36,52.01 179.64,49.29 179.64,40.42 176.7,37.48 176.7,35.62 176.61,35.53 176.37,35.53 176.04,35.86 v1(176.04,35.93)
  BOTTOM w0.076: v1(172.63,105.92) 172.3,105.6 U9001.M9
  BOTTOM w0.102: v1(176.04,35.93) 175.97,35.85 175.42,35.85 175.22,35.65 175.22,35.21 175.37,35.06 175.37,34.8 175.22,34.64 175.22,34.25 175.62,33.84 175.62,33.72 175.55,33.64 175.54,33.64 175.35,33.46 JDIM1002.240
M_B_DQSN8: length 94.8
  TOP w0.102: JDIM1003.95 137.1,33.02 137.18,33.1 137.33,33.1 137.83,33.59 137.83,33.74 137.77,33.8 137.09,33.8 137.01,33.72 137.01,33.36 136.81,33.16 136.22,33.16 135.95,33.43 135.95,33.77 136.23,34.05 136.23,34.12 136.09,34.25 136.09,35.68 136.06,35.71 135.93,35.71 135.65,35.43 v1(135.65,35.38)
  IN1 w0.076: v1(150.67,105.92) 150.96,105.64 150.96,105.51 151.06,105.41 151.06,104.45 149.88,103.28 149.88,93.26 149.79,93.17 149.73,93.17 149.71,93.16
  IN1 w0.114: v1(135.65,35.38) 134.98,35.38 134.55,35.8 134.55,39.64 132.25,41.95 132.25,47.43 132.65,47.84 132.65,54.71 132.68,54.73 132.68,61.7 134.84,63.86 134.84,69.14 135.32,69.63 135.32,78.76 149.71,93.16
  BOTTOM w0.076: U9001.AY9 150.35,105.6 v1(150.67,105.92)
  BOTTOM w0.102: v1(135.65,35.38) 135.51,35.51 135.22,35.51 135.03,35.69 135.03,37.55 136,38.52 136.13,38.52 137.1,39.5 JDIM1002.95
M_B_DQSP0: length 102.1
  TOP w0.102: JDIM1003.13 116.6,33.45 116.3,33.76 115.91,33.76 115.81,33.87 115.81,34.1 115.98,34.28 116.19,34.28 116.41,34.51 116.41,35.75 116.64,35.98 116.64,36.41 116.46,36.6 116,36.6 v1(115.8,36.8)
  IN1 w0.076: 136.2,105.56 136.21,105.58 136.21,105.64 136.37,105.8 137.15,105.8 138.25,106.9 140.46,106.9 140.68,106.68 140.68,106.51 140.61,106.44 v1(140.39,106.44)
  IN1 w0.114: 136.2,105.56 135.99,105.35 135.14,105.35 130.75,100.96 128.98,100.96 122.55,94.53 122.55,88.22 117.81,83.48 117.81,80.15 117.1,79.44 117.1,66.13 112.15,61.18 112.15,56.25 110.2,54.31 110.2,51.05 112.22,49.04 112.22,40.76 115.65,37.32 115.65,36.92 115.77,36.8 v1(115.8,36.8)
  BOTTOM w0.076: v1(140.39,106.44) 140.39,106 140.49,105.9 140.49,105.8 140.42,105.72 139.93,105.72 139.88,105.77 139.88,105.86 U9001.BP9
  BOTTOM w0.102: v1(115.8,36.8) 115.8,36.74 115.47,36.41 115.42,36.41 115.32,36.52 115.32,37.84 116.6,39.12 JDIM1002.13
M_B_DQSP1: length 99.4
  TOP w0.102: v1(120.36,36.4) 120.36,36.37 120.07,36.09 119.92,36.09 119.82,36.19 119.82,38.29 120.23,38.7 121.06,38.7 121.57,39.21 121.77,39.21 121.85,39.3 JDIM1003.34
  IN1 w0.076: v1(142.51,105.92) 142.32,105.92 142.27,105.88 142.27,104.62 141.8,104.15 141.22,104.15 141.17,104.1 141.15,104.1
  IN1 w0.114: v1(120.36,36.4) 120.16,36.2 119.95,36.2 119.79,36.35 119.79,38.4 116.73,41.46 116.73,47.56 116.53,47.77 116.53,49.53 116.9,49.9 116.9,60.72 120.79,64.61 120.79,66.16 121.49,66.87 121.49,77.35 121.89,77.76 121.89,82.35 126.23,86.69 126.23,93 131.19,97.96 136.76,97.96 139.21,100.42 139.21,102.28 141.03,104.1 141.15,104.1
  BOTTOM w0.076: v1(142.51,105.92) 142.35,105.76 142.35,105.11 142.45,105.01 142.55,105.01 142.73,105.19 142.73,105.42 U9001.BJ9
  BOTTOM w0.102: v1(120.36,36.4) 120.53,36.23 120.86,36.23 121.06,36.03 121.06,34.44 121.85,33.65 JDIM1002.34
M_B_DQSP2: length 100
  TOP w0.102: JDIM1003.55 127.1,33.5 126.69,33.92 126.16,33.92 125.89,33.65 124.9,33.65 124.7,33.85 124.7,34.05 124.78,34.13 125.46,34.13 125.87,34.54 125.87,35.54 125.53,35.88 125.2,35.88 v1(125.06,36.02)
  IN1 w0.076: 143.12,99.72 143.14,99.73 143.14,99.79 143.27,99.92 143.39,99.92 144.38,100.91 144.38,103.05 145.72,104.38 145.72,105.6 145.6,105.73 145.6,105.98 145.72,106.1 145.92,106.1 v1(146.1,105.92)
  IN1 w0.114: 143.12,99.72 138.09,94.69 135.95,94.69 135.71,94.93 133.37,94.93 130.51,92.07 130.51,85.36 126.7,81.55 126.7,76.98 126,76.28 126,66.12 124.47,64.59 124.47,63.08 122.05,60.66 122.05,47.92 122.41,47.56 122.41,40.99 124.52,38.88 124.52,36.22 124.79,35.95 124.98,35.95 v1(125.06,36.02)
  BOTTOM w0.076: v1(146.1,105.92) 145.78,105.6 U9001.BF9
  BOTTOM w0.102: v1(125.06,36.02) 125.06,35.98 124.79,35.71 124.7,35.71 124.6,35.81 124.6,37.45 125,37.86 125.34,37.86 126.72,39.25 126.89,39.25 127.1,39.46 JDIM1002.55
M_B_DQSP3: length 97.5
  TOP w0.102: JDIM1003.76 132.35,39.41 131.69,38.74 131.69,38.25 131.12,37.68 130.11,37.68 129.47,37.05 129.47,36.24 129.62,36.09 129.96,36.09 130.25,36.38 v1(130.25,36.51)
  IN1 w0.076: 147.61,101.53 147.61,101.55 147.56,101.6 147.56,102.11 147.84,102.39 147.84,103.48 148.46,104.1 148.46,105.82 148.57,105.92 v1(148.84,105.92)
  IN1 w0.114: v1(130.25,36.51) 129.99,36.25 129.99,36.16 129.88,36.05 129.77,36.05 129.62,36.2 129.62,38.99 127.5,41.11 127.5,47.53 126.75,48.28 126.75,49.68 127.03,49.96 127.03,50.65 126.75,50.93 126.75,54.63 127.03,54.91 127.03,55.59 126.75,55.87 126.75,56.36 127.03,56.64 127.03,57.32 126.75,57.6 126.75,60.15 128.15,61.55 128.15,63.06 130.4,65.31 130.4,66.22 130.15,66.47 129.8,66.47 129.69,66.59 129.69,66.98 129.8,67.09 130.15,67.09 130.4,67.35 130.4,67.94 130.15,68.2 129.8,68.2 129.69,68.31 129.69,68.71 129.8,68.82 130.09,68.82 130.4,69.13 130.4,79.44 144.91,93.94 145.45,93.94 147.61,96.1 147.61,101.53
  BOTTOM w0.076: U9001.BB9 148.52,105.6 v1(148.84,105.92)
  BOTTOM w0.102: JDIM1002.76 132.35,33.35 131.93,33.77 131.45,33.77 130.97,34.25 130.97,36.19 130.77,36.38 130.38,36.38 v1(130.25,36.51)
M_B_DQSP4: length 89.6
  TOP w0.102: JDIM1003.179 160.1,33.19 160.05,33.24 159.91,33.24 159.81,33.34 159.81,33.52 159.63,33.7 159.04,33.7 158.93,33.8 158.93,34.07 159.05,34.19 159.39,34.19 159.62,34.41 159.62,36.33 159.72,36.43 159.89,36.43 160.15,36.16 v1(160.15,36.1)
  IN1 w0.076: 165.23,103.51 165.23,103.53 165.19,103.58 165.19,104.2 164.92,104.46 164.92,105.54 v1(165.3,105.92)
  IN1 w0.114: v1(160.15,36.1) 160.21,36.16 160.69,36.16 160.91,36.38 160.91,38.34 160.67,38.57 160.67,38.9 161.08,39.31 161.56,39.31 162,39.75 162,40.23 162.3,40.53 162.78,40.53 163.23,40.97 163.23,41.45 166.77,45 166.77,47.41 167.06,47.7 167.06,48.37 166.67,48.76 166.67,49.25 167.06,49.64 167.06,50.36 166.77,50.65 166.77,75.71 169.72,78.66 169.72,89.32 166.38,92.67 166.38,96.73 165.23,97.87 165.23,103.51
  BOTTOM w0.076: v1(165.3,105.92) 164.98,105.6 U9001.AA9
  BOTTOM w0.102: JDIM1002.179 160.1,38.93 160.86,38.17 160.86,36.35 160.66,36.15 160.2,36.15 v1(160.15,36.1)
M_B_DQSP5: length 89.2
  TOP w0.102: v1(164.31,35.65) 165.14,35.65 165.61,36.13 165.61,37.07 165.41,37.27 165.03,37.27 164.95,37.35 164.95,37.78 165.06,37.88 165.2,37.88 165.36,38.04 JDIM1003.200
  IN1 w0.076: v1(168.05,105.92) 167.67,105.54 167.67,99.13 170.29,96.5 170.29,96.07 170.34,96.03 170.34,96.01
  IN1 w0.114: v1(164.31,35.65) 164.88,35.65 165.09,35.87 165.09,37.62 171.02,43.55 171.02,49.93 171.51,50.41 171.51,75.22 173.41,77.12 173.41,89.84 170.34,92.9 170.34,96.01
  BOTTOM w0.076: v1(168.05,105.92) 167.72,105.6 U9001.V9
  BOTTOM w0.102: JDIM1002.200 165.36,33.14 165.26,33.24 165.16,33.24 163.81,34.58 163.81,35.95 163.88,36.02 164.01,36.02 164.31,35.71 v1(164.31,35.65)
M_B_DQSP6: length 91.4
  TOP w0.102: JDIM1003.221 170.6,33.13 170.54,33.19 170.54,33.19 170.37,33.19 170.31,33.25 170.31,33.47 170.64,33.8 170.64,34.49 170.4,34.74 170.01,34.74 169.77,34.49 169.77,34.35 169.54,34.12 169.19,34.12 168.46,34.86 168.46,35.29 168.69,35.52 169.01,35.52 v1(169.36,35.17)
  IN1 w0.076: 173.82,96.22 173.82,96.24 173.77,96.28 173.77,96.57 170.36,99.99 170.36,104.29 170.41,104.35 170.41,105.54 v1(170.79,105.92)
  IN1 w0.114: 173.82,96.22 173.82,93.11 177.14,89.79 177.14,75.64 176.27,74.76 176.27,51.76 175.89,51.38 175.89,41.86 175.41,41.38 174.96,41.38 170.25,36.67 170.25,35.37 170.05,35.17 v1(169.36,35.17)
  BOTTOM w0.076: v1(170.79,105.92) 170.46,105.6 U9001.P9
  BOTTOM w0.102: JDIM1002.221 170.6,38.68 170.11,38.18 170.11,35.37 169.92,35.17 v1(169.36,35.17)
M_B_DQSP7: length 89.4
  TOP w0.102: v1(176.04,35.29) 176.61,35.29 176.81,35.49 176.81,36.68 175.85,37.63 JDIM1003.242
  IN1 w0.076: v1(173.5,105.92) 173.12,105.54 173.12,104.45 173.31,104.26 173.47,104.26 174.18,103.55 174.18,102.14 174.23,102.1 174.23,102.08
  IN1 w0.114: v1(176.04,35.29) 176.71,35.29 176.94,35.52 176.94,37.38 179.88,40.32 179.88,49.19 182.6,51.91 182.6,53.58 181.43,54.76 181.43,67.77 180.82,68.37 180.82,89.19 176.61,93.4 176.61,98.28 174.23,100.67 174.23,102.08
  BOTTOM w0.076: U9001.L9 173.18,105.6 v1(173.5,105.92)
  BOTTOM w0.102: v1(176.04,35.29) 176.04,35.35 175.74,35.65 175.5,35.65 175.42,35.57 175.42,35.3 175.57,35.14 175.57,34.71 175.42,34.56 175.42,34.33 175.83,33.93 175.83,33.64 175.63,33.44 175.62,33.44 175.56,33.38 175.56,33.22 175.62,33.16 175.74,33.16 175.85,33.04 JDIM1002.242
M_B_DQSP8: length 94.8
  TOP w0.102: v1(135.65,36.01) 135.74,35.91 136.14,35.91 136.3,35.76 136.3,34.34 136.43,34.2 136.43,33.97 136.15,33.69 136.15,33.52 136.3,33.36 136.73,33.36 136.81,33.45 136.81,33.81 137.01,34 137.85,34 138.03,33.82 138.03,33.51 137.61,33.08 JDIM1003.97
  IN1 w0.076: v1(151.59,105.92) 151.26,105.92 151.11,105.77 151.11,105.57 151.21,105.47 151.21,104.39 150.03,103.21 150.03,93.2 149.9,93.07 149.9,93 149.89,92.99
  IN1 w0.114: 149.89,92.99 135.56,78.66 135.56,69.53 135.08,69.04 135.08,63.76 132.92,61.6 132.92,54.63 132.89,54.61 132.89,47.73 132.49,47.33 132.49,42.05 134.8,39.74 134.8,35.9 135.08,35.62 135.33,35.62 135.65,35.94 v1(135.65,36.01)
  BOTTOM w0.076: U9001.AW9 151.26,105.6 v1(151.59,105.92)
  BOTTOM w0.102: v1(135.65,36.01) 135.65,35.96 135.4,35.71 135.3,35.71 135.24,35.78 135.24,37.47 136.08,38.32 136.21,38.32 137.08,39.19 137.31,39.19 137.61,39.49 JDIM1002.97
M_B_ODT0: length 81.3
  IN1 w0.114: v1(155.54,37.36) 155.54,42.5 157.82,44.78 157.82,47.69 160.06,49.94 160.06,54.87 158.27,56.66 158.27,57.21 158.74,57.68 158.74,60.76 158.41,61.1 158.41,61.87 158.53,61.99 158.63,61.99 158.74,62.1 158.74,62.37 158.63,62.48 158.53,62.48 158.41,62.6 158.41,64.1 157.92,64.59 157.92,64.85 158.04,64.96 158.48,64.96 158.59,65.07 158.59,65.34 158.48,65.46 158.04,65.46 157.92,65.57 157.92,65.84 158.04,65.95 158.48,65.95 158.59,66.07 158.59,66.33 158.48,66.45 158.04,66.45 157.92,66.56 157.92,66.87 158.59,67.53 158.59,74.51 164.81,80.73 164.81,88.62 162.14,91.29 162.14,100.34 161.82,100.65 161.82,104.26 161.65,104.43 v1(161.65,104.65)
  BOTTOM w0.076: v1(161.65,104.65) 161.3,104.3 U9001.AF7
  BOTTOM w0.102: v1(155.54,37.36) 154.1,38.79 JDIM1002.155
M_B_ODT1: length 84.5
  IN1 w0.076: 163.35,95.82 163.35,95.84 163,96.2 163,100.82 162.56,101.26 162.56,103.9 162.77,104.11 162.77,104.31 162.94,104.48 162.94,104.8 162.75,104.99 162.75,105.09 v1(162.56,105.27)
  IN1 w0.114: 163.35,95.82 163.35,92.26 166.68,88.94 166.68,79.95 161.31,74.59 161.31,73.65 161.17,73.51 160.73,73.51 160.61,73.39 160.61,73 160.73,72.88 161.17,72.88 161.31,72.74 161.31,65.2 161.52,64.99 161.98,64.99 162.17,64.8 162.17,57.88 162.31,57.74 162.31,49.55 160.74,47.97 160.74,44.13 157.42,40.81 157.42,35.82 v1(157,35.4)
  BOTTOM w0.076: U9001.AE8 162.23,104.95 v1(162.56,105.27)
  BOTTOM w0.102: JDIM1002.161 155.6,38.95 157.4,37.16 157.4,35.81 v1(157,35.4)
M_B_ODT2: length 91.2
  TOP w0.102: JDIM1003.155 154.1,33.77 154.59,34.26 v1(154.59,35.15)
  IN1 w0.076: 162.57,100.26 162.57,100.57 162.18,100.96 162.18,105.54 v1(162.56,105.92)
  IN1 w0.114: v1(154.59,35.15) 154.97,35.53 155.74,35.53 156.57,36.36 156.57,41.99 159.9,45.33 159.9,48.32 161.45,49.87 161.45,56.91 161.09,57.27 161.09,60.25 160.98,60.36 159.89,60.36 159.77,60.48 159.77,60.74 159.89,60.86 160.95,60.86 161.06,60.97 161.06,61.24 160.95,61.35 159.89,61.35 159.77,61.47 159.77,61.73 159.89,61.85 160.95,61.85 161.06,61.96 161.06,62.23 160.95,62.34 159.89,62.34 159.77,62.46 159.77,62.72 159.89,62.84 160.95,62.84 161.06,62.95 161.06,63.22 160.95,63.33 159.89,63.33 159.77,63.45 159.77,65.57 159.89,65.69 160.19,65.69 160.33,65.83 160.33,66.04 160.19,66.18 159.89,66.18 159.77,66.3 159.77,74.24 165.84,80.3 165.84,88.76 162.59,92.01 162.59,100.24 162.57,100.26
  BOTTOM w0.076: U9001.AE9 162.23,105.6 v1(162.56,105.92)
M_B_ODT3: length 93.4
  TOP w0.102: v1(157,34.57) 155.6,33.18 JDIM1003.161
  IN1 w0.076: v1(162.56,107.22) 163.06,106.73 163.06,106.18 163.09,106.14 163.09,105.1 163.25,104.95 163.25,104.35 163.08,104.18 163.08,103.99 162.86,103.77 162.86,101.59 163.38,101.08 163.38,96.84 164.12,96.1 164.12,95.31
  IN1 w0.114: v1(157,34.57) 157.35,34.57 158.25,35.47 158.25,39.61 162.02,43.37 162.02,48.07 163.57,49.62 163.57,54.78 163.69,54.9 163.92,54.9 164.03,55.01 164.03,55.28 163.92,55.39 163.53,55.39 163.42,55.51 163.42,55.77 163.53,55.89 163.92,55.89 164.03,56 164.03,56.27 163.92,56.38 163.53,56.38 163.42,56.5 163.42,56.77 163.53,56.88 163.92,56.88 164.03,56.99 164.03,57.26 163.92,57.37 163.69,57.37 163.57,57.49 163.57,57.76 163.69,57.87 163.92,57.87 164.03,57.98 164.03,58.25 163.92,58.37 163.69,58.37 163.57,58.48 163.57,58.75 163.69,58.86 163.92,58.86 164.03,58.97 164.03,59.24 163.92,59.36 163.69,59.36 163.57,59.47 163.57,59.74 163.69,59.85 163.92,59.85 164.03,59.97 164.03,60.23 163.92,60.35 163.69,60.35 163.57,60.46 163.57,60.73 163.69,60.84 163.92,60.84 164.03,60.96 164.03,61.39 163.3,62.12 163.3,66.54 163.18,66.65 162.96,66.65 162.85,66.77 162.85,67.03 162.96,67.15 163.18,67.15 163.3,67.26 163.3,67.53 163.18,67.64 162.96,67.64 162.85,67.76 162.85,68.02 162.96,68.14 163.18,68.14 163.3,68.25 163.3,68.52 163.18,68.63 162.96,68.63 162.85,68.75 162.85,69.02 162.96,69.13 163.21,69.13 163.3,69.22 163.3,69.51 163.18,69.62 162.96,69.62 162.85,69.74 162.85,70.01 162.96,70.12 163.18,70.12 163.3,70.23 163.3,70.5 163.18,70.62 162.96,70.62 162.85,70.73 162.85,71 162.96,71.11 163.18,71.11 163.3,71.22 163.3,71.49 163.18,71.61 162.96,71.61 162.85,71.72 162.85,71.99 162.96,72.1 163.18,72.1 163.3,72.22 163.3,72.48 163.18,72.6 162.96,72.6 162.85,72.71 162.85,72.98 162.96,73.09 163.18,73.09 163.3,73.21 163.3,73.47 163.18,73.59 162.96,73.59 162.85,73.7 162.85,73.99 163.3,74.44 163.3,75.39 167.51,79.61 167.51,88.86 164.12,92.26 164.12,95.31
  BOTTOM w0.076: v1(162.56,107.22) 162.23,106.9 U9001.AE11
MAIN_BAT_DET#: length 17.6
  IN4 w0.076: v1(223.43,7.08) 223.86,7.51 234.7,7.51 235.72,6.49 v1(235.72,6.01)
  BOTTOM w0.114: PR12014.1 223.69,7.34 v1(223.43,7.08) ; PR11021.1 236.05,5.68 v1(235.72,6.01)
MDI0+: length 13.5
  TOP w0.102: U4001.1 29.02,133.69 28.71,134 28.1,134 27.79,133.69 27.79,131.99 25.69,129.88 23.85,129.88 23.21,130.52 v1(23.15,130.52)
  BOTTOM w0.102: v1(23.15,130.52) 23.3,130.37 23.3,129.83 23.58,129.55 23.58,128.45 23.74,128.29 U4000.13
MDI0-: length 13.5
  TOP w0.102: v1(23.91,130.52) 23.78,130.39 23.78,130.24 23.93,130.09 25.6,130.09 27.59,132.08 27.59,133.78 28.01,134.2 28.35,134.2 29.12,134.96 29.9,134.96
  BOTTOM w0.102: U4000.14 24.14,127.78 23.94,127.97 23.94,128.37 23.78,128.53 23.78,129.63 23.5,129.91 23.5,130.32 23.7,130.52 v1(23.91,130.52)
MDI1+: length 17.3
  TOP w0.102: U4001.5 28.86,138.77 28.38,139.25 27.94,139.25 27.46,138.77 27.46,135.09 26.42,134.05 26.42,132.4 25.61,131.59 24.95,131.59 24.67,131.31 v1(24.67,131.15)
  BOTTOM w0.102: U4000.17 25.34,127.85 25.43,127.94 25.43,131.25 25.2,131.48 24.8,131.48 24.67,131.35 v1(24.67,131.15)
MDI1-: length 17.3
  TOP w0.102: U4001.6 28.94,140.04 28.35,139.45 27.86,139.45 27.26,138.86 27.26,135.18 26.22,134.13 26.22,132.48 25.53,131.79 24.8,131.79 v1(24.67,131.92)
  BOTTOM w0.102: U4000.18 25.74,127.85 25.64,127.96 25.64,131.33 25.28,131.68 24.9,131.68 v1(24.67,131.92)
MDI2+: length 29.5
  TOP w0.102: v1(27.97,141.57) 28.23,141.82 28.51,141.82 29.01,141.31 U4001.7
  IN1 w0.076: v1(27.97,141.57) 27.97,141.74 28.15,141.92 28.43,141.92 28.61,141.74 28.61,140.3 28.25,139.94 27.34,139.94 27.04,139.64 27.04,138.95 27.34,138.65 28.4,138.65 28.61,138.44 28.61,137.87 28.4,137.67 26.46,137.67 26.16,137.37 26.16,136.28 26.46,135.98 27.39,135.98 27.59,135.78 27.59,135.21 27.39,135 26.07,135 25.77,134.7 25.77,133.96 26.07,133.66 27.26,133.66 27.46,133.45 27.46,132.76 27.26,132.55 25.69,132.55 25.39,132.25 25.39,131.56 25.69,131.26 26.46,131.26 26.66,131.05 26.66,129.34 v1(26.32,128.99)
  BOTTOM w0.102: v1(26.32,128.99) 26.64,128.67 26.64,128.01 26.54,127.92 U4000.20
MDI2-: length 29.5
  TOP w0.102: v1(27.97,142.33) 28.28,142.03 28.53,142.03 29.09,142.58 29.9,142.58
  IN1 w0.076: v1(26.95,128.99) 26.83,129.11 26.83,131.12 26.53,131.42 25.76,131.42 25.56,131.62 25.56,132.18 25.76,132.39 27.33,132.39 27.63,132.69 27.63,133.52 27.33,133.82 26.14,133.82 25.94,134.03 25.94,134.63 26.14,134.84 27.46,134.84 27.76,135.14 27.76,135.85 27.46,136.15 26.52,136.15 26.32,136.35 26.32,137.3 26.52,137.5 28.47,137.5 28.77,137.8 28.77,138.51 28.47,138.81 27.41,138.81 27.21,139.02 27.21,139.58 27.41,139.78 28.32,139.78 28.77,140.23 28.77,141.81 28.5,142.08 28.22,142.08 v1(27.97,142.33)
  BOTTOM w0.102: v1(26.95,128.99) 26.84,128.88 26.84,127.95 26.94,127.85 U4000.21
MDI3+: length 24
  TOP w0.102: v1(28.23,146.65) 28.48,146.9 28.73,146.9 29.24,146.39 U4001.11
  IN1 w0.076: v1(28.22,128.99) 28.57,129.34 28.57,131.86 29.75,133.04 29.75,145.91 28.66,147 28.4,147 28.23,146.82 v1(28.23,146.65)
  BOTTOM w0.102: v1(28.22,128.99) 28.43,128.78 28.43,128.52 27.74,127.83 U4000.23
MDI3-: length 24
  TOP w0.102: U4001.12 29.24,147.66 28.68,147.11 28.53,147.11 v1(28.23,147.41)
  IN1 w0.076: v1(28.86,128.99) 28.73,129.11 28.73,131.79 29.92,132.97 29.92,145.98 28.73,147.16 28.47,147.16 v1(28.23,147.41)
  BOTTOM w0.102: U4000.24 28.14,127.94 28.63,128.44 28.63,128.77 v1(28.86,128.99)
ME_UNLOCK#: length 110.4
  TOP w0.114: v3(266.94,27.92) 266.55,27.52 265.44,27.52 265.05,27.14 R6050.2 ; Q9006.2 254.84,86.76 255.18,87.09 256.45,87.09 256.72,87.37 256.72,88.46 v1(256.78,88.51)
  IN4 w0.076: v1(287.05,29.91) 287.05,29.67 286.18,28.79 285.41,28.79 284.34,27.72 280.17,27.72 279.75,27.29 267.57,27.29 v3(266.94,27.92)
  BOTTOM w0.114: U6001.G4 v3(266.94,27.92) ; v1(256.78,88.51) 256.78,88.56 257.45,89.23 259.35,89.23 260.06,89.94 260.19,89.94 260.34,90.08 260.94,90.08 262.11,88.91 262.11,88.31 262.41,88 262.41,87.67 263.31,86.77 263.31,86.44 264.19,85.55 264.19,85.31 265.66,83.84 265.66,83.47 265.41,83.23 265.41,82.95 266.43,81.93 267.14,81.93 268.64,80.43 268.84,80.43 269.5,79.77 269.93,79.77 272.29,77.41 272.31,77.41 274.8,74.91 275.98,74.91 281.09,69.8 281.09,67.8 283.37,65.52 283.37,63.9 280.46,60.98 280.46,57.36 282.45,55.36 282.68,55.36 283.95,54.09 283.95,53.18 283.72,52.95 283.72,49.52 284.39,48.86 284.39,44.22 284.76,43.85 284.76,42.69 283.62,41.56 283.62,38.57 284.16,38.04 284.61,38.04 286.85,35.8 286.85,34.41 287.58,33.68 287.58,30.84 287.05,30.32 v1(287.05,29.91)
MEM_VDD_CTRL: length 123
  TOP w0.114: v1(231.86,151.47) 231.45,151.07 231.45,150.87 PR8018.1
  IN2 w0.089: v1(219.2,99.69) 219.2,99.44 221.01,97.63 221.01,96.74 223.5,94.25 225.25,94.25 225.73,93.77 231.73,93.77 232.82,92.67 238.23,92.67 238.82,93.26 241.38,93.26 243.24,95.11 247.35,95.11 247.96,94.5 252.28,94.5 253.68,95.9 253.68,115.21 252.81,116.08 252.81,121.72 251.83,122.7 251.83,129.25 249.05,132.02 249.05,137.36 246.62,139.79 233.08,139.79 231.86,138.57 231.38,138.57 231.11,138.83 231.11,150.73 v1(231.86,151.47)
  BOTTOM w0.114: R2088.2 218.22,95.32 218.22,97.47 218.43,97.68 218.43,99.44 218.68,99.69 v1(219.2,99.69) 219.58,100.07 U2000.L3
MEM_VREF_CTL: length 108.4
  TOP w0.114: v1(231.71,141.29) 232.32,141.9 v1(232.32,142.2) 232.32,142.59 232.09,142.82 Q2500.2
  IN2 w0.089: v1(231.71,141.29) 233.03,139.97 246.69,139.97 249.23,137.43 249.23,132.1 252.01,129.32 252.01,122.77 252.99,121.79 252.99,116.15 253.85,115.29 253.85,95.82 252.36,94.32 247.89,94.32 247.28,94.93 243.31,94.93 240.49,92.12 v1(237.27,92.12) 233.13,92.12 231.68,93.56 225.69,93.56 225.18,94.07 223.19,94.07 220.81,96.45 v1(219.23,96.45)
  BOTTOM w0.102: 219.74,97.19 219.58,97.35 U2000.L1
  BOTTOM w0.114: R2081.2 219.67,95.5 219.67,96.01 v1(219.23,96.45) 219.74,96.96 219.74,97.19 ; v1(237.27,92.12) 237.13,91.98 Q2501.2
MEM_VREF_CTL_QA: length 3.4
  TOP w0.114: R2508.1 228.93,140.86 229.27,140.52 230.63,140.52 v1(230.79,140.68) 231.05,140.93 Q2500.3
MEM_VREF_CTL_QB: length 2.2
  BOTTOM w0.114: v1(238.16,92.29) 237.51,92.94 R2523.1 237.09,93.15 Q2501.3
MID1: length 4
  TOP w0.114: R9158.1 R9157.2 261.99,63.84 261.54,63.84 260.87,64.52 v1(260.87,64.81)
  BOTTOM w0.114: v1(260.87,64.81) 260.55,64.49 U9002.AM43
MID2: length 7.6
  BOTTOM w0.102: U9002.AM47 262.07,62.76 262.35,62.47 262.35,61.62 262.73,61.24
  BOTTOM w0.114: R9160.1 265.44,57.73 264.51,58.66 R9159.2 263.92,59.1 263.17,59.85 263.17,60.81 262.73,61.24
MOD_ID1_TBT: length 3.7
  BOTTOM w0.114: U8500.A8 v1(341.93,98.63) 341.93,98.67 341.5,99.1 341.5,99.56 R8506.1 R8505.2
MOD_ID2_TBT: length 4.2
  BOTTOM w0.114: U8500.A9 341.54,97.7 341.54,98.79 341.41,98.92 341.4,98.92 341.27,99.06 341.27,99.11 340.34,100.04 R8512.1 340.15,101.01 R8507.1
MODEM_CLKREQ: length 145.1
  TOP w0.114: v3(339.33,64.81) 339.33,65.7 338.84,66.18 337.14,66.18 336.99,66.33 336.99,68.04 336.1,68.92 R4132.1 ; v1(254.67,75.2) 254.36,75.2 v1(254.06,74.89) 254.06,74.36 254.16,74.26 254.16,73.62 253.6,73.07 253.34,73.07 ; v1(341.77,50.13) 341.77,50.63 343.55,52.4 343.55,55.61 342.95,56.21 342.95,60.07 342.22,60.8 v3(342.22,62.5)
  IN1 w0.076: v1(254.67,75.2) 255.43,74.44 255.43,73.62 256.45,72.61 256.45,71.27 257.74,69.98 257.74,69.36 260.46,66.64 260.46,66.21 260.99,65.67 261.4,65.67 262.08,64.99 262.67,64.99 263,64.66 263,63.59 264.7,61.89 264.7,59.78 264.45,59.53 264.45,57.11 264.76,56.8 266.79,56.8 267.14,56.45 267.14,56.22 271.05,52.31 271.05,51.53 273.41,49.17 276.03,49.17 278.75,46.45 280.7,46.45 282.23,44.92 283.91,44.92 284.37,44.46 287.41,44.46 288.86,43.02 295.03,43.02 295.82,42.23 298.38,42.23 298.85,41.76 306.72,41.76 307.09,41.39 311.41,41.39 313.72,39.08 319.97,39.08 320.58,38.47 331.56,38.47 333.32,40.22 333.89,40.22 335.82,42.15 335.82,45.35 338.83,48.36 338.83,49.25 339.71,50.13 v1(341.77,50.13)
  IN2 w0.089: v3(339.33,64.81) 339.33,64.73 340.06,64 341.15,64 341.73,63.43 341.73,62.99 v3(342.22,62.5)
  BOTTOM w0.102: U9002.BA17 254.56,75.78 254.67,75.67 v1(254.67,75.2)
MODEM_CLKREQ_R: length 2.3
  TOP w0.114: U4102.4 341.06,69.39 v1(341.08,69.41) 341.09,69.42 R4134.1
MP2949A_ADDR_P: length 5
  BOTTOM w0.203: PU19000.25 124.86,152.11 124.49,152.11 124.34,152.26 PR19031.1 123.61,152.45 123.18,152.88 122.84,152.88 v1(122.46,153.25) 122.84,153.63 122.84,154.14 123.1,154.4 PR19030.2
MP2949A_ALT#: length 2
  BOTTOM w0.114: PU19000.29 126.69,152.9 PR19023.1
MP2949A_EN: length 4.4
  BOTTOM w0.203: PU19000.37 130.46,151.13 130.85,151.53 131.49,151.53 PC19005.1 ; PC19005.1 132.46,150.56 v1(132.46,150.27) ; PC19005.1 132.71,151.86 PR19010.1
MP2949A_IMONA: length 11.9
  TOP w0.203: v1(122.21,150.46) 121.6,149.85 121.6,147.39 122.98,146.01 v1(125.23,146.01) PC19009.2 PR19041.2
  BOTTOM w0.203: PU19000.21 123.61,149.93 123.53,150.02 123.21,150.02 122.65,150.59 122.33,150.59 v1(122.21,150.46)
MP2949A_IMONB: length 10.1
  TOP w0.203: 124.36,146.91 PR19043.2 ; 124.36,146.91 PC19010.2 ; 124.36,146.91 v1(123.36,146.91) 122.78,146.91 121.95,147.74 121.95,149.35 122.68,150.08 122.68,150.65 122.4,150.93 122.37,150.93 v1(122.21,151.09)
  BOTTOM w0.203: PU19000.22 123.35,150.33 122.71,150.97 122.33,150.97 v1(122.21,151.09)
MP2949A_IMONC: length 3.6
  TOP w0.203: v1(123.49,150.92) 123.49,150.22 v1(123.5,150.2) 123.76,149.95 PC19011.2 PR19045.2
  BOTTOM w0.203: v1(123.49,150.92) 123.68,150.74 PU19000.23
MP2949A_IREF: length 2.2
  TOP w0.203: PR19036.2 123.72,151.6 v1(123.48,151.6)
  BOTTOM w0.203: PU19000.24 123.94,151.13 v1(123.48,151.6)
MP2949A_PE: length 6.7
  BOTTOM w0.114: PR19057.2 v1(134.9,151.97)
  BOTTOM w0.203: PU19000.36 129.74,152.14 130.01,152.14 130.47,152.59 131.59,152.59 131.86,152.86 PC19007.1 PR19034.1 133.88,152.86 PR19029.1 134.4,152.8 134.41,152.8 PR19057.2
MP2949A_SCL_P: length 2.9
  BOTTOM w0.114: PR19014.2 130.03,153.68 v1(129.55,153.2) 129.45,153.1 129.06,153.1 128.29,152.33 PU19000.33
MP2949A_SCLK: length 4.4
  BOTTOM w0.114: PU19000.27 125.89,153.12 PR19028.2 125.38,153.63 124.97,154.04 124.97,154.86 124.97,154.86 124.97,155.3 124.62,155.65 124.51,155.65 v1(124.49,155.67)
MP2949A_SDA_P: length 2.6
  BOTTOM w0.114: PR19016.2 129.29,153.66 127.89,152.25 PU19000.32
MP2949A_SDIO: length 4.1
  BOTTOM w0.114: v1(125.89,155.67) 125.89,154.01 126.28,153.63 PR19025.2 126.29,153.51 PU19000.28
MP2949A_SLP_SO#: length 6.8
  TOP w0.114: PR19005.1 131.03,154.4 v1(131.27,154.65) 130.84,155.08 v1(130.49,155.08)
  BOTTOM w0.114: PU19000.35 129.09,152.26 129.27,152.44 129.93,152.44 PR19012.2 130.49,153.2 130.77,153.48 130.99,153.48 131.15,153.64 131.15,154.52 130.59,155.08 v1(130.49,155.08)
MP2949A_STB: length 3.1
  BOTTOM w0.114: PU19000.34 128.69,152.24 129.14,152.69 129.65,152.69 130.77,153.81 PR19011.1
MP2949A_TEMP: length 6.9
  BOTTOM w0.114: PR19056.1 133.38,145.63 134.02,145 134.02,144.79 v1(134.06,144.74)
  BOTTOM w0.203: PU19000.45 130.72,147.93 130.78,148 131.6,148 132.29,147.31 132.84,147.31 PC19014.2 PR19056.1 133.22,145.48 PR19052.2
MP2949A_VDD18: length 3.4
  BOTTOM w0.203: PC19003.2 124.63,153.63 125.49,152.77 PU19000.26
  BOTTOM w0.508: PC19003.2 PR19030.1
MP2949A_VIN_SEN: length 6.1
  TOP w0.254: PR19008.2 PR19009.2 129.31,146.13 130.47,146.13 130.56,146.22 v1(131.99,146.22)
  BOTTOM w0.203: PU19000.47 130.74,147.13 131.1,146.78 PC19004.2 131.99,146.39 v1(131.99,146.22)
MP2949A_VRHOT#: length 2.1
  BOTTOM w0.114: PR19019.2 128.43,153.25 127.49,152.31 PU19000.31
MP2949A_VRRDY: length 2.8
  TOP w0.203: v1(127.41,152.87) 127.41,152.49 v1(127.16,152.24) 126.91,151.98 PR19021.1
  BOTTOM w0.114: PU19000.30 127.09,152.55 v1(127.41,152.87)
MPHY_EXT_PWR_GATE: length 2.1
  TOP w0.114: TP9016.1 256.88,70.83 v1(256.6,70.55) 256.17,70.55 R9068.1
  BOTTOM w0.114: U9002.AP29 256.6,70.1 v1(256.6,70.55)
MSR_ENABLE_N: length 7.1
  BOTTOM w0.114: v1(71.92,67.52) R406.2 72.68,66.64 73.38,67.34 76.55,67.34 76.73,67.52 CON400.60
NB679A_AGND: length 2.9
  BOTTOM w0.254: PR13001.2 PC13007.2 199.68,40.97 v1(199.52,40.81) 199.55,40.78 PU13000.10

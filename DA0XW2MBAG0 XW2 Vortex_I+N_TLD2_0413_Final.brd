# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMIC_3_D2_L: length 4.1
  TOP w0.114: v1(343.31,21.95) U3607.4 341.52,21.95 341.29,21.72 R3682.1 341.13,20.79 341.13,20.33 341.03,20.23 R3011.1
DMIC_3_D2_R: length 446.2
  TOP w0.114: v1(337.04,50.89) 337.83,50.1 337.83,48.4 339.76,46.47 339.76,45.06 338.37,43.67 338.37,34.96 338.97,34.36 338.97,32.64 339.43,32.18 339.93,32.18 340.35,31.76 340.35,29.77 339.63,29.05 339.63,27.65 339.07,27.09 337.7,27.09 337.34,26.74 337.34,23.59 337.68,23.25 U3607.1 340.47,23.25 340.7,23.03 340.7,21.14 R3682.2 340.19,20.95 v1(339.63,20.39)
  IN1 w0.076: v1(331.76,53.56) 332.54,53.56 334.78,51.32 335.9,51.32 336.33,50.89 v1(337.04,50.89) ; v1(339.63,20.39) 339.88,20.14 339.88,18.51 336.71,15.33 336.71,9.87 331.63,4.79 330.74,4.79 328.06,2.11 314.37,2.11 312.01,4.47 299.45,4.47 298.15,3.16 234.01,3.16 232.79,4.38 213.57,4.38 212.63,5.32 206.1,5.32 201.89,9.54 200.69,9.54 196.16,14.07 184.13,14.07 178.07,8.02 108.73,8.02 103.06,13.68 102.33,13.68 96.97,19.04 96.97,38.65 93.92,41.71 93.41,41.71 90.79,44.33 90.79,45.07 88.02,47.84 75.58,47.84 72.11,44.38 65.73,44.38 65.45,44.66 57.21,44.66 56.69,45.18 56.17,45.18 54.6,46.74 52.06,46.74 50.32,48.48 50.32,49.4 48.67,51.05 48.67,54.54 48.04,55.18 48.04,57.11 47.35,57.8 v1(47.35,59.81)
  IN3 w0.089: v1(331.76,53.56) 330.94,53.56 328.52,55.98 320.97,55.98 320.42,56.53 314.69,56.53 312.63,58.59 312.63,58.79 311.59,59.83 310.9,59.83 309.13,61.6 297.06,61.6 296.99,61.53 v1(296.4,61.53)
  BOTTOM w0.114: v1(47.35,59.81) 47.35,57.29 48.93,55.71 CON3000.34 ; R9616.1 295.67,60.81 v1(296.4,61.53)
DMIC_CLK1_R: length 3.9
  TOP w0.114: U3600.14 337.23,14.59 336.55,15.26 v1(336.12,15.26) 335.75,15.26 335.6,15.12 EC3603.2 R3618.2
DMIC_CLK2_R: length 7.2
  TOP w0.114: U3600.8 339.63,15.76 EC3605.2 340.29,16.42 340.29,17.17 v1(341.2,18.08) 341.56,18.44 341.56,19.33 341.94,19.71 R3629.2
DMUX_EDP_PD_SEL: length 2.9
  TOP w0.114: Q3004.3 54.39,62.83 v1(53.88,63.34) 53.88,63.59 54.27,63.98 R3058.1
DP0_CFG1: length 3.8
  BOTTOM w0.114: TP22053.1 348.77,32.09 349.28,31.59 351.29,31.59 351.42,31.46 R10002.2
DP0_CFG2: length 2.5
  BOTTOM w0.114: R10003.2 351.01,32.6 350.5,32.09 TP22054.1
DP1_CFG1: length 1.9
  BOTTOM w0.114: R10010.2 358.11,30.84 357.97,30.7 357.97,30.01 358.12,29.86 TP22060.1
DP1_CFG2: length 2.1
  BOTTOM w0.114: TP22059.1 357.6,29.86 357.72,29.99 357.72,30.73 357.61,30.84 R10009.2
DPSNK0_AUX_N: length 6.3
  BOTTOM w0.076: C8027.2 353.91,110.81 353.45,110.81 353.12,111.14 v5(353.12,111.65) 353.12,112.21 351.75,113.58 349.97,113.58 U8001.N2
DPSNK0_AUX_P: length 6.3
  BOTTOM w0.076: U8001.N1 350.22,113.95 350.3,114.03 350.41,114.03 350.51,113.92 350.51,113.81 350.59,113.73 v5(351.29,113.73) 351.81,113.73 353.27,112.27 353.27,111.2 353.51,110.96 353.96,110.96 354.14,111.14 C8025.2
DPSNK0_ML0_N: length 4.8
  BOTTOM w0.076: U8001.AB7 347.46,109.56 347.69,109.33 347.69,108.59 348.98,107.3 348.98,107.16 349.07,107.07 349.07,106.9
  BOTTOM w0.102: 349.07,106.9 349.07,105.81 C8014.2
DPSNK0_ML0_P: length 4.9
  BOTTOM w0.076: U8001.AC7 347.46,109.31 347.41,109.36 347.3,109.36 347.25,109.31 347.25,109.03 347.53,108.75 347.53,108.53 v5(347.95,108.12) 348.82,107.24 348.82,107.16 348.74,107.07 348.74,106.9
  BOTTOM w0.102: 348.74,106.9 348.74,105.81 C8008.2
DPSNK0_ML1_N: length 5
  BOTTOM w0.076: 346.65,106.9 346.65,106.92 346.74,107.01 346.74,108.03 346.61,108.16 346.61,108.73 346.31,109.03 346.31,109.29 346.39,109.36 346.49,109.36 346.54,109.31 U8001.AC9
  BOTTOM w0.102: C8010.2 346.65,105.76 346.65,106.1 v1(346.18,106.57) 346.55,106.57 346.65,106.67 346.65,106.9
DPSNK0_ML1_P: length 5
  BOTTOM w0.076: U8001.AB9 346.54,109.59 346.77,109.36 346.77,108.22 346.89,108.09 346.89,107.01 346.98,106.92 346.98,106.9
  BOTTOM w0.102: 346.98,106.9 346.98,106.67 347.08,106.57 v1(347.48,106.57) 346.98,106.07 346.98,105.87 C8016.2
DPSNK0_ML2_N: length 4.7
  BOTTOM w0.076: 345,106.9 345,107.08 344.91,107.16 344.91,107.42 v5(345.5,108) 345.85,108.35 345.85,109.42 U8001.AB11
  BOTTOM w0.102: C8019.2 345,105.81 345,106.9
DPSNK0_ML2_P: length 4.7
  BOTTOM w0.076: 344.67,106.9 344.67,107.06 344.76,107.15 344.76,107.48 345.69,108.42 345.69,108.71 345.37,109.03 345.37,109.24 345.47,109.34 345.55,109.34 345.62,109.27 U8001.AC11
  BOTTOM w0.102: C8018.2 344.67,105.81 344.67,106.9
DPSNK0_ML3_N: length 6.4
  BOTTOM w0.076: 342.56,106.9 342.56,106.92 342.65,107.01 342.65,107.47 343.33,108.14 344.34,108.14 344.7,108.5 344.7,108.81 344.48,109.03 344.48,109.31 344.53,109.36 344.65,109.36 344.7,109.31 U8001.AC13
  BOTTOM w0.102: C8023.2 342.61,105.79 342.61,106.1 v1(342.09,106.62) 342.49,106.62 342.56,106.69 342.56,106.9
DPSNK0_ML3_P: length 6.4
  BOTTOM w0.076: U8001.AB13 344.93,109.42 344.93,108.93 344.85,108.85 344.85,108.44 344.41,107.99 343.39,107.99 342.81,107.41 342.81,107.01 342.89,106.92 342.89,106.9
  BOTTOM w0.102: C8021.2 342.94,105.84 342.94,106.17 v1(343.39,106.62) 343,106.62 342.89,106.72 342.89,106.9
DPSNK1_AUX_N: length 8.5
  BOTTOM w0.076: C8042.2 355.36,109.62 353.84,109.62 352.69,110.77 352.69,112 351.59,113.1 349.99,113.1 U8001.P2
DPSNK1_AUX_P: length 8.5
  BOTTOM w0.076: C8040.2 355.79,109.84 355.83,109.79 355.83,109.57 355.76,109.49 355.69,109.49 355.42,109.77 v5(354.79,109.77) 353.9,109.77 352.84,110.83 352.84,112.07 351.66,113.25 350.3,113.25 U8001.P1
DPSNK1_ML0_N: length 3.9
  BOTTOM w0.076: U8001.B5 348.16,119.07 348.16,121.52 348.46,121.83 348.46,122.2 348.26,122.4 C8029.2
DPSNK1_ML0_P: length 4
  BOTTOM w0.076: U8001.A5 348.38,119.18 348.42,119.14 348.55,119.14 348.6,119.19 348.6,119.47 348.31,119.76 v5(348.31,120.79) 348.31,121.46 348.62,121.76 348.62,122.11 C8028.2
DPSNK1_ML1_N: length 3.8
  TOP w0.102: C8031.2 349.64,122.42 349.46,122.24 349.46,121.78 349.61,121.63 v1(349.69,121.63)
  BOTTOM w0.076: v1(349.69,121.63) 349.51,121.63 349.31,121.43 349.31,120.23 349.21,120.13 349.21,119.4 U8001.A3
DPSNK1_ML1_P: length 3.8
  TOP w0.102: C8030.2 349.13,122.32 349.13,121.71 v3(349.05,121.63)
  BOTTOM w0.076: v3(349.05,121.63) 349.16,121.53 349.16,120.3 349.05,120.19 349.05,119.09 U8001.B3
DPSNK1_ML2_N: length 5
  BOTTOM w0.076: U8001.C1 350.28,118.45 350.44,118.45 350.78,118.8 v5(350.78,119.34) 350.78,122.57 350.89,122.67 C8035.2
DPSNK1_ML2_P: length 5
  BOTTOM w0.076: C8033.2 350.63,122.47 v5(350.63,120.64) 350.63,118.86 350.37,118.61 349.98,118.61 U8001.C2
DPSNK1_ML3_N: length 7.2
  BOTTOM w0.076: C8039.2 352.41,122.67 352.3,122.57 352.3,122.34 v1(352.91,121.73) 352.3,121.12 352.3,120.91 351.67,120.27 351.67,118.43 350.78,117.54 350.29,117.54 U8001.E1
DPSNK1_ML3_P: length 7.2
  BOTTOM w0.076: C8037.2 352.15,122.47 352.15,122.26 v1(351.62,121.73) 352.15,121.2 352.15,120.97 351.52,120.33 351.52,118.49 350.72,117.69 349.98,117.69 U8001.E2
DPSRC_HPD: length 3.1
  TOP w0.076: 350.04,111.22 349.89,111.37 349.89,111.86 349.45,112.31 349.05,112.31 v3(348.73,112.63)
  TOP w0.114: R8013.1 350.28,110.98 350.04,111.22
  BOTTOM w0.114: U8001.R5 v3(348.73,112.63)
DPWROK: length 67.4
  TOP w0.127: v1(277.17,50.81) 277.07,50.71 276.86,50.71 275.8,49.65 275.8,43.82 274.86,42.88 v1(274.86,42.74) ; v1(276.37,60.9) 276.8,61.34 276.8,61.7 277.53,62.43 277.53,63.77 278.17,64.41 278.17,65.69 278.5,66.01 278.5,66.76 279.16,67.42 279.16,68.09 275.71,71.54 275.03,71.54 273.97,72.61 273.06,72.61 272.7,72.25 R9107.2 ; R6061.2 271.56,19.51 v1(271.56,19.14)
  IN2 w0.127: v1(274.86,42.74) 274.86,39.71 277.1,37.48 277.1,33.7 275.36,31.96 275.36,30.44 275.06,30.15 275.06,23.73 273.99,22.66 273.99,22.03 271.56,19.59 v1(271.56,19.14)
  BOTTOM w0.127: v1(277.17,50.81) 277.17,52.03 276.94,52.26 276.94,55.92 276.65,56.21 276.65,57.36 275.94,58.07 275.94,60.18 276.13,60.37 276.13,60.67 v1(276.37,60.9) ; v1(274.86,42.74) 274.99,42.61 PR25023.1 274.61,41.76 274.47,41.89 PU25001.4
DPWROK_EC: length 7.1
  TOP w0.076: 269.87,24.31 269.87,25.64 269.65,25.86
  TOP w0.114: 269.87,24.31 v1(269.54,23.98) 269.83,23.69 270.27,23.69 270.82,23.14 270.82,21.59 271.3,21.1 R6061.1 ; v3(269.54,25.97) 269.65,25.86
  BOTTOM w0.114: U6001.E7 v3(269.54,25.97)
DPWROK_R: length 11.7
  TOP w0.114: v1(262.41,68.3) 262.41,68.68 262.76,69.04 262.86,69.04 263.73,69.9 268.27,69.9 269.05,70.68 R9139.2 269.5,71.32 269.91,71.72 271.51,71.72 R9107.1
  BOTTOM w0.114: U9002.AW41 v1(262.41,68.3)
EARP_L1: length 5.2
  TOP w0.254: L3605.2 C3639.2 VC3601.1 ; VC3601.1 358.03,12.44 CON3601.1 ; VC3601.1 v1(356.63,13.3)
EARP_R1: length 11.8
  TOP w0.254: CON3601.2 360.7,4.27 359.44,3.01 356.93,3.01 v1(356.65,3.29) 356.16,3.78 VC3600.1 C3640.2 L3606.2
EC_HID_INTR: length 11.9
  BOTTOM w0.102: U9002.BE36 263.02,71.13 263.35,71.46 263.35,71.82 264.03,72.51 264.82,72.51 265.38,73.07 265.89,73.07 266.18,72.78 266.36,72.78
  BOTTOM w0.114: 266.36,72.78 266.36,72.78 267.94,72.78 268.33,73.16 269.28,73.16 270.71,74.6 271.03,74.6 271.25,74.82 272.33,74.82 R9196.2
EC_RST#: length 92.7
  TOP w0.114: v1(260.31,35.46) 260.88,36.03 R9026.1 261.26,36.15 261.62,36.51 262.59,36.51 263.13,35.98 263.13,33.39 262.67,32.93 262.67,32.5 262.92,32.25 263.63,32.25 264.75,31.14 v1(264.75,30.95) ; v1(265.61,72.4) 265.36,72.14 R9376.1
  IN2 w0.089: v1(264.75,30.95) 265.14,30.56 265.14,27.31 264.97,27.15 264.97,25.23 263.71,23.97 263.71,23.34 263.99,23.06 v1(263.99,21.55) ; v1(265.61,72.4) 265.61,70.47 267.71,68.38 268.39,68.38 269.65,67.11 269.65,64.96 269.25,64.56 269.25,59.88 266.07,56.71 266.07,55.11 261.78,50.81 261.78,48.1 257.41,43.73 257.41,41.25 255.81,39.65 253.62,39.65 250.4,36.43 250.4,36.03 248.35,33.98 v1(247.59,33.98)
  IN3 w0.114: v1(247.59,33.98) 248.56,33.98 249.79,35.22 254.82,35.22 255.17,35.57 260.19,35.57 v1(260.31,35.46)
  BOTTOM w0.102: v1(265.61,72.4) 265,71.78 264.67,71.78 264.1,71.2 263.75,71.2 263.64,71.09 U9002.BF38
  BOTTOM w0.114: R9009.2 266.61,18.79 266.4,19 266.4,19.6 264.95,21.05 264.5,21.05 v1(263.99,21.55)
EDP_AUXN_OUT: length 13.2
  TOP w0.114: U3007.31 62.27,68.53 v1(61.37,69.43) 61.3,69.36 60.65,69.36 R3060.1
  BOTTOM w0.114: C3015.2 53.98,63.63 53.98,63.85 56.29,66.16 56.3,66.17 57.06,66.93 58.08,66.93 60.41,69.27 61.21,69.27 v1(61.37,69.43)
EDP_AUXN_OUT_R: length 11.2
  BOTTOM w0.114: CON3000.19 56.43,54.45 56.53,54.55 56.53,55.19 54.15,57.58 54.15,60.46 R3039.1 53.97,60.93 54.17,61.13 54.17,61.25 v1(53.68,61.74) 54.09,61.74 54.17,61.81 54.17,62.05 C3015.1
EDP_AUXP_OUT: length 13.2
  TOP w0.114: R3061.1 60.45,69.06 61.11,69.06 v1(61.37,68.8) 61.59,68.8 61.83,68.56 61.83,68.34 62.04,68.13 U3007.32
  BOTTOM w0.114: C3014.2 54.42,63.32 54.27,63.46 54.27,63.73 v2(56.5,65.95) 57.18,66.64 58.2,66.64 60.53,68.98 61.2,68.98 v1(61.37,68.8)
EDP_AUXP_OUT_R: length 11.2
  BOTTOM w0.114: C3014.1 54.46,62.05 54.46,61.84 54.56,61.74 v1(54.95,61.74) 54.46,61.25 54.46,61.13 54.65,60.93 R3037.1 54.44,60.42 54.44,57.7 56.83,55.31 56.83,54.5 56.93,54.4 CON3000.18
EDP_DISP_UTIL: length 4.8
  BOTTOM w0.089: 181.24,124.88 180.41,124.05 U9001.A33
  BOTTOM w0.127: 181.24,124.88 181.5,125.14 182.86,125.14 183.29,125.57 TP9005.1
EDP_HPD: length 14.3
  TOP w0.114: v1(54.9,54.98) 55.16,55.24 R3001.2 Q3005.2 56.78,58.79 56.67,58.89 56.67,60.42 56.14,60.95 56.14,64.37 v1(55.78,64.73) R3056.1
  BOTTOM w0.114: CON3000.21 55.43,54.44 v1(54.9,54.98)
EDP_RCOMP: length 8.9
  BOTTOM w0.114: U9001.D37 177.41,126.46 177.68,126.73 177.68,127.24 177.68,127.24 178.8,128.36
  BOTTOM w0.254: 178.8,128.36 179.89,128.36 v1(182.73,131.21) 182.91,131.03 R9038.2
EDP_TXN0_OUT: length 7.9
  TOP w0.114: v1(60.89,63.03) 60.89,62.9 60.96,62.83 61.88,62.83 61.99,62.93 U3007.45
  BOTTOM w0.114: C3012.2 56.68,60.93 56.51,61.1 56.51,61.75 57.13,62.36 60,62.36 60.24,62.6 60.46,62.6 v1(60.89,63.03)
EDP_TXN0_OUT_R: length 7.8
  BOTTOM w0.114: C3012.1 56.7,59.8 56.7,59.37 56.9,59.17 v1(57.21,59.17) 56.7,58.66 56.7,56.83 58.33,55.21 58.33,54.64 58.43,54.53 CON3000.15
EDP_TXN1_OUT: length 9.6
  TOP w0.114: U3007.42 61.8,64.13 61.73,64.06 61.07,64.06 60.82,64.31 60.82,64.43 v1(60.87,64.48)
  BOTTOM w0.114: C3010.2 58.59,60.93 58.51,61.01 58.51,61.46 58.61,61.56 60.92,61.56 v2(61.21,61.85) 61.68,62.31 61.68,63.64 61.4,63.92 60.82,63.92 60.65,64.09 60.65,64.4 60.73,64.48 v1(60.87,64.48)
EDP_TXN1_OUT_R: length 7.7
  BOTTOM w0.114: CON3000.12 59.93,54.54 59.83,54.64 59.83,55.02 59.37,55.48 57.94,56.9 57.94,58.69 58.68,59.43 58.68,59.75 C3010.1
EDP_TXN2_OUT: length 4.8
  TOP w0.114: U3007.39 61.54,65.33 v1(61.5,65.37)
  BOTTOM w0.114: C3009.2 62.77,63.42 62.66,63.54 62.66,64.49 62.01,65.14 62.01,65.65 61.88,65.78 61.65,65.78 61.5,65.62 v1(61.5,65.37)
EDP_TXN2_OUT_R: length 12.7
  BOTTOM w0.114: C3009.1 62.96,62.64 62.81,62.49 62.81,61.32 61.82,60.33 v1(61.82,59.65) 61.14,59.65 60.78,59.29 59.79,59.29 59.05,58.55 59.05,57.84 61.35,55.53 61.35,54.61 61.43,54.53 CON3000.9
EDP_TXN3_OUT: length 9.3
  TOP w0.114: U3007.36 61.7,66.53 61.34,66.89 v1(61.32,66.89)
  BOTTOM w0.114: C3002.2 64.59,60.94 64.59,61.34 63.99,61.94 63.99,65.07 62.17,66.89 v1(61.32,66.89)
EDP_TXN3_OUT_R: length 8.7
  BOTTOM w0.114: CON3000.6 62.93,54.54 62.83,54.64 62.83,55.09 63.26,55.52 63.7,55.52 64.12,55.94 64.12,55.97 65.25,57.09 65.25,57.35 65.25,57.72 64.43,58.53 64.43,58.79 64.64,58.99 v1(64.93,58.99) 64.43,59.49 64.43,59.84 64.56,59.98 C3002.1
EDP_TXP0_OUT: length 7.9
  TOP w0.114: U3007.46 60.75,62.53 v1(60.26,63.03)
  BOTTOM w0.114: C3013.2 56.22,61.12 56.22,61.87 57,62.65 59.87,62.65 v1(60.26,63.03)
EDP_TXP0_OUT_R: length 7.8
  BOTTOM w0.114: CON3000.16 57.93,54.54 58.04,54.64 58.04,55.08 56.41,56.71 56.41,58.7 v1(55.94,59.17) 56.23,59.17 56.41,59.35 56.41,59.78 C3013.1
EDP_TXP1_OUT: length 9.6
  TOP w0.114: v1(60.23,64.48) 60.94,63.77 61.85,63.77 61.88,63.79 61.93,63.79 61.99,63.73 U3007.43
  BOTTOM w0.114: v1(60.23,64.48) 60.32,64.39 60.36,64.35 60.36,63.97 60.7,63.63 61.28,63.63 61.39,63.52 61.39,62.43 60.8,61.85 58.49,61.85 58.22,61.58 58.22,61.08 C3011.2
EDP_TXP1_OUT_R: length 7.6
  BOTTOM w0.114: CON3000.13 59.43,54.54 59.54,54.64 59.54,54.9 59.25,55.19 57.65,56.78 57.65,58.81 58.08,59.24 58.39,59.55 58.39,59.84 C3011.1
EDP_TXP2_OUT: length 4.7
  TOP w0.114: v1(60.87,65.37) 61.3,64.93 U3007.40
  BOTTOM w0.114: C3001.2 62.36,63.57 62.36,64.37 61.8,64.94 61.3,64.94 v1(60.87,65.37)
EDP_TXP2_OUT_R: length 12.6
  BOTTOM w0.114: C3001.1 62.35,62.64 62.52,62.47 62.52,61.44 61.55,60.47 v1(60.85,60.47) 60.85,59.77 60.65,59.58 59.66,59.58 58.76,58.67 58.76,57.72 61.06,55.41 61.06,54.66 60.93,54.54 CON3000.10
EDP_TXP3_OUT: length 9.3
  TOP w0.114: U3007.37 61.45,66.13 v1(61.32,66.26)
  BOTTOM w0.114: C3003.2 64.18,60.76 64.3,60.87 64.3,61.21 63.7,61.82 63.7,64.95 v2(62.99,65.66) 62.05,66.6 61.67,66.6 v1(61.32,66.26)
EDP_TXP3_OUT_R: length 8.7
  BOTTOM w0.114: C3003.1 64.02,59.98 64.14,59.86 64.14,59.48 v1(63.66,58.99) 63.96,58.99 64.14,58.82 64.14,58.41 64.38,58.17 64.95,57.6 64.95,57.21 63.83,56.09 63.83,56.06 63.58,55.81 63.14,55.81 62.54,55.21 62.54,54.64 62.43,54.54 CON3000.7
EN: length 4.8
  TOP w0.114: R634.2 55.79,49.62 56.3,49.11 57.17,49.11 C634.1 58.25,49.62 v1(58.5,49.87) 59,50.38 U603.7
EN_1V05A: length 5.5
  TOP w0.127: v1(310.93,59.91) 310.64,60.2 R9287.2 309.02,60.2 R9286.1 309.02,60.55 309.27,60.8 R9288.2 C9250.2 309.27,62.47 308.91,62.83 PR18008.1
EN_1V8: length 122
  TOP w0.508: PR16013.1 299.49,14.1 v1(299.55,14.16) ; R9275.2 203.54,19.5 199.24,15.21 199.24,14.76 200.09,13.91 v1(200.21,13.91)
  IN1 w0.508: v1(299.55,14.16) 298.81,14.16 296.5,11.85 295.59,11.85 292.09,8.36 292.09,7.44 290.84,6.19 274.12,6.19 272.71,7.6 268.65,7.6 267.75,6.69 v1(267.75,6.03)
  IN4 w0.508: v1(267.75,6.03) 266.12,4.41 256.32,4.41 255.81,4.92 250.44,4.92 249.99,4.47 241.42,4.47 240.6,5.3 239.88,5.3 238.68,4.09 234.65,4.09 233.56,5.18 217.21,5.18 216.51,5.88 207.35,5.88 200.18,13.04 200.18,13.88 v1(200.21,13.91)
EN_2V5: length 12.1
  BOTTOM w0.127: PR15002.1 205.64,22.16 v1(199.65,22.16) 198.41,22.16 197.64,22.92 197.64,24.5 197.85,24.71 R9280.2 R9281.2
EN_3V: length 62.5
  TOP w0.114: v1(201.23,45.05) 201.05,44.87 200.74,44.87 200.49,44.62 195.15,44.62 194.49,43.96 190.31,43.96 189.74,43.4 189.74,40.12 190.79,39.08 190.79,31.42 191.95,30.25 191.95,27.63 192.28,27.29 197.28,27.29 200.68,23.9 200.68,22.97 v1(200.95,22.7) 201.33,22.32 201.33,21.66 201.63,21.35 R9274.2
  IN3 w0.089: v1(201.23,45.05) 201.73,44.54 202.93,44.54 203.44,44.03 206.7,44.03 207.13,43.6 215.86,43.6 216.69,42.76 v1(216.69,39.46)
  BOTTOM w0.254: PR13014.2 v1(216.69,39.46)
EN_5V: length 63.5
  TOP w0.254: v1(201.96,43.65) 201.29,44.33 195.28,44.33 194.61,43.66 190.53,43.66 190.09,43.21 190.09,40.2 191.08,39.2 191.08,31.54 192.25,30.38 192.25,27.76 192.42,27.59 197.4,27.59 200.97,24.02 200.97,23.68 201.45,23.2 201.45,22.66 R9273.2 201.75,22.61 202.2,23.07 209.32,23.07 212.12,25.87 212.12,28.23 210.22,30.14 v1(210.22,31.08)
  BOTTOM w0.114: PR13022.1 212.21,31.83 212.07,31.69 212.07,31.26 211.46,30.65 210.65,30.65 v1(210.22,31.08)
  BOTTOM w0.254: PR13006.1 201.71,43.14 201.96,43.4 v1(201.96,43.65)
EN_5V_3V: length 400.5
  TOP w0.114: v1(191.5,29.56) 191.55,29.51 191.55,27.71 192.22,27.04 197.15,27.04 200.41,23.78 200.41,22.47 201.07,21.81 201.07,21.22 201.48,20.82 202.05,20.82 R9277.2 R9274.1 R9273.1 203.53,22.37 R9275.1 203.96,22.38 205.28,21.06 211.73,21.06 219.83,29.17 220.59,29.17 222.26,30.83 222.26,31.84 223.74,33.33 225.98,33.33 v1(226.44,33.79) ; R6177.1 254.41,44.29 v1(254.29,44.16) ; PR18011.1 307.19,59.76 307.17,59.75 v1(307.17,58.85) ; R6174.2 254.55,51.01 v1(254.79,50.76) ; U6402.3 127.72,113.05 R6403.2 127.79,112.62 128.05,112.36 129.06,112.36 v1(129.45,112.74)
  IN1 w0.076: v1(254.29,44.16) 254.29,44.11 254.82,43.58 256.14,43.58 256.41,43.31 256.41,42.88 261.07,38.22 263.4,38.22 263.99,37.63 267.6,37.63 268.43,36.79 270.24,36.79 271.28,35.75 275.16,35.75 275.37,35.55 275.37,34.69 275.85,34.2 278.01,34.2 278.9,33.31 279.36,33.31 281.54,31.13 287.24,31.13 288.67,32.55 294.39,32.55 295.84,31.1 297.31,31.1 298.81,29.61 301.1,29.61 302.9,27.8 v1(302.9,25.47)
  IN2 w0.089: v1(244.2,33.06) 244.2,34.88 245.2,35.89 246.13,35.89 248.68,38.44 249.09,38.44 249.66,39.02 249.66,39.7 250.34,40.38 251.5,40.38 252.9,41.78 252.9,42.4 254.29,43.78 v1(254.29,44.16) 254.29,44.92 254.92,45.56 254.92,50.64 v1(254.79,50.76)
  IN4 w0.076: v1(129.45,112.74) 129.45,109.42 126.94,106.91 126.94,104.2 120.5,97.76 120.5,96.71 120.15,96.35 119.41,96.35 119.19,96.14 119.19,95.83 119.88,95.14 119.88,93.8 119.06,92.97 119.06,89.08 108.71,78.73 108.71,56.09 107.71,55.09 107.71,48.68 110.37,46.01 110.37,39.37 108.83,37.82 108.83,30.64 114.18,25.29 120.44,25.29 121.54,24.2 140.99,24.2 145.08,20.1 159.53,20.1 162.8,16.84 172.08,16.84 172.5,16.42 175.09,16.42 177.27,18.6 178.71,18.6 179.35,19.23 179.35,21.37 183.49,25.52 185.97,25.52 190.01,29.56 v1(191.5,29.56)
  BOTTOM w0.114: v1(226.44,33.79) 226.65,33.57 227.27,33.57 v1(227.92,34.22) 229.3,34.22 230.28,33.24 231.8,33.24 233.11,31.92 235.66,31.92 236.64,30.95 241.78,30.95 243.89,33.06 v1(244.2,33.06) ; v1(302.9,25.47) 303.51,25.47 306.28,28.23 306.28,36.03 306.62,36.37 306.62,38.33 306.97,38.68 306.97,38.71 308.59,40.33 308.59,42.79 309.1,43.3 309.1,44.83 310.74,46.46 310.93,46.46 311.94,47.47 313.46,47.47 313.72,47.21 315.8,47.21 317.13,48.54 317.13,50.26 318.04,51.17 318.04,52.03 317.63,52.44 315.93,52.44 315.27,53.1 315.27,55.69 313.21,57.75 308.21,57.75 307.17,58.79 v1(307.17,58.85)
EN_P1V5S: length 198.5
  TOP w0.127: v1(102.31,18.66) 101.88,18.66 100.96,19.58 100.96,20.52 100.92,20.56 PR16015.1 ; v1(263.68,19.14) 263.81,19.01 R9285.2 264.31,19.5 C9251.2
  IN2 w0.127: v1(263.68,19.14) 263.94,18.89 263.94,14.65 264.71,13.87 264.71,12.72 265.28,12.16 265.28,7.55 264.49,6.76 262.55,6.76 261.97,7.33 250.6,7.33 249.84,6.57 246.38,6.57 246.36,6.54 245.7,6.54 244.53,7.71 240.94,7.71 240.19,8.46 237.03,8.46 236.73,8.75 227.07,8.75 225.39,10.43 211.59,10.43 v1(211,11.01)
  IN4 w0.127: v1(102.31,18.66) 102.31,16.41 109.21,9.51 112.34,9.51 115,6.85 176.09,6.85 187.04,17.79 203.32,17.79 206.23,14.89 206.23,12.69 207.29,11.62 210.39,11.62 v1(211,11.01)
EN_PVCCIO: length 2
  BOTTOM w0.127: R9283.2 PR17010.1 187.99,152.36 187.74,152.62 v1(187.36,152.62)
EN_USB5V: length 88.8
  TOP w0.114: v1(212.53,31.18) 212.53,29.81 212.83,29.5 212.83,25.57 v1(208.77,21.5)
  IN3 w0.089: v1(262.92,24.91) 262.72,24.91 258.91,28.72 257.54,28.72 256.39,29.87 252.31,29.87 250.91,28.46 239.94,28.46 234.49,23.01 223.18,23.01 217.84,17.67 217.84,16.65 216.46,15.27 213.64,15.27 212.78,14.42 210.2,14.42 209.4,13.62 v1(209.4,13.43)
  BOTTOM w0.114: v1(208.77,21.5) 208.77,20.92 207.02,19.17 207.02,16.25 209.4,13.86 v1(209.4,13.43) ; U6001.D2 265.65,25.96 263.9,25.96 v1(262.92,24.91) ; PR13025.1 212.11,30.77 v1(212.53,31.18)
EN_VRPVDDQ: length 155.1
  TOP w0.127: v1(103.41,69.68) 102.53,68.8 PR14009.1
  IN2 w0.127: v1(201.83,23.93) 200.93,24.83 190.5,24.83 189.95,24.28 187.79,24.28 187.19,23.69 171.37,23.69 170.29,22.6 163.28,22.6 162.5,23.38 142.01,23.38 141.23,22.6 136.91,22.6 136.3,23.2 105.62,23.2 102.72,26.1 102.72,28.97 101.23,30.47 101.23,38.65 97.95,41.92 v1(97.95,43.52)
  BOTTOM w0.127: v1(97.95,43.52) 97.95,45.15 103.82,51.02 103.82,61.79 102.52,63.08 102.52,68.79 v1(103.41,69.68) ; v1(201.83,23.93) 201.95,24.06 R9279.2 201.45,24.57 201.37,24.66 D9001.2
EN_VRPVTT: length 2
  TOP w0.127: R9282.2 102.53,71.34 v1(102.83,71.34) 102.32,70.83 PR14007.1
ENABLT: length 11.2
  TOP w0.114: R3050.1 250.65,39.44 250.65,37.74 250.48,37.57 U3009.4 249.98,37.05 250.35,36.67 v1(250.35,35.65) 249.89,35.19 R3036.2 249.39,35.34 248.88,35.85 U49.2
ENAVDD: length 250
  TOP w0.114: U3000.3 51.66,51.6 51.59,51.53 R3010.2 R3024.2 53.77,50.9 v1(53.85,50.81) ; v1(203.86,12.79) 204.52,13.45 204.52,15.32 206.71,17.52 212.52,17.52 220.98,25.97 221.17,25.97 227.12,25.97 233.65,32.5 235.85,32.5 238.07,31.58 239.04,31.39 240.02,31.39 240.99,31.58 241.43,31.76 242.3,31.76 244.03,33.49 246.67,33.49 247.3,32.86 249.13,32.86 251.37,35.09 253.85,35.09 254.54,35.78 254.54,36.68 R3049.1 253.91,38.07 254.14,38.3 U3008.4
  IN1 w0.076: v1(203.86,12.79) 203.16,13.5 203.16,15.58 200.47,18.26 182.27,18.26 178.21,14.2 112.09,14.2 104.61,21.68 103.6,21.68 100.88,24.4 100.88,30 99.26,31.63 99.26,39.92 94.71,44.46 93.94,44.46 93.28,45.13 93.28,45.82 88.95,50.14 74.44,50.14 72.92,48.62 69.92,48.62 69.09,49.45 65.76,49.45 65.52,49.69 62.15,49.69 61.93,49.48 61.39,49.48 61.25,49.62 57.69,49.62 56.04,51.27 54.31,51.27 v1(53.85,50.81)
ENVDD_GFX: length 102.9
  TOP w0.114: U3008.3 251.71,38.3 251.44,38.04 251.44,36.43 251.32,36.31 251.32,36.06 251.31,36.06 251.31,35.88 250.04,34.61 249.03,34.61 247.8,33.38 v1(247.4,33.38)
  IN2 w0.089: v1(224.09,80.02) 224.09,78.53 226.22,76.39 226.22,71.26 230.24,67.24 230.24,41.92 229.81,41.5 229.39,41.5 229.13,41.24 229.13,40 v1(229.55,39.59) ; v1(233.94,88.97) 233.74,88.76 229.78,88.76 229.09,88.07 227.46,88.07 227.08,87.7 v1(226.89,87.7)
  BOTTOM w0.114: v1(224.09,80.02) 224.54,80.48 224.95,80.48 225.71,81.24 225.71,82.04 226.29,82.62 226.29,86.41 226.73,86.85 226.73,87.54 v1(226.89,87.7) ; v1(229.55,39.59) 229.12,39.16 229.12,38.74 229.39,38.47 230.36,38.47 230.87,37.96 230.87,35.46 233.3,33.03 233.49,32.84 236.04,32.84 237.02,31.86 241.4,31.86 243.71,34.17 244.81,34.17 245.33,33.65 247.12,33.65 v1(247.4,33.38) ; R2234.2 R2151.1 236.88,87.12 232.36,87.12 232.24,87.24 232.24,87.76 232.35,87.87 U2009.4 233.48,87.87 233.94,88.33 v1(233.94,88.97)
ENVDD_GFX_R: length 31.5
  IN2 w0.089: v1(219.18,102.1) 219.21,102.1 219.59,101.72 220.25,101.72 220.78,101.18 220.78,99.26 221.27,98.78 221.27,96.74 223.55,94.45 225.32,94.45 225.83,93.94 233.97,93.94 v1(234.47,93.44)
  BOTTOM w0.114: v1(234.47,93.44) 234.65,93.61 235.24,93.61 235.49,93.36 235.49,91.56 235.74,91.3 235.74,90.73 235.9,90.58 235.9,90.44 236.57,89.77 R2113.2 ; U2009.1 235.79,89.17 236.15,89.52 R2113.2 ; U2009.2 236.53,88.52 R2234.1 R2113.2
  BOTTOM w0.127: v1(219.18,102.1) 219.18,102.1 U2000.M5
ENVDD_PCH: length 49.4
  TOP w0.114: U3008.1 252.75,39.6 253.06,39.29 253.06,37.84 253.13,37.76 R3049.2 253.13,36.67 253.01,36.54 R9328.1 252.75,35.65 252.23,35.65 v1(251.75,36.13)
  IN1 w0.076: v1(263.23,66.93) 263.23,66.49 263.86,65.86 263.86,63.96 265.64,62.18 265.64,60.67 267.47,58.84 267.96,58.84 269.31,57.5 v1(269.31,56.36)
  IN2 w0.089: v1(251.75,36.13) 252.31,36.7 252.31,37.08 253.28,38.04 253.83,38.04 254.38,38.6 255.84,38.6 258.17,40.93 258.17,43.35 263.35,48.53 263.77,48.53 264.71,49.46 264.71,52.4 267.49,55.18 268.18,55.18 269.06,56.06 269.06,56.15 269.27,56.36 v1(269.31,56.36)
  BOTTOM w0.114: v1(263.23,66.93) 263.23,66.64 263.11,66.52 U9002.AV44
ESPI_CLK_EC: length 79.4
  TOP w0.114: R9066.1 268.81,75.53 269.4,75.53 269.75,75.88 270.19,75.88 270.21,75.86 271.94,75.86 272.63,75.17 274.58,75.17 276.03,73.72 276.61,73.72 281.36,68.97 281.36,66.54 280.85,66.03 280.85,63.7 279.91,62.75 279.91,61.67 279.34,61.1 279.34,57.4 278.44,56.5 278.44,54.77 v1(278.32,54.64)
  IN2 w0.089: v1(278.32,54.64) 278.32,54.52 278.04,54.23 278.04,51.03 277.15,50.14 277.15,50.03 275.67,48.55 274.2,48.55 270.57,44.92 270.57,44.33 271.77,43.13 271.77,38.9 268.66,35.79 268.66,35.35 268.06,34.74 268.06,34.66 264.95,31.56 v1(264.93,31.56) 265.67,30.82 265.67,27.16 265.62,27.11 265.46,26.95 265.46,24.05 265.78,23.73 265.78,21.69 265.55,21.47 265.55,19.43 v1(265.84,19.14)
  BOTTOM w0.114: v1(264.93,31.56) 264.93,31.64 263.53,33.04 263.53,34.23 R6134.2 ; R9008.2 v1(265.84,19.14)
ESPI_CLK_EC_R: length 10.2
  TOP w0.114: v3(260.94,70.55) 260.94,70.62 262.26,71.95 262.95,71.95 264.2,73.2 264.2,73.46 264.35,73.6 v1(265.21,73.6) 265.89,73.6 267.05,74.77 267.75,74.77 R9066.2
  BOTTOM w0.114: U9002.BB36 261.36,70.12 v3(260.94,70.55)
ESPI_CS#: length 86.6
  IN2 w0.089: v1(261.78,19.17) 261.78,21.13 261.28,21.63 261.28,26.25 260.24,27.28 260.24,29.72 260.69,30.16 260.69,31.49 261.45,32.25 261.45,32.53 262.02,33.1 262.68,33.1 264.7,35.13 v1(264.7,35.27) ; v1(250.88,36.13) 250.88,36.31 253.09,38.51 253.63,38.51 254.22,39.11 255.68,39.11 257.7,41.13 257.7,43.61 262.08,48 262.08,50.71 266.38,55 266.38,56.73 269.69,60.04 269.69,62.64 270.15,63.11 270.15,67.03 268.41,68.77 268.41,68.9 268.46,68.95 268.46,69.31 268.34,69.42 267.63,69.42 267.43,69.63 267.3,69.63 267.15,69.48 267,69.48 266.82,69.66 266.82,69.81 266.97,69.96 266.97,70.09 266.76,70.29 266.63,70.29 266.43,70.09 266.38,70.09 266.05,70.42 266.05,70.55 266.4,70.9 266.4,71.01 266.05,71.36 v1(266.05,71.94)
  IN3 w0.089: v1(264.7,35.27) 264.09,35.88 255.05,35.88 254.69,35.52 251.49,35.52 v1(250.88,36.13)
  BOTTOM w0.089: U9002.BE38 263.54,70.72 263.83,71.01 264.19,71.01 264.19,71.01
  BOTTOM w0.102: 264.19,71.01 264.76,71.58 265.69,71.58 v1(266.05,71.94)
  BOTTOM w0.114: R6004.2 264.95,35.02 v1(264.7,35.27) ; R9003.2 262.03,18.91 v1(261.78,19.17)
ESPI_CS#_L: length 4.2
  BOTTOM w0.114: R6004.1 264.97,33.86 265.77,33.07 v1(265.77,32.63) 265.65,32.52 265.65,30.51 U6001.L2
ESPI_CS#_L_R: length 2.7
  BOTTOM w0.114: JCN9000.6 262.74,16.94 262.14,17.54 262.06,17.54 v1(262.03,17.57) R9003.1
ESPI_EC_IO0: length 8.1
  TOP w0.114: R9061.2 267.98,71.65 267.07,70.75 264.94,70.75 264.74,70.94 264.23,70.94 263.86,70.58 263.49,70.58 262.59,69.68 262.49,69.68 262.35,69.54 v1(262.07,69.54)
  BOTTOM w0.114: v1(262.07,69.54) 262.38,69.24 U9002.BB39
ESPI_EC_IO0_L: length 77
  TOP w0.114: v1(278.29,60.21) 278.29,61.36 278.79,61.86 278.79,63.04 v1(278.97,63.22) 279.88,64.13 279.88,66.35 280.43,66.9 280.43,68.61 276.23,72.81 275.65,72.81 274.2,74.25 271.3,74.25 270.03,72.98 268.76,72.98 R9061.1
  IN2 w0.089: v1(278.29,60.21) 278.24,60.26 278.24,61 278.15,61.09 277.88,61.09 277.79,61 277.79,59.34 276.56,58.1 276.56,51.55 276.12,51.11 276.12,50.24 275.3,49.43 273.85,49.43 269.63,45.21 269.63,43.37 270.69,42.3 270.69,40.77 270.28,40.36 270.28,38.68 267.2,35.6 267.2,35.06 266.29,34.16 265.4,34.16 264.35,33.11 264.35,32.21 263.37,31.22 263.37,30.82 263,30.44 262.77,30.44 262.5,30.17 262.5,29.52 v1(262.92,29.1) 262.5,28.68 262.5,24.79 262.5,24.78 262.5,22.97 v1(263.1,22.37)
  BOTTOM w0.114: v1(263.1,22.37) 263.35,22.11 263.35,21.5 263.74,21.12 R9007.2 ; v1(262.92,29.1) 262.91,29.13 261.94,29.13 R6138.2
ESPI_EC_IO0_R: length 4
  BOTTOM w0.114: U6001.H1 263.78,28.24 v1(263.63,28.39) 263.42,28.6 263.42,29.29 263.13,29.57 262.31,29.57 R6138.1
ESPI_EC_IO0_R_R: length 5.8
  BOTTOM w0.114: R9007.1 264.6,20.72 v1(264.93,20.39) 265.11,20.21 265.11,18.84 264.65,18.38 264.65,17.9 264.88,17.67 264.88,17.26 264.74,17.13 JCN9000.10
ESPI_EC_IO1: length 12.1
  TOP w0.114: R9062.2 270.37,72.56 269.21,72.56 267.15,70.5 264.6,70.5 v1(264.57,70.53) 264.41,70.36 263.58,70.36 262.68,69.47 262.58,69.47 262.51,69.39 262.05,68.94 261.06,68.94 v1(260.71,69.29)
  BOTTOM w0.114: U9002.AW37 261.07,68.93 v1(260.71,69.29)
ESPI_EC_IO1_L: length 76.9
  TOP w0.114: R9062.1 271.64,73.83 274.03,73.83 275.47,72.39 276.06,72.39 280.01,68.44 280.01,67.07 279.34,66.41 279.34,65.28 279.03,64.96 279.03,64.07 278.37,63.42 278.37,62.06 278.11,61.8 277.93,61.62 277.73,61.42 v1(277.73,59.5) v1(278.29,58.94)
  IN2 w0.089: v1(278.29,58.94) 277.81,58.46 277.81,56.47 277.72,56.38 277.49,56.38 277.4,56.47 277.4,57.94 277.31,58.03 277.06,58.03 276.97,57.94 276.97,51.4 276.51,50.95 276.51,50.08 275.47,49.04 274.01,49.04 270.08,45.11 270.08,44.13 271.29,42.93 271.29,39.13 270.68,38.52 270.67,38.52 268.59,36.43 267.59,35.43 267.59,34.89 264.36,31.66 264.36,30.6 264.19,30.42 263.63,30.42 263.24,30.02 v1(262.92,30.02) 263.49,29.46 263.49,28.41 263.68,28.21 263.68,27.7 263.93,27.45 263.93,25.21 263.1,24.37 263.1,23.03 263.56,22.57 263.56,22.27 263.26,21.97 263.16,21.97 v1(262.9,21.71)
  BOTTOM w0.114: v1(262.92,30.02) 262.06,30.02 R6137.2 ; R9006.2 263.3,19.95 262.9,20.36 v1(262.9,21.71)
ESPI_EC_IO1_R: length 3.9
  BOTTOM w0.114: U6001.J1 264.88,28.89 264.22,29.55 263.74,29.55 263.35,29.95 263.35,30.2 263.05,30.5 262.75,30.5 262.68,30.57 R6137.1
ESPI_EC_IO1_R_R: length 4.4
  BOTTOM w0.114: R9006.1 264.19,19.43 264.37,19.25 v1(264.37,19.19) 264.37,18.08 264.01,17.72 264.01,17.03 264.24,16.8 JCN9000.9
ESPI_EC_IO2: length 9.8
  TOP w0.114: v1(260.89,68.35) 261.25,68.72 262.14,68.72 262.6,69.17 262.67,69.25 262.77,69.25 263.64,70.12 267.42,70.12 v1(267.62,70.32) R9063.2
  BOTTOM w0.114: v1(260.89,68.35) 260.65,68.59 U9002.AV37
ESPI_EC_IO2_L: length 80.3
  TOP w0.114: R9063.1 269.44,72.14 270.71,72.14 271.83,73.26 273.95,73.26 275.24,71.97 275.89,71.97 279.59,68.27 279.59,67.25 278.92,66.58 278.92,65.45 278.6,65.13 278.6,64.24 277.95,63.59 277.95,62.24 277.81,62.1 277.63,61.92 277.27,61.56 277.27,60.92 v1(277.15,60.8) 276.69,60.34 276.69,60.32 v1(276.37,60)
  IN2 w0.089: v1(276.37,60) 276.48,60 276.84,60.37 276.84,62.03 276.93,62.12 277.26,62.12 277.35,62.03 277.35,59.48 276.16,58.28 276.16,51.71 275.72,51.27 275.72,50.41 275.21,49.9 273.76,49.9 269.15,45.29 269.15,43.29 270.3,42.14 270.3,40.93 269.89,40.52 269.89,38.84 268.73,37.68 267.67,37.68 267.15,37.16 267.15,36.51 267.15,36.18 266.35,35.38 266.07,35.38 263.96,33.27 263.96,32.37 262.92,31.33 v1(262.92,30.93) 262.26,30.93 262.1,30.77 262.1,21.92 263.05,20.97 v1(263.05,19.14)
  BOTTOM w0.114: R9005.2 263.07,19.14 v1(263.05,19.14) ; R6136.2 261.97,31.08 262.77,31.08 v1(262.92,30.93)
ESPI_EC_IO2_R: length 4
  BOTTOM w0.114: U6001.K1 265.04,29.54 264.05,30.54 263.71,30.54 263.43,30.82 263.43,31.08 262.97,31.54 R6136.1
ESPI_EC_IO2_R_R: length 2.4
  BOTTOM w0.114: R9005.1 v1(263.56,17.31) 263.56,16.89 263.74,16.7 JCN9000.8
ESPI_EC_IO3: length 11.3
  TOP w0.114: v1(261.45,69.35) 261.45,69.5 261.9,69.95 262.56,69.95 263.4,70.8 263.77,70.8 264.19,71.21 264.78,71.21 265.03,70.96 266.83,70.96 267.24,71.38 v1(267.24,71.72) 267.24,72.06 268.65,73.48 R9064.2
  BOTTOM w0.114: U9002.BA38 261.75,69.04 v1(261.45,69.35)
ESPI_EC_IO3_L: length 79.9
  TOP w0.114: v1(276.37,59.37) 277.53,58.21 278.54,58.21 278.72,58.38 278.72,61.18 278.84,61.3 279.41,61.88 279.41,63.07 280.36,64.01 280.36,66.24 280.85,66.73 280.85,68.78 276.41,73.23 275.82,73.23 274.38,74.67 270.95,74.67 R9064.1
  IN2 w0.089: v1(276.37,59.37) 275.67,58.67 275.67,51.78 274.9,51.01 272.89,51.01 270.42,48.53 270.42,47.11 268.71,45.41 268.71,43.17 269.91,41.98 269.91,41.09 269.49,40.68 269.49,39.01 268.66,38.18 267.61,38.18 266.76,37.33 266.76,36.35 266.18,35.78 265.91,35.78 263.56,33.43 263.56,32.53 263.25,32.22 v1(261.89,32.22) 261.84,32.17 261.84,32.08 261.17,31.41 261.17,29.05 261.71,28.51 261.71,21.75 262.41,21.05 v1(262.41,19.14)
  BOTTOM w0.114: v1(262.41,19.14) 262.8,18.76 R9004.2 ; R6135.2 261.52,32.36 261.65,32.22 v1(261.89,32.22)
ESPI_EC_IO3_R: length 4.6
  BOTTOM w0.114: U6001.L1 264.93,30.19 264.26,30.86 264.26,31.16 263.35,32.07 v1(263.28,32.07) 263.2,32.15 262.66,32.15 262.3,32.52 R6135.1
ESPI_EC_IO3_R_R: length 2.5
  BOTTOM w0.114: JCN9000.7 263.24,16.6 263.12,16.73 263.12,17.7 262.8,18.03 R9004.1
EXP_CLK_REQ7#: length 6.3
  BOTTOM w0.102: U9002.AC48 259,59.39 259.59,58.8 259.59,56.96 v1(259.37,56.73)
  BOTTOM w0.114: R9184.1 258.73,54.83 258.73,56.1 v1(259.37,56.73)
EXT_DPC_HPD: length 221.6
  TOP w0.114: R2059.2 219.6,87.71 C2166.2 219.72,88.32 v1(220,88.05) 220.17,88.23 Q2023.2
  IN1 w0.076: v1(359.32,52.67) 359.32,46.03 357.63,44.34 357.63,41.45 v1(357.41,41.24)
  IN2 w0.089: v1(220,88.05) 219.62,87.67 219.62,86.68 219.89,86.4 219.89,84.6 220.71,83.78 220.71,82.83 222.09,81.45 222.09,80.69 222.28,80.49 224.2,80.49 224.52,80.18 224.52,78.35 226.4,76.47 226.4,71.33 230.42,67.31 230.42,41.73 v1(229.55,40.86)
  IN3 w0.089: v1(357.41,41.24) 357.41,40.64 356.95,40.18 356.95,37.85 355.92,36.82 352.45,36.82 348.15,32.53 346.17,32.53 344.26,30.62 341.33,30.62 340.59,29.89 335.77,29.89 335.19,29.3 332.24,29.3 329.19,26.25 319.46,26.25 318.4,25.2 315.97,25.2 314.21,26.96 309.66,26.96 307.35,29.28 304.62,29.28 303.59,30.3 301.92,30.3 300.63,31.59 294.99,31.59 294.41,31.01 292.39,31.01 291.22,32.18 288.99,32.18 287.52,30.71 286.33,30.71 286.19,30.85 283.21,30.85 282.8,30.44 280.47,30.44 279.26,31.64 276.2,31.64 275.57,32.27 270.98,32.27 269.65,33.6 266.81,33.6 265.61,33.6 265.37,33.84 264.11,33.84 263.69,34.25 261.91,34.25 261.66,34 258.81,34 258.22,33.41 253.63,33.41 253.43,33.21 251.06,33.21 250.48,32.63 246.92,32.63 246.67,32.88 v3(246.67,32.96)
  BOTTOM w0.114: v3(246.67,32.96) 246.44,33.18 245,33.18 244.47,33.71 243.9,33.71 241.59,31.4 236.83,31.4 235.85,32.38 233.3,32.38 233.09,32.59 230.37,35.31 230.37,37.77 230.16,37.99 229.17,37.99 228.63,38.52 228.63,39.94 v1(229.55,40.86) ; R18089.2 v1(359.32,52.67)
EXT_DPC_SCL: length 190.1
  IN4 w0.076: v1(346.11,53.18) 345.08,52.15 342.43,52.15 341.42,51.13 341.37,51.13 341.25,51.01 338.65,51.01 335.72,53.94 333.57,53.94 332.1,55.41 330.71,55.41 330.11,56.02 321.18,56.02 320.59,56.61 312.58,56.61 311.94,57.24 309.02,57.24 308.46,56.68 301.07,56.68 300.72,56.33 297.59,56.33 297.15,56.77 294.95,56.77 293.94,57.78 292.49,57.78 292.37,57.66 290.87,57.66 290.59,57.38 289.33,57.38 288.19,58.52 288.19,59.65 285.24,62.6 278.4,62.6 276.89,64.12 275.6,64.12 273.35,66.37 273.35,66.38 272.35,66.38 271.56,67.17 270.7,67.17 268.82,69.05 268.29,69.05 266.76,70.58 266.1,70.58 262.4,74.27 262.4,75.16 261.4,76.16 260.79,76.16 258.31,78.64 258.31,79.57 256.87,81.02 254.11,81.02 252.17,82.95 251.93,82.95 251.23,83.66 250.44,83.66 249.42,82.64 247.46,82.64 244.56,85.54 242.16,85.54 240.41,87.29 235.45,87.29 234.67,88.08 233.83,88.08 233.27,88.64 231.39,88.64 231,88.25 221.39,88.25 220.63,89 220.63,89.37 220.07,89.93 212.38,89.93 209.07,93.23 209.07,94.07 208.44,94.71 206.15,94.71 205.77,95.09 204.63,95.09 203.99,94.45 203.99,93.82 v1(203.49,93.31)
  BOTTOM w0.114: v1(346.11,53.18) 345.63,53.65 345.63,55.54 344.6,56.57 344.6,58.15 347.02,60.57 348.42,60.57 348.52,60.67 348.92,61.07 R18090.2 ; v1(203.49,93.31) 203.63,93.17 203.63,90.03 204.1,89.56 205.7,89.56 206.27,90.12 Q2024.6
EXT_DPC_SDA: length 189.8
  IN4 w0.076: v1(344.84,52.52) 342.34,52.52 341.28,51.46 341.19,51.46 341.07,51.34 338.8,51.34 335.82,54.32 333.66,54.32 332.21,55.77 330.97,55.77 330.38,56.35 321.32,56.35 320.47,57.2 312.67,57.2 312.3,57.57 304.02,57.57 303.55,57.1 295.12,57.1 294.02,58.2 293.2,58.2 293.2,58.2 292.44,58.2 292.23,57.99 290.73,57.99 290.46,57.71 289.46,57.71 288.52,58.65 288.52,59.81 285.35,62.98 278.49,62.98 277.02,64.45 275.77,64.45 274.68,65.53 274.68,66.18 273.95,66.92 272.42,66.92 269.96,69.38 268.56,69.38 267.04,70.91 266.28,70.91 263.32,73.87 263.32,74.14 263.44,74.26 263.44,74.64 261.59,76.49 260.92,76.49 258.64,78.77 258.64,79.71 256.98,81.37 254.24,81.37 252.32,83.28 252.07,83.28 251.37,83.99 250.17,83.99 249.21,83.02 247.65,83.02 244.75,85.92 242.25,85.92 240.55,87.62 235.59,87.62 234.8,88.41 233.97,88.41 233.41,88.97 231.25,88.97 230.86,88.58 221.52,88.58 220.96,89.14 220.96,89.51 220.21,90.26 212.51,90.26 209.4,93.37 209.4,94.21 208.58,95.04 206.29,95.04 205.91,95.42 204.49,95.42 203.66,94.59 203.66,94.12 v1(203.49,93.94)
  BOTTOM w0.114: v1(203.49,93.94) 203.49,94.32 203.61,94.45 203.87,94.45 203.99,94.32 203.99,90.53 204.12,90.41 204.38,90.41 204.5,90.53 204.5,91.29 204.63,91.42 Q2024.3 ; v1(344.84,52.52) 345.26,52.94 345.26,55.39 344.23,56.42 344.23,58.33 346.83,60.93 348.26,60.93 348.77,61.44 352.84,61.44 352.97,61.56 353.22,61.56 353.35,61.69 R18088.2
EXT_DPC_TXN0: length 180.7
  IN4 w0.076: v1(205.01,97.09) 205.01,97 204.91,96.9 204.91,96.69 204.98,96.61 206.51,96.61 207.07,96.05 210.55,96.05 210.73,96.23 212.39,96.23 212.96,95.66 212.96,94.18 213.25,93.89 213.63,93.89 213.82,94.08 213.82,95.33 214.35,95.85 215.02,95.85 216.29,94.58 221.27,94.58 221.82,94.03 221.82,93.02 222.79,92.05 222.79,90.4 223.65,89.54 230.44,89.54 230.78,89.88 234.86,89.88 236.2,88.53 240.93,88.53 242.55,86.91 247.87,86.91 248.89,85.89 252.89,85.89 254.77,84.01 254.77,83.78 256.22,82.34 256.62,82.34 256.91,82.62 257.79,82.62 259.42,80.99 260.94,80.99 261.73,80.2 261.73,79.27 262.62,78.39 262.62,77.88 268.45,72.05 269.21,72.05 270.23,71.03 270.63,71.03 272.95,68.71 275.46,68.71 278.44,65.72 282.66,65.72 284.08,64.3 285.35,64.3 290.75,58.9 291.85,58.9 292.07,59.12 292.82,59.12 294.4,59.12 294.69,58.83 299.73,58.83 299.97,59.07 302.63,59.07 303.07,58.64 306.31,58.64 306.46,58.49 312.55,58.49 312.83,58.76 315.64,58.76 316.01,58.4 317.89,58.4 318.11,58.18 320.99,58.18 321.47,57.7 330.78,57.7 331.77,56.71 333.05,56.71 333.75,56.01 333.75,55.63 334.04,55.34 335.64,55.34 336.99,56.68 338.28,56.68 339.1,57.49 341.29,57.49 344.52,54.27 346.79,54.27 352.76,48.3 352.89,48.3 352.97,48.38 v3(352.97,48.73)
  BOTTOM w0.102: U2000.AJ1 204.27,98.5 204.12,98.35 204.12,98.14 204.63,97.63 204.63,97.27 204.81,97.09 v1(205.01,97.09) ; C592.1 v3(352.97,48.73)
EXT_DPC_TXN1: length 176.7
  IN4 w0.076: v3(352.97,51.02) 353.18,51.02 353.31,50.89 353.31,50.46 353.18,50.33 351.92,50.33 347.11,55.13 344.84,55.13 341.64,58.33 338.65,58.33 337.86,57.55 334.88,57.55 333.97,58.46 332.57,58.46 332.01,59.02 319.06,59.02 317.18,60.9 315.97,60.9 314.75,59.68 310.05,59.68 309.67,60.06 306.7,60.06 306.43,59.79 306.37,59.73 303.24,59.73 302.94,60.03 293.53,60.03 293.15,60.42 291.15,60.42 286.43,65.14 284.57,65.14 283.14,66.56 278.79,66.56 275.72,69.64 274.43,69.64 274.13,69.94 273.6,69.94 271.62,71.92 270.59,71.92 269.58,72.94 268.74,72.94 263.51,78.18 263.51,78.68 262.57,79.62 262.57,80.55 261.29,81.83 259.81,81.83 256.38,85.26 255.12,85.26 253.55,86.83 250.3,86.83 248.9,88.23 247.66,88.23 247.38,87.95 242.7,87.95 241.28,89.38 236.89,89.38 234.99,91.28 231.43,91.28 230.64,92.06 230.64,92.95 229.71,93.89 225.91,93.89 225.43,94.38 222.87,94.38 221.81,95.44 216.62,95.44 214.98,97.07 210.04,97.07 209.91,96.94 207.4,96.94 206.28,98.06 204.15,98.06 203.55,98.65 203.55,99.08 203.72,99.24 204.06,99.24 204.17,99.13 v1(204.17,98.9)
  BOTTOM w0.102: C590.1 v3(352.97,51.02)
  BOTTOM w0.114: v1(204.17,98.9) 204.18,98.9 U2000.AJ2
EXT_DPC_TXN2: length 178.7
  IN4 w0.076: v3(352.97,53.3) 352.61,52.95 350.48,52.95 347.46,55.97 345.19,55.97 343.26,57.9 343.26,58.95 342.53,59.68 335.68,59.68 335.01,60.35 332.27,60.35 331.77,59.86 319.68,59.86 317.32,62.22 315.89,62.22 314.19,60.52 310.39,60.52 309.94,60.97 303.71,60.97 303.05,61.64 297.33,61.64 296.67,60.97 293.99,60.97 293.25,61.71 291.06,61.71 290.86,61.91 290.85,61.91 286.78,65.98 285.05,65.98 283.55,67.48 279.87,67.48 276.84,70.5 274.75,70.5 274.35,70.91 273.91,70.91 272,72.81 270.99,72.81 269.89,73.9 269.51,73.9 263.4,80.01 263.4,80.9 261.58,82.72 260.75,82.72 256.51,86.96 255.05,86.96 253.91,88.1 252.56,88.1 250.76,89.91 248.15,89.91 247.31,89.07 243.3,89.07 241.95,90.41 238.88,90.41 237.81,91.48 236.09,91.48 235.32,92.24 233.52,92.24 232,93.77 231.16,93.77 229.68,95.25 223.52,95.25 222.31,96.45 220.54,96.45 219.67,97.32 217.26,97.32 217.07,97.52 216.87,97.71 216.87,98.32 216.43,98.77 215.63,98.77 215.1,98.25 212.53,98.25 211.72,99.06 211.72,101.69 211.27,102.14 209.46,102.14 208.31,103.29 207.52,103.29 206.97,102.74 206.97,102.13 206.46,101.63 206.46,100.83 205.93,100.3 205.17,100.3 v1(205.01,100.47)
  BOTTOM w0.102: C588.1 v3(352.97,53.3)
  BOTTOM w0.114: U2000.AH4 205.01,100.48 v1(205.01,100.47)
EXT_DPC_TXN3: length 181.7
  IN4 w0.076: v3(352.97,55.59) 350.31,55.59 348.98,56.92 348.98,57.68 347.39,59.27 346.25,59.27 344.47,61.05 337.88,61.05 337.35,60.52 336.03,60.52 335.13,61.42 324.91,61.42 324.29,62.04 320.87,62.04 319.02,63.9 316.17,63.9 314.09,61.81 311.84,61.81 311.66,61.99 304.15,61.99 303.59,62.55 291.41,62.55 287.09,66.87 285.44,66.87 283.56,68.75 280.5,68.75 277.84,71.41 275.95,71.41 275.67,71.7 274.88,71.7 272.75,73.83 271.29,73.83 270.38,74.74 269.88,74.74 264.7,79.92 264.7,80.23 264.83,80.35 264.83,81.22 262.27,83.78 260.9,83.78 256.58,88.1 256.15,88.1 253.52,90.74 252.92,90.74 251.64,92.01 250.93,92.01 249.94,91.02 249.21,91.02 248.44,91.78 248.44,93.52 246.3,95.67 242.16,95.67 240.94,94.45 234.1,94.45 232.47,96.08 225.23,96.08 224.63,96.69 223.48,96.69 222,98.16 217.7,98.16 217.51,98.35 217.51,98.82 216.67,99.66 215.53,99.66 215.06,99.2 213.11,99.2 212.76,99.54 212.76,102.08 211.87,102.97 211.87,104.1 211.28,104.69 206.34,104.69 205.39,103.73 205.39,102.96 205.01,102.58 205.01,101.84 205.35,101.51 205.65,101.51 v1(205.87,101.28)
  BOTTOM w0.102: C586.1 v3(352.97,55.59)
  BOTTOM w0.114: v1(205.87,101.28) 205.9,101.28 U2000.AG4
EXT_DPC_TXP0: length 180.7
  IN4 w0.076: v1(204.25,97.09) 204.45,96.88 204.45,96.5 204.8,96.15 206.32,96.15 206.88,95.59 210.74,95.59 210.91,95.77 212.2,95.77 212.5,95.47 212.5,93.99 213.06,93.44 213.82,93.44 214.28,93.89 214.28,95.14 214.54,95.39 214.83,95.39 216.1,94.12 221.08,94.12 221.36,93.84 221.36,92.84 222.33,91.86 222.33,90.21 223.46,89.09 230.63,89.09 230.97,89.42 234.67,89.42 236.01,88.08 240.74,88.08 242.36,86.45 247.68,86.45 248.7,85.43 252.7,85.43 254.31,83.82 254.31,83.59 256.03,81.88 256.81,81.88 257.1,82.16 257.6,82.16 259.23,80.53 260.75,80.53 261.27,80.01 261.27,79.08 262.16,78.2 262.16,77.69 268.26,71.59 269.02,71.59 270.04,70.57 270.44,70.57 272.76,68.25 275.27,68.25 278.26,65.27 282.47,65.27 283.89,63.84 285.16,63.84 290.56,58.44 292.04,58.44 292.26,58.66 292.63,58.66 294.21,58.66 294.5,58.37 299.91,58.37 300.16,58.61 302.44,58.61 302.88,58.18 306.12,58.18 306.27,58.03 312.74,58.03 313.02,58.31 315.45,58.31 315.82,57.94 317.71,57.94 317.92,57.72 320.8,57.72 321.28,57.24 330.59,57.24 331.58,56.25 332.86,56.25 333.29,55.82 333.29,55.44 333.85,54.88 335.83,54.88 337.18,56.22 338.47,56.22 339.29,57.04 341.1,57.04 344.33,53.81 346.6,53.81 352.57,47.84 352.71,47.84 v3(352.97,47.59)
  BOTTOM w0.102: C591.1 v3(352.97,47.59) ; U2000.AK1 203.92,98.36 203.92,98.06 204.43,97.55 204.43,97.27 v1(204.25,97.09)
EXT_DPC_TXP1: length 176.7
  IN4 w0.076: v3(352.97,49.87) 351.73,49.87 346.93,54.68 344.65,54.68 341.45,57.88 338.84,57.88 338.05,57.09 334.69,57.09 333.78,58 332.38,58 331.82,58.56 318.87,58.56 316.99,60.44 316.16,60.44 314.94,59.22 309.86,59.22 309.48,59.6 306.89,59.6 306.56,59.27 303.05,59.27 302.75,59.58 293.34,59.58 292.96,59.96 290.96,59.96 286.24,64.68 284.38,64.68 282.95,66.11 278.6,66.11 275.53,69.18 274.24,69.18 273.94,69.48 273.41,69.48 271.43,71.46 270.4,71.46 269.39,72.48 268.55,72.48 263.05,77.99 263.05,78.49 262.11,79.43 262.11,80.36 261.1,81.37 259.62,81.37 256.19,84.8 254.93,84.8 253.36,86.37 250.11,86.37 248.71,87.77 247.85,87.77 247.57,87.49 242.51,87.49 241.09,88.92 236.7,88.92 234.8,90.82 231.24,90.82 230.18,91.87 230.18,92.76 229.52,93.43 225.72,93.43 225.24,93.92 222.68,93.92 221.62,94.98 216.43,94.98 214.79,96.61 210.23,96.61 210.1,96.48 207.21,96.48 206.09,97.6 203.96,97.6 203.09,98.47 203.09,99.27 203.53,99.7 v1(204.16,99.7)
  BOTTOM w0.102: C589.1 v3(352.97,49.87)
  BOTTOM w0.114: U2000.AJ3 204.18,99.7 v1(204.16,99.7)
EXT_DPC_TXP2: length 178.7
  IN4 w0.076: v1(204.98,99.68) 205.15,99.85 206.12,99.85 206.92,100.64 206.92,101.44 207.42,101.94 207.42,102.55 207.71,102.83 208.12,102.83 209.27,101.68 211.08,101.68 211.26,101.5 211.26,98.87 212.34,97.79 215.29,97.79 215.82,98.31 216.24,98.31 216.41,98.13 216.41,97.53 216.74,97.2 217.08,96.86 219.48,96.86 220.35,95.99 222.12,95.99 223.33,94.79 229.49,94.79 230.97,93.31 231.81,93.31 233.33,91.78 235.13,91.78 235.9,91.02 237.62,91.02 238.69,89.96 241.76,89.96 243.11,88.61 247.5,88.61 248.34,89.45 250.57,89.45 252.37,87.64 253.72,87.64 254.86,86.5 256.32,86.5 260.56,82.26 261.39,82.26 262.95,80.71 262.95,79.82 269.32,73.45 269.7,73.45 270.8,72.35 271.81,72.35 273.72,70.45 274.16,70.45 274.56,70.04 276.66,70.04 279.68,67.02 283.36,67.02 284.86,65.52 286.59,65.52 290.66,61.46 290.67,61.46 290.87,61.25 293.06,61.25 293.8,60.52 296.86,60.52 297.52,61.18 302.86,61.18 303.52,60.52 309.75,60.52 310.2,60.06 314.38,60.06 316.08,61.76 317.13,61.76 319.49,59.4 331.96,59.4 332.45,59.9 334.82,59.9 335.49,59.22 342.34,59.22 342.8,58.76 342.8,57.71 345,55.51 347.27,55.51 350.3,52.49 352.63,52.49 v3(352.97,52.16)
  BOTTOM w0.102: C587.1 v3(352.97,52.16)
  BOTTOM w0.114: v1(204.98,99.68) 205.4,100.1 U2000.AH3
EXT_DPC_TXP3: length 181.7
  IN4 w0.076: v1(205.87,102.08) 205.75,101.96 205.54,101.96 205.47,102.03 205.47,102.39 205.85,102.77 205.85,103.55 206.53,104.23 211.09,104.23 211.41,103.91 211.41,102.78 212.3,101.89 212.3,99.35 212.92,98.74 215.25,98.74 215.72,99.2 216.48,99.2 217.05,98.63 217.05,98.16 217.51,97.7 221.81,97.7 223.29,96.23 224.44,96.23 225.04,95.63 232.28,95.63 233.92,93.99 241.13,93.99 242.35,95.21 246.11,95.21 247.99,93.33 247.99,91.6 249.02,90.57 250.13,90.57 251.12,91.56 251.45,91.56 252.73,90.28 253.33,90.28 255.96,87.64 256.39,87.64 260.71,83.33 262.08,83.33 264.37,81.03 264.37,80.54 264.24,80.42 264.24,79.73 269.69,74.28 270.19,74.28 271.1,73.37 272.56,73.37 274.69,71.24 275.48,71.24 275.76,70.96 277.65,70.96 280.31,68.29 283.37,68.29 285.25,66.41 286.9,66.41 291.22,62.09 303.4,62.09 303.96,61.53 311.48,61.53 311.65,61.36 314.28,61.36 316.36,63.44 318.83,63.44 320.68,61.58 324.1,61.58 324.72,60.96 334.94,60.96 335.84,60.06 337.54,60.06 338.07,60.59 344.28,60.59 346.06,58.82 347.2,58.82 348.52,57.49 348.52,56.73 350.12,55.13 353.18,55.13 353.31,55.01 353.31,54.57 353.18,54.45 v3(352.97,54.45)
  BOTTOM w0.102: C585.1 v3(352.97,54.45)
  BOTTOM w0.114: U2000.AG5 206.28,102.07 206.15,102.2 205.99,102.2 v1(205.87,102.08)
EXT_DPE_AUX_SRCN: length 4.5
  BOTTOM w0.114: U500.61 330.82,57.06 331.3,56.58 331.3,54.93 331.86,54.37 332.31,54.37 C532.2
EXT_DPE_AUX_SRCP: length 4.5
  BOTTOM w0.114: U500.62 330.81,56.66 331.01,56.46 331.01,54.81 331.74,54.08 332.24,54.08 C531.2
EXT_DPE_AUXN: length 185
  TOP w0.114: v1(210.88,101.29) 210.17,100.58 210.17,100.14 210.45,99.86 210.45,99.49 210.12,99.16 210.12,98.61 210.46,98.27 210.46,97.77 209.07,96.39 R10040.2
  IN3 w0.089: v1(210.88,101.29) 211.08,101.09 211.38,101.09 211.7,100.76 211.7,99.98 212.5,99.18 212.5,98.44 214.04,96.9 214.04,92.03 213.1,91.09 213.1,89.28 214.26,88.13 218.7,88.13 219.31,88.74 221.73,88.74 222.75,89.75 222.75,91.72 223.44,92.4 223.44,93.88 224.78,95.22 232.56,95.22 233.08,94.69 240.43,94.69 240.91,95.18 246.09,95.18 248.45,92.82 248.45,92.01 249.11,91.35 250.35,91.35 250.81,91.82 251.48,91.82 251.97,91.33 253.5,91.33 253.68,91.51 255.18,91.51 256.22,90.46 257.64,90.46 259.1,89 259.1,88.03 262.43,84.71 262.43,84.18 265.29,81.31 265.29,81.03 271.48,74.84 273.49,74.84 275.04,73.29 275.98,73.29 277.5,71.77 278.15,71.77 284.22,65.7 286.77,65.7 289.55,62.92 292.09,62.92 294.47,60.54 297.29,60.54 297.47,60.37 302.6,60.37 302.95,60.72 308.73,60.72 310.29,59.16 310.29,58.66 311.26,57.7 312.23,57.7 314.89,55.04 314.89,53.28 315.44,52.72 320.69,52.72 321.51,53.55 325.22,53.55 325.63,53.13 325.63,51.02 325.78,50.88 326,50.88 326.14,51.02 326.14,52.44 326.42,52.72 326.86,52.72 327.16,52.43 327.16,51.58 327.35,51.39 327.77,51.39 328.39,50.76 328.39,48.64 328.52,48.51 328.74,48.51 328.9,48.67 328.9,49.96 329.14,50.21 331.76,50.21 332.09,49.87 332.09,49.09 v1(332.19,48.99)
  BOTTOM w0.102: U2000.AB4 210.43,100.93 210.79,101.29 v1(210.88,101.29)
  BOTTOM w0.114: C532.1 333.61,54.7 334.35,53.96 334.35,53.23 333.74,52.62 333.74,51.58 331.93,49.77 331.93,49.24 v1(332.19,48.99)
EXT_DPE_AUXP: length 184.9
  TOP w0.114: v1(210.88,100.49) 210.79,100.57 210.57,100.57 210.46,100.46 210.46,100.26 210.74,99.98 210.74,99.37 210.41,99.04 210.41,98.73 210.75,98.39 210.75,97.65 209.5,96.4 209.5,95.75 209.61,95.64 210,95.64 R10041.2
  IN3 w0.089: v1(210.88,100.49) 210.88,100.62 211.13,100.87 211.29,100.87 211.49,100.67 211.49,99.89 212.29,99.09 212.29,98.35 213.82,96.81 213.82,92.12 212.88,91.18 212.88,89.19 214.17,87.91 218.79,87.91 219.4,88.52 221.82,88.52 222.97,89.67 222.97,91.63 223.65,92.31 223.65,93.79 224.87,95 232.47,95 232.99,94.48 240.52,94.48 241,94.96 246,94.96 248.23,92.73 248.23,91.92 249.02,91.14 250.44,91.14 250.9,91.6 251.39,91.6 251.88,91.11 253.59,91.11 253.77,91.29 255.09,91.29 256.13,90.25 257.55,90.25 258.88,88.91 258.88,87.94 262.21,84.62 262.21,84.09 265.07,81.22 265.07,80.94 271.39,74.63 273.4,74.63 274.95,73.08 275.89,73.08 277.41,71.55 278.06,71.55 284.13,65.48 286.68,65.48 289.47,62.7 292.01,62.7 294.38,60.33 297.2,60.33 297.38,60.15 302.69,60.15 303.04,60.5 308.64,60.5 310.08,59.07 310.08,58.57 311.17,57.48 312.14,57.48 314.67,54.95 314.67,53.19 315.36,52.51 320.78,52.51 321.6,53.33 325.13,53.33 325.42,53.04 325.42,50.93 325.69,50.66 326.09,50.66 326.36,50.93 326.36,52.35 326.51,52.5 326.77,52.5 326.94,52.34 326.94,51.49 327.26,51.17 327.68,51.17 328.17,50.67 328.17,48.55 328.43,48.3 328.83,48.3 329.11,48.58 329.11,49.87 329.23,49.99 331.67,49.99 331.87,49.79 331.87,49.33 331.53,48.99 v1(331.45,48.99)
  BOTTOM w0.102: U2000.AB3 210.48,100.1 v1(210.88,100.49)
  BOTTOM w0.114: v1(331.45,48.99) 331.64,49.18 331.64,49.89 333.45,51.7 333.45,52.74 334.05,53.35 334.05,53.84 333.7,54.19 333.41,54.19 333.31,54.09 333.31,53.8 C531.1

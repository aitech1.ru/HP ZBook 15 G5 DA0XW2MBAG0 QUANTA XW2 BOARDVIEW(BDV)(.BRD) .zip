# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Nets (continued)
OPC_AGND: PC17000.2 PR17007.2 PR17019.1 PR17020.1 PU17000.11(AGND)
OPC_BST: PR17009.2 PU17000.9(BST)
OPC_EN: PC17006.1 PR17010.2 PU17000.5(EN)
OPC_PG: PR17016.2 PU17000.13(PG)
OPC_SW: PC17007.2 PL17001.1 PR17013.2 PU17000.8(SW)
OPC_VIN: PC17001.2 PC17002.1 PC17003.1 PC17005.2 PL17000.1 PU17000.1(VIN)
OPC_VOUT: PR17017.2 PR17018.1 PU17000.12(VOUT)
OUT08_PSR_OFF#: R18002.2 R18005.2 U12003.4(OUT Y)
OUT_HPD_PIN44: R3056.2 U3007.44(OUT_HPD)
OUT_L_A: L3615.2 U3603.C6(OUTA) U3603.D6(NC1) U3603.D7(NC2)
OUT_L_B: L3616.2 U3603.A6(OUTB)
OUT_R_A: L3613.2 U3602.C6(OUTA) U3602.D6(NC1) U3602.D7(NC2)
OUT_R_B: L3614.2 U3602.A6(OUTB)
OVERT#: Q2015.1(S) R2086.2 U2000.M1(OVERT)
OVP_DET: PQ11003.2(G) PQ12012.3(COLLECTOR) PR11037.2 PR12037.2
OVP_TRIP_P1_P2.1: TP8520.1 U8500.K5(SDA_4/OVP_TRIP_P1/GPIO_P2.4)
PA_USB2_RBIAS: R8011.2 U8001.H19(PA_USB2_RBIAS)
PAC1933_ADDR: PR9809.1 PR9812.2 PU9802.6(ADDRSEL)
PAC1933_ALERT: PR9814.2 PU9802.1(SLOW/A\L\E\R\T\)
PANEL_BKEN_GFX: R2150.1 R2235.2 U2010.4(OUT Y) U3009.3(B0)
PANEL_BKEN_GFX_R: R2125.2 R2235.1 U2000.M4(GPIO13) U2010.1(INB) U2010.2(INA)
PANEL_BKEN_PCH: R3050.2 R9329.1 U3009.1(B1) U9002.AV46(GPP_F20/EDP_BKLTEN)
PB_USB2_RBIAS: R8012.2 U8001.F19(PB_USB2_RBIAS)
PCH_2_CPU_TRIG: R9270.1 U9001.H23(PROC_TRIGIN)
PCH_2_CPU_TRIG_R: R9270.2 U9002.AK3(TRIGGER_OUT)
PCH_+VCCAPLL_1P05A: C12023.1 R17900.1 U9002.B1(VCCAPLL_1P051) U9002.B2(VCCAPLL_1P052) U9002.B3(VCCAPLL_1P053)
PCH_DPST_PWM_R: R3014.2 R3021.2 R3022.1
PCH_DPST_PWM_R_R: C3036.1 CON3000.23 R3022.2
PCH_GPP_A22: R9351.2 R17887.1 U9002.AW32(GPP_A22/ISH_GP4)
PCH_ISH_I2C0_SCL: R9349.2 U9002.AG45(GPP_H20/ISH_I2C0_SCL)
PCH_ISH_I2C0_SDA: R9350.2 U9002.AH46(GPP_H19/ISH_I2C0_SDA)
PCH_KBC_CLK: Q9009.4(S) R9110.1 U9002.BF27(GPP_C6/SML1CLK)
PCH_KBC_DATA: Q9009.1(S) R9113.1 U9002.BE27(GPP_C7/SML1DATA)
PCH_KBC_SMCLK: PU11001.1(SMBCLK) Q2019.3(D) Q6402.6(D) Q9009.3(D) R6039.2 U6001.K8(GPIO90/I2C1_SCL0)
PCH_KBC_SMDATA: PU11001.5(SMBDATA) Q2019.6(D) Q6402.3(D) Q9009.6(D) R6038.2 U6001.K7(GPIO87/I2C1_SDA0)
PCH_LVDS_BLON_R: D3001.1(CATHODE) R3004.2 R3007.2 R3036.1 U49.4(OUT Y)
PCH_PCIE_WAKE#: Q4101.6(D) Q8000.3(D) Q8012.3(COLLECTOR) R4006.2 R7308.1 R8530.2 R9093.2
PCH_PECI: R9017.1 R9166.2 U9002.AF2(PECI)
PCH_PWROK: R9128.2 R9132.1 R9134.1 U9000.4(OUT Y) U9002.AY42(PCH_PWROK)
PCH_SLP_S0IX#: R9239.2 U9002.AW24(GPP_C14/UART1_RTS#/ISH_UART1_RT)
PCH_SLP_SUS#: R9597.1 U6001.J6(GPIO75/32KHZ_OUT) U9002.BD39(SLP_SUS#)
PCH_SMBCLK: CON400.53(SCL) JDIM1000.253(SCL) JDIM1001.253(SCL) JDIM1002.253(SCL) JDIM1003.253(SCL) Q9008.1(S1) R9126.2
PCH_SMBDATA: CON400.51(SDA) JDIM1000.254(SDA) JDIM1001.254(SDA) JDIM1002.254(SDA) JDIM1003.254(SDA) Q9008.4(S2) R9125.2
PCH_SPI1_CLK_L: R9200.2 R9599.1 U9002.AW47(SPI0_CLK)
PCH_SPI1_SI_L: R9197.2 R9203.1 R9207.2 U9002.AU41(SPI0_MOSI)
PCH_SPI1_SO_L: R9192.1 R9194.2 R9335.2 U9002.BA45(SPI0_MISO)
PCH_SPI_CS0#_L: R9199.2 U9002.AY47(SPI0_CS0#)
PCH_SPI_IO2_ROM: R6152.2 U6202.3(W\P\(IO2)) U6204.3(W\P\(IO2))
PCH_SPI_IO3_ROM: R6210.2 R6218.1 U6202.7(H\O\L\D\(IO3)) U6204.7(H\O\L\D\(IO3))
PCH_TBT_PERST#: R9588.1 R17977.2 U9002.BF33(GPP_B1/GSPI1_CS1#/TIME_SYNC1) U12001.2(INA)
PCH_TBT_WAKE#: Q9043.1(S) R9241.1 U9002.AL48(GPP_E4/SATA_DEVSLP0)
PCH_TCK: R403.2 R9117.2 U9002.AJ3(PCH_JTAG_TCK)
PCH_TDI: R9115.1 U9002.AH2(PCH_JTAG_TDI)
PCH_TDO: R9114.1 R9124.2 U9002.AH3(PCH_JTAG_TDO)
PCH_TMS: R9112.1 U9002.AJ4(PCH_JTAG_TMS)
PCH_VCCA_SRC_1P05: C12024.2 R17901.1 U9002.W19(VCCA_SRC_1P051) U9002.W20(VCCA_SRC_1P052)
PCH_VCCPRIM_1P05_AD31: R17909.1 U9002.AD31(VCCPRIM_1P0514)
PCH_WAKE#_L: R9093.1 R9094.1 U9002.BB47(WAKE#)
PCI_PLTRST#: CON5100.50(PERST#/NC_50) CON5101.50(PERST#/NC_50) Q6001.2(G) Q6500.5(G) Q6501.2(G) Q9007.2 R4000.2 R4117.1 R4208.1 R6507.2 R9213.2 R9215.2 R9586.1 U2001.2(INA) U4200.1(B) U7301.1(PERST#) U9003.4(OUT Y) U12001.1(INB)
PCI_PLTRST#_R: CON4201.50(NC_50) R4208.2 R4213.2 U4200.4(Y)
PCIE_CLKREQ9#: R9176.1 U9002.AF48(GPP_H3/SRCCLKREQ9#)
PCIE_CLKREQ10#: R9173.1 U9002.AC41(GPP_H4/SRCCLKREQ10#)
PCIE_CLKREQ11#: R9177.1 U9002.AC39(GPP_H5/SRCCLKREQ11#)
PCIE_CLKREQ12#: R9179.1 U9002.AE39(GPP_H6/SRCCLKREQ12#)
PCIE_CLKREQ13#: R9181.1 U9002.AB48(GPP_H7/SRCCLKREQ13#)
PCIE_CLKREQ14#: R9183.1 U9002.AC44(GPP_H8/SRCCLKREQ14#)
PCIE_CLKREQ15#: R9185.1 U9002.AC43(GPP_H9/SRCCLKREQ15#)
PCIE_CLKREQ_L: R4116.1 U4100.30(CLKREQ#/NC)
PCIE_RBIAS: R8001.1 U8001.N16(PCIE_RBIAS)
PCIE_RXN3_CARD: C7319.1 U9002.K18(PCIE3_RXN/USB31_9_RXN)
PCIE_RXN4_WWAN: CON4201.41(NC_41) U9002.N18(PCIE4_RXN/USB31_10_RXN)
PCIE_RXN5_TBT: C8001.2 U9002.F20(PCIE5_RXN)
PCIE_RXN5_TBT_C: C8001.1 U8001.V22(PCIE_TX0_N)
PCIE_RXN6_TBT: C8003.2 U9002.K21(PCIE6_RXN)
PCIE_RXN6_TBT_C: C8003.1 U8001.P22(PCIE_TX1_N)
PCIE_RXN7_TBT: C8005.2 U9002.L24(PCIE7_RXN)
PCIE_RXN7_TBT_C: C8005.1 U8001.K22(PCIE_TX2_N)
PCIE_RXN8_TBT: C8007.2 U9002.F24(PCIE8_RXN)
PCIE_RXN8_TBT_C: C8007.1 U8001.F22(PCIE_TX3_N)
PCIE_RXN9_SSD: CON5100.5(PERN3) U9002.G36(PCIE9_RXN)
PCIE_RXN10_SSD: CON5100.17(PERN2) U9002.K37(PCIE10_RXN)
PCIE_RXN11_SSD: CON5100.29(PERN1) U9002.G38(PCIE11_RXN/SATA0A_RXN)
PCIE_RXN12_SSD: CON5100.43(PERP0/SATA-B-) U9002.H42(PCIE12_RXN/SATA1A_RXN)
PCIE_RXN13_LAN: C4001.1 U9002.C45(PCIE13_RXN/SATA0B_RXN)
PCIE_RXN13_LAN_C: C4001.2 U4000.39(PETN)
PCIE_RXN14_WLAN: C4111.1 TP4100.1 U9002.D46(PCIE14_RXN/SATA1B_RXN)
PCIE_RXN14_WLAN_C: C4111.2 U4100.36(PERN0/NC)
PCIE_RXN17_SSD: CON5101.43(PERP0/SATA-B-) U9002.K43(PCIE17_RXN/SATA4_RXN)
PCIE_RXN18_SSD: CON5101.29(PERN1) U9002.P41(PCIE18_RXN/SATA5_RXN)
PCIE_RXN19_SSD: CON5101.17(PERN2) U9002.M44(PCIE19_RXN/SATA6_RXN)
PCIE_RXN20_SSD: CON5101.5(PERN3) U9002.R35(PCIE20_RXN/SATA7_RXN)
PCIE_RXP3_CARD: C7321.1 U9002.J18(PCIE3_RXP/USB31_9_RXP)
PCIE_RXP4_WWAN: CON4201.43(NC_43) U9002.R18(PCIE4_RXP/USB31_10_RXP)
PCIE_RXP5_TBT: C8000.2 U9002.G20(PCIE5_RXP)
PCIE_RXP5_TBT_C: C8000.1 U8001.V23(PCIE_TX0_P)
PCIE_RXP6_TBT: C8002.2 U9002.J21(PCIE6_RXP)
PCIE_RXP6_TBT_C: C8002.1 U8001.P23(PCIE_TX1_P)
PCIE_RXP7_TBT: C8004.2 U9002.J24(PCIE7_RXP)
PCIE_RXP7_TBT_C: C8004.1 U8001.K23(PCIE_TX2_P)
PCIE_RXP8_TBT: C8006.2 U9002.G24(PCIE8_RXP)
PCIE_RXP8_TBT_C: C8006.1 U8001.F23(PCIE_TX3_P)
PCIE_RXP9_SSD: CON5100.7(PERP3) U9002.F36(PCIE9_RXP)
PCIE_RXP10_SSD: CON5100.19(PERP2) U9002.J37(PCIE10_RXP)
PCIE_RXP11_SSD: CON5100.31(PERP1) U9002.F39(PCIE11_RXP/SATA0A_RXP)
PCIE_RXP12_SSD: CON5100.41(PERN0/SATA-B+) U9002.J41(PCIE12_RXP/SATA_1A_RXP)
PCIE_RXP13_LAN: C4000.1 U9002.C46(PCIE13_RXP/SATA0B_RXP)
PCIE_RXP13_LAN_C: C4000.2 U4000.38(PETP)
PCIE_RXP14_WLAN: C4112.1 TP4101.1 U9002.C47(PCIE14_RXP/SATA1B_RXP)
PCIE_RXP14_WLAN_C: C4112.2 U4100.37(PERP0/NC)
PCIE_RXP17_SSD: CON5101.41(PERN0/SATA-B+) U9002.K44(PCIE17_RXP/SATA4_RXP)
PCIE_RXP18_SSD: CON5101.31(PERP1) U9002.R40(PCIE18_RXP/SATA5_RXP)
PCIE_RXP19_SSD: CON5101.19(PERP2) U9002.N42(PCIE19_RXP/SATA6_RXP)
PCIE_RXP20_SSD: CON5101.7(PERP3) U9002.R37(PCIE20_RXP/SATA7_RXP)
PCIE_TXN3_CARD: C9166.2 U7301.4(HSIN)
PCIE_TXN3_CARD_C: C9166.1 U9002.B19(PCIE3_TXN/USB31_9_TXN)
PCIE_TXN4_WWAN: C9170.2 CON4201.47(NC_47)
PCIE_TXN4_WWAN_C: C9170.1 U9002.D20(PCIE4_TXN/USB31_10_TXN)
PCIE_TXN5_TBT: C9174.1 U8001.Y22(PCIE_RX0_N)
PCIE_TXN5_TBT_C: C9174.2 U9002.B21(PCIE5_TXN)
PCIE_TXN6_TBT: C9178.1 U8001.T22(PCIE_RX1_N)
PCIE_TXN6_TBT_C: C9178.2 U9002.D21(PCIE6_TXN)
PCIE_TXN7_TBT: C9182.1 U8001.M22(PCIE_RX2_N)
PCIE_TXN7_TBT_C: C9182.2 U9002.C23(PCIE7_TXN)
PCIE_TXN8_TBT: C9184.1 U8001.H22(PCIE_RX3_N)
PCIE_TXN8_TBT_C: C9184.2 U9002.B24(PCIE8_TXN)
PCIE_TXN9_SSD: C9191.2 CON5100.11(PETN3)
PCIE_TXN9_SSD_C: C9191.1 U9002.C34(PCIE9_TXN)
PCIE_TXN10_SSD: C9193.2 CON5100.23(PETN2)
PCIE_TXN10_SSD_C: C9193.1 U9002.C35(PCIE10_TXN)
PCIE_TXN11_SSD: C9197.1 CON5100.35(PETN1)
PCIE_TXN11_SSD_C: C9197.2 U9002.B36(PCIE11_TXN/SATA0A_TXN)
PCIE_TXN12_SSD: C9207.1 CON5100.47(PETN0/SATA-A-)
PCIE_TXN12_SSD_C: C9207.2 U9002.D38(PCIE12_TXN/SATA1A_TXN)
PCIE_TXN13_LAN: C9205.2 U4000.42(PERN)
PCIE_TXN13_LAN_C: C9205.1 U9002.B38(PCIE13_TXN/SATA0B_TXN)
PCIE_TXN14_WLAN: C9200.2 TP4102.1 U4100.39(PETN0/NC)
PCIE_TXN14_WLAN_C: C9200.1 U9002.C39(PCIE14_TXN/SATA1B_TXN)
PCIE_TXN17_SSD: C9198.2 CON5101.47(PETN0/SATA-A-)
PCIE_TXN17_SSD_C: C9198.1 U9002.A42(PCIE17_TXN/SATA4_TXN)
PCIE_TXN18_SSD: C9201.2 CON5101.35(PETN1)
PCIE_TXN18_SSD_C: C9201.1 U9002.C42(PCIE18_TXN/SATA5_TXN)
PCIE_TXN19_SSD: C9211.1 CON5101.23(PETN2)
PCIE_TXN19_SSD_C: C9211.2 U9002.C44(PCIE19_TXN/SATA6_TXN)
PCIE_TXN20_SSD: C9209.1 CON5101.11(PETN3)
PCIE_TXN20_SSD_C: C9209.2 U9002.A44(PCIE20_TXN/SATA7_TXN)
PCIE_TXP3_CARD: C9167.2 U7301.3(HSIP)
PCIE_TXP3_CARD_C: C9167.1 U9002.C19(PCIE3_TXP/USB31_9_TXP)
PCIE_TXP4_WWAN: C9171.2 CON4201.49(NC_49)
PCIE_TXP4_WWAN_C: C9171.1 U9002.C20(PCIE4_TXP/USB31_10_TXP)
PCIE_TXP5_TBT: C9175.1 U8001.Y23(PCIE_RX0_P)
PCIE_TXP5_TBT_C: C9175.2 U9002.A22(PCIE5_TXP)
PCIE_TXP6_TBT: C9179.1 U8001.T23(PCIE_RX1_P)
PCIE_TXP6_TBT_C: C9179.2 U9002.C21(PCIE6_TXP)
PCIE_TXP7_TBT: C9183.1 U8001.M23(PCIE_RX2_P)
PCIE_TXP7_TBT_C: C9183.2 U9002.B23(PCIE7_TXP)
PCIE_TXP8_TBT: C9185.1 U8001.H23(PCIE_RX3_P)
PCIE_TXP8_TBT_C: C9185.2 U9002.C24(PCIE8_TXP)
PCIE_TXP9_SSD: C9192.2 CON5100.13(PETP3)
PCIE_TXP9_SSD_C: C9192.1 U9002.D34(PCIE9_TXP)
PCIE_TXP10_SSD: C9194.2 CON5100.25(PETP2)
PCIE_TXP10_SSD_C: C9194.1 U9002.B35(PCIE10_TXP)
PCIE_TXP11_SSD: C9196.1 CON5100.37(PETP1)
PCIE_TXP11_SSD_C: C9196.2 U9002.C36(PCIE11_TXP/SATA0A_TXP)
PCIE_TXP12_SSD: C9206.1 CON5100.49(PETP0/SATA-A+)
PCIE_TXP12_SSD_C: C9206.2 U9002.E37(PCIE12_TXP/SATA1A_TXP)
PCIE_TXP13_LAN: C9204.2 U4000.41(PERP)
PCIE_TXP13_LAN_C: C9204.1 U9002.C38(PCIE13_TXP/SATA0B_TXP)
PCIE_TXP14_WLAN: C9202.2 TP4103.1 U4100.40(PETP0/NC)
PCIE_TXP14_WLAN_C: C9202.1 U9002.D39(PCIE14_TXP/SATA1B_TXP)
PCIE_TXP17_SSD: C9199.2 CON5101.49(PETP0/SATA-A+)
PCIE_TXP17_SSD_C: C9199.1 U9002.B42(PCIE17_TXP/SATA4_TXP)
PCIE_TXP18_SSD: C9203.2 CON5101.37(PETP1)
PCIE_TXP18_SSD_C: C9203.1 U9002.D42(PCIE18_TXP/SATA5_TXP)
PCIE_TXP19_SSD: C9210.1 CON5101.25(PETP2)
PCIE_TXP19_SSD_C: C9210.2 U9002.D43(PCIE19_TXP/SATA6_TXP)
PCIE_TXP20_SSD: C9208.1 CON5101.13(PETP3)
PCIE_TXP20_SSD_C: C9208.2 U9002.B44(PCIE20_TXP/SATA7_TXP)
PCIE_WAKE#: R7308.2 R7328.1 U7301.32(WAKE#)
PCIECOMP_N: R9188.1 U9002.B12(PCIE_RCOMPN)
PCIECOMP_P: R9188.2 U9002.A13(PCIE_RCOMPP)
PD_ADP_DIS1: PQ10004.5(G) PR10008.2 U6001.H7(GPIOC5/K\B\R\S\T\)
PD_ADP_DIS2: PQ10005.5(G) PR10009.2 U6001.D10(GPIOC6/S\M\I\)
PD_I2C_SCL3: R6011.1 R6031.1 U6001.F8(GPIOD1/I2C3_SCL0)
PD_I2C_SDA3: R6000.1 R6028.1 U6001.F9(GPIOD0/I2C3_SDA0)
PECI: R6026.2 R9017.2 U9001.BT34(PECI)
PEDET1#: CON5100.69(PEDET) Q5101.2(G) R5108.1 R5111.2
PEDET4#: CON5101.69(PEDET) Q5102.2(G) R5100.1 R5103.2
PEG_COMP: R9037.2 U9001.G2(PEG_RCOMP)
PEG_RXN0: C2141.1 U9001.E10(PEG_RXN_15)
PEG_RXN0_C: C2141.2 U2000.AJ14(PEX_TX0*)
PEG_RXN1: C2145.1 U9001.E11(PEG_RXN_14)
PEG_RXN1_C: C2145.2 U2000.AG14(PEX_TX1*)
PEG_RXN2: C2136.1 U9001.E12(PEG_RXN_13)
PEG_RXN2_C: C2136.2 U2000.AJ15(PEX_TX2*)
PEG_RXN3: C2137.1 U9001.E13(PEG_RXN_12)
PEG_RXN3_C: C2137.2 U2000.AK16(PEX_TX3*)
PEG_RXN4: C2114.1 U9001.E14(PEG_RXN_11)
PEG_RXN4_C: C2114.2 U2000.AJ17(PEX_TX4*)
PEG_RXN5: C2071.1 U9001.E15(PEG_RXN_10)
PEG_RXN5_C: C2071.2 U2000.AG17(PEX_TX5*)
PEG_RXN6: C2102.1 U9001.E16(PEG_RXN_9)
PEG_RXN6_C: C2102.2 U2000.AJ18(PEX_TX6*)
PEG_RXN7: C2089.1 U9001.E17(PEG_RXN_8)
PEG_RXN7_C: C2089.2 U2000.AK19(PEX_TX7*)
PEG_RXN8: C2189.1 U9001.F18(PEG_RXN_7)
PEG_RXN8_C: C2189.2 U2000.AJ20(PEX_TX8*)
PEG_RXN9: C2191.1 U9001.D19(PEG_RXN_6)
PEG_RXN9_C: C2191.2 U2000.AG20(PEX_TX9*)
PEG_RXN10: C2193.1 U9001.F20(PEG_RXN_5)
PEG_RXN10_C: C2193.2 U2000.AJ21(PEX_TX10*)
PEG_RXN11: C2195.1 U9001.D21(PEG_RXN_4)
PEG_RXN11_C: C2195.2 U2000.AK22(PEX_TX11*)
PEG_RXN12: C2197.1 U9001.F22(PEG_RXN_3)
PEG_RXN12_C: C2197.2 U2000.AJ23(PEX_TX12*)
PEG_RXN13: C2199.1 U9001.D23(PEG_RXN_2)
PEG_RXN13_C: C2199.2 U2000.AG23(PEX_TX13*)
PEG_RXN14: C2201.1 U9001.F24(PEG_RXN_1)
PEG_RXN14_C: C2201.2 U2000.AJ24(PEX_TX14*)
PEG_RXN15: C2203.1 U9001.D25(PEG_RXN_0)
PEG_RXN15_C: C2203.2 U2000.AK25(PEX_TX15*)
PEG_RXP0: C2140.1 U9001.F10(PEG_RXP_15)
PEG_RXP0_C: C2140.2 U2000.AK14(PEX_TX0)
PEG_RXP1: C2144.1 U9001.D11(PEG_RXP_14)
PEG_RXP1_C: C2144.2 U2000.AH14(PEX_TX1)
PEG_RXP2: C2135.1 U9001.F12(PEG_RXP_13)
PEG_RXP2_C: C2135.2 U2000.AK15(PEX_TX2)
PEG_RXP3: C2138.1 U9001.D13(PEG_RXP_12)
PEG_RXP3_C: C2138.2 U2000.AL16(PEX_TX3)
PEG_RXP4: C2115.1 U9001.F14(PEG_RXP_11)
PEG_RXP4_C: C2115.2 U2000.AK17(PEX_TX4)
PEG_RXP5: C2080.1 U9001.D15(PEG_RXP_10)
PEG_RXP5_C: C2080.2 U2000.AH17(PEX_TX5)
PEG_RXP6: C2104.1 U9001.F16(PEG_RXP_9)
PEG_RXP6_C: C2104.2 U2000.AK18(PEX_TX6)
PEG_RXP7: C2093.1 U9001.D17(PEG_RXP_8)
PEG_RXP7_C: C2093.2 U2000.AL19(PEX_TX7)
PEG_RXP8: C2188.1 U9001.E18(PEG_RXP_7)
PEG_RXP8_C: C2188.2 U2000.AK20(PEX_TX8)
PEG_RXP9: C2190.1 U9001.E19(PEG_RXP_6)
PEG_RXP9_C: C2190.2 U2000.AH20(PEX_TX9)
PEG_RXP10: C2192.1 U9001.E20(PEG_RXP_5)
PEG_RXP10_C: C2192.2 U2000.AK21(PEX_TX10)
PEG_RXP11: C2194.1 U9001.E21(PEG_RXP_4)
PEG_RXP11_C: C2194.2 U2000.AL22(PEX_TX11)
PEG_RXP12: C2196.1 U9001.E22(PEG_RXP_3)
PEG_RXP12_C: C2196.2 U2000.AK23(PEX_TX12)
PEG_RXP13: C2198.1 U9001.E23(PEG_RXP_2)
PEG_RXP13_C: C2198.2 U2000.AH23(PEX_TX13)
PEG_RXP14: C2200.1 U9001.E24(PEG_RXP_1)
PEG_RXP14_C: C2200.2 U2000.AK24(PEX_TX14)
PEG_RXP15: C2202.1 U9001.E25(PEG_RXP_0)
PEG_RXP15_C: C2202.2 U2000.AL25(PEX_TX15)
PEG_TXN0: C9005.1 U2000.AM12(PEX_RX0*)
PEG_TXN1: C9007.1 U2000.AM14(PEX_RX1*)
PEG_TXN2: C9009.1 U2000.AP15(PEX_RX2*)
PEG_TXN3: C9011.1 U2000.AM15(PEX_RX3*)
PEG_TXN4: C9013.1 U2000.AM17(PEX_RX4*)
PEG_TXN5: C9015.1 U2000.AP18(PEX_RX5*)
PEG_TXN6: C9017.1 U2000.AM18(PEX_RX6*)
PEG_TXN7: C9019.1 U2000.AM20(PEX_RX7*)
PEG_TXN8: C9021.1 U2000.AP21(PEX_RX8*)
PEG_TXN9: C9023.1 U2000.AM21(PEX_RX9*)
PEG_TXN10: C9025.1 U2000.AM23(PEX_RX10*)
PEG_TXN11: C9027.1 U2000.AP24(PEX_RX11*)
PEG_TXN12: C9029.1 U2000.AM24(PEX_RX12*)
PEG_TXN13: C9031.1 U2000.AM26(PEX_RX13*)
PEG_TXN14: C9033.1 U2000.AP27(PEX_RX14*)
PEG_TXN15: C9035.1 U2000.AM27(PEX_RX15*)
PEG_TXP0: C9004.1 U2000.AN12(PEX_RX0)
PEG_TXP1: C9006.1 U2000.AN14(PEX_RX1)
PEG_TXP2: C9008.1 U2000.AP14(PEX_RX2)
PEG_TXP3: C9010.1 U2000.AN15(PEX_RX3)
PEG_TXP4: C9012.1 U2000.AN17(PEX_RX4)
PEG_TXP5: C9014.1 U2000.AP17(PEX_RX5)
PEG_TXP6: C9016.1 U2000.AN18(PEX_RX6)
PEG_TXP7: C9018.1 U2000.AN20(PEX_RX7)
PEG_TXP8: C9020.1 U2000.AP20(PEX_RX8)
PEG_TXP9: C9022.1 U2000.AN21(PEX_RX9)
PEG_TXP10: C9024.1 U2000.AN23(PEX_RX10)
PEG_TXP11: C9026.1 U2000.AP23(PEX_RX11)
PEG_TXP12: C9028.1 U2000.AN24(PEX_RX12)
PEG_TXP13: C9030.1 U2000.AN26(PEX_RX13)
PEG_TXP14: C9032.1 U2000.AP26(PEX_RX14)
PEG_TXP15: C9034.1 U2000.AN27(PEX_RX15)
PEGX_RST#: Q2015.2(G) R2038.1 R2147.1 U2000.AJ12(PEX_RST*)
PEX_PLL_HVDD: C2125.1 R2020.1 U2000.AH12(PEX_PLL_HVDD)
PEX_TERMP: R2065.2 U2000.AP29(PEX_TERMP)
PEX_VDD: C2045.1 C2047.2 C2048.1 C2049.2 C2050.2 C2054.2 C2055.2 C2060.2 C2061.2 C2062.2 C2155.2 C2159.2 C2222.2 C2223.2 C2224.2 C2225.1 PR9512.1 U2000.AC7(IFP_IOVDD_1) U2000.AC8(IFP_IOVDD_2) U2000.AF6(IFP_IOVDD_3) U2000.AG6(IFP_IOVDD_4) U2000.AG8(IFP_IOVDD_5) U2000.AG9(IFP_IOVDD_6) U2000.AG19(PEX_DVDD_1) U2000.AG21(PEX_DVDD_2) U2000.AG22(PEX_DVDD_3) U2000.AG24(PEX_DVDD_4) U2000.AH21(PEX_DVDD_5) U2000.AH25(PEX_DVDD_6)
PEX_VDD_S: PC9514.1 PC9515.2 PL9501.2 PR9511.2 PR9512.2 PR9519.1
PEXVDD_PWREN: PQ9501.2(G) PQ9502.3(D) PR9520.1 PR9521.2
PEXVDD_PWREN_MOS: PQ9501.3(D) PR9519.2
PGDMON: R9266.2 U9002.Y14(RSVD#Y14)
PLAY_MUTE_LED: Q6805.3(D) R6806.2 R6818.1
PLAY_MUTE_LED_CNTR: Q6805.2(G) R6826.1 U3600.10(GPIO4)
PLT_ID0: R9149.2 R9150.1 U9002.AU46(GPP_F12/SATA_SDATAOUT1)
PLT_ID1: R9151.2 R9152.1 U9002.AU47(GPP_F13/SATA_SDATAOUT0)
PLT_ID2: R9153.2 R9154.1 U9002.BA24(GPP_C10/UART0_RTS#)
PLT_RST#: R9215.1 R9336.2 R9547.2 U9003.1(INB) U9003.2(INA)
PLT_SYSRST_CPU: R9547.1 R9602.1 U9002.AV29(GPP_B13/PLTRST#)
PLTRST#_EC: LED9003.1 R9336.1 U6001.J5(GPIO76/E\C\_\S\C\I\)
PM_PWROK: R6071.2 U6001.K4(GPIO61/R\E\S\E\T\_\O\U\T\) U9002.AU3(SYS_PWROK)
PM_SYNC: R9164.1 U9001.BM34(PM_SYNC)
PM_SYNC_R: R9164.2 U9002.AF3(PM_SYNC)
PM_THRMTRIP#: Q9000.3(COLLECTOR) R1001.1 R1018.1 R1026.1 R1044.1 R2137.2 R9161.2
PM_THRMTRIP#_L: C9195.1 R9141.1 R9161.1 U9002.AD3(THRMTRIP#)
PORTD_A: R3611.2 U3600.42(PORTD_A)
PORTD_A_R: C3611.2 R3611.1
PORTD_B: C3612.2 U3600.43(PORTD_B)
PP_DETECT#: R3079.2 R6237.2 U6001.G10(GPIO50)
PP_DETECT#_EDP: CON3000.27 Q3006.2(G) R3080.2
PP_DETECT#_R: Q3006.3(D) R3079.1
PP_HVA: R3002.2 R3081.1 U6001.H6(GPIOD7)
PP_HVA_R: CON3000.28 R3081.2
PRIVACY_LED#: Q9038.5(G) R6230.2 R18075.1 U6001.A9(GPIOD4/JTAG_TDO1_SWO1)
PRIVACY_LED#_R: Q9038.6(D) R6819.1 R17966.1 R18075.2
PROC_SEL#: R9317.1 R9319.2 U9001.BN1(PROC_SELECT#)
PROCPWRGD: TP9002.1 U9001.BT31(PROCPWRGD) U9002.AE3(CPUPWRGD)
PS8331_1P5V_3V: C3044.1 C3045.1 C3046.1 R3052.1 R3053.1 U3007.21(VDD33_1) U3007.35(VDD33_3) U3007.60(VDD33_5)
PS8331_CEXT_1P5V: C3084.1 R3044.2 U3007.47(CEXT)
PS8331_PC0__EDP: R3066.2 U3007.38(PC0)
PS8331_PC1__EDP: R3065.2 U3007.55(PC1)
PS8331_PD: Q3004.2(G) Q3005.3(D) R3059.1 U3007.50(PD)
PS8331_PI0_EDP: R3064.2 R3077.2 U3007.56(PI0)
PS8331_REXT: R3057.2 U3007.34(REXT)
PS8409_DCIN_ENB: R18068.1 U12006.3(DCIN_ENB)
PS8409_EQ: R18069.1 R18070.1 U12006.5(EQ)
PS8409_HDMI_HPD_R: C3207.1 CON3200.19(HP DET) U12006.21(HPD_SNK) VC3200.1
PS8409_HDMI_ID: R18073.1 U12006.32(HDMI_ID)
PS8409_I2C_ADDR: R18072.1 U12006.31(I2C_ADDR)
PS8409_PRE: R18071.1 U12006.27(PRE)
PS8409_RST#: C12064.1 R18079.1 U12006.35(RESETB)
PS8461_1_CFG0: R518.1 R519.1 U500.28(CFG0)
PS8461_1_CFG1: R514.1 U500.27(CFG1)
PS8461_1_CFG2: R515.1 R516.1 U500.26(CFG2)
PS8461_1_CFG3: R513.1 U500.25(CFG3)
PS8461_1_CFG4: R524.1 R525.1 U500.46(CFG4)
PS8461_1_DP_CADET: R501.2 U500.52(DP_CADET)
PS8461_1_I2C_ADDR: R511.1 R512.1 TP512.1 U500.6(I2C_ADDR)
PS8461_1_IN1_EQ0: R508.2 R509.2 U500.40(IN1_EQ0)
PS8461_1_IN1_EQ1: R506.2 R507.2 U500.41(IN1_EQ1)
PS8461_1_IN2_EQ0: R503.2 R505.2 U500.38(IN2_EQ0)
PS8461_1_IN2_EQ1: R502.2 R504.2 U500.39(IN2_EQ1)
PS8461_1_SW: R510.1 R517.1 U500.9(SW)
PS8461_2_CFG0: R546.1 R547.1 U501.28(CFG0)
PS8461_2_CFG1: R540.1 U501.27(CFG1)
PS8461_2_CFG2: R541.1 R543.1 U501.26(CFG2)
PS8461_2_CFG3: R539.1 U501.25(CFG3)
PS8461_2_CFG4: R549.1 R550.1 U501.46(CFG4)
PS8461_2_DP_CADET: R526.2 U501.52(DP_CADET)
PS8461_2_I2C_ADDR: R537.1 R538.1 TP513.1 U501.6(I2C_ADDR)
PS8461_2_IN1_EQ0: R534.2 R535.2 U501.40(IN1_EQ0)
PS8461_2_IN1_EQ1: R532.2 R533.2 U501.41(IN1_EQ1)
PS8461_2_IN2_EQ0: R529.2 R530.2 U501.38(IN2_EQ0)
PS8461_2_IN2_EQ1: R527.2 R528.2 U501.39(IN2_EQ1)
PS8461_2_SW: R536.1 R545.1 U501.9(SW)
PS_FBVDD_PGOOD: D2008.2(CATHODE2) PR8003.1 U2004.1(I1) U2007.2(INA)
PS_PEXVDD_PGOOD: PR9505.2 PR9506.1 R2093.1 U2005.2(I0) U2006.2(INA)
PSI: PR9013.1 R2043.2 U2000.M7(GPIO6)
PSR_OFF#: R18004.1 R18005.1 R18024.1 U9002.AV7(GPP_J10)
PSR_OFF#_R: CON3000.35 Q9046.6(D) R18002.1
PVADPTR: PC11000.1 PC11001.2 PD2.1 PD3.1 PD11001.2(ANODE) PQ10011.1(S1) PQ10011.2(S2) PQ10011.3(S3) PQ10012.1(S1) PQ10012.2(S2) PQ10012.3(S3) PQ10013.1(S1) PQ10013.2(S2) PQ10013.3(S3) PQ10017.1(E1) PQ10018.1(E1) PQ10019.1(E1) PR11000.1 PR11001.2 PR11009.2 PR11035.1 PR12000.1 PR12034.2
PVCORE_PG: PR19017.2 PR19021.2 PR20060.1 PR20061.1 PR20062.1 PR20063.1 R9129.1 U9000.2(INA)
PVT_CS#: R6205.2 TP6207.1 U6001.L10(P\V\T\_\C\S\0\/GPIO97) U6203.1(CE#)
PVT_HOLD: R6222.2 U6203.7(HOLD#)
PVT_MOSI: R6015.2 TP6205.1 U6203.5(SI)
PVT_MOSI_L: R6015.1 U6001.K12(PVT_MOSI_DIO0/SPIP_MOSI/GPIOA3)
PVT_SCLK: R6014.2 U6203.6(SCK)
PVT_SCLK_L: R6014.1 U6001.L12(PVT_SCLK/SPIP_SCLK/GPIOA1)
PVT_SPI_MISO: R6212.1 U6001.M12(PVT_MISO_DIO1/SPIP_MISO/GPIO95)
PVT_SPI_MISO_R: R6212.2 TP6206.1 U6203.2(SO)
PWM_EC_IN: C859.2 R909.1 R910.2 U6001.F3(GPIOE1/ADC7)
PWM_EC_OUT: R3014.1 U6001.K5(GPIO80/PWM3_LED3)
PWM_LED#: Q6800.2(G) U6001.H10(GPIOC2/PWM1/I2C6_SCL0)
PWR_BTN_OUT#: R6079.2 U6001.D9(KSO16/GPIO03) U9002.BE46(GPD3/PWRBTN#)
PWR_GATE#: PR23020.2 Q9035.3(COLLECTOR) R17908.1 R17911.2
PWR_GOOD_3: LED9002.1 PC25004.2 PR24003.1 PR25018.2 PR25020.1 PU25000.1(OUTPUT) Q9002.5(G) R9283.1 R9284.1 U6001.M4(PWRGD/GPIO72)
PWR_LEVEL: Q2014.1 R2085.2 U2000.N3(GPIO12)
PWRBTN#: C6019.2 R6078.2 R6080.2 U6001.G5(GPIO73/PS2_CLK3/TA2)
R_A_SD#: R6008.1 U6001.L8(GPIO92/I2C2_SCL0)
R_ADP_ID_CHK: R6407.1 U6001.K9(GPIO91/I2C2_SDA0)
R_CNV_RF_RESET#: R4120.1 R4133.2 U4100.58(PCM_SYNC/I2S_WS/NC) U4100.A42(RF_RESET_B/RF_RESET_B)
R_LAN_DIS#: R4026.1 U4000.3(LAN_DISABLE_N)
R_MODEM_CLKREQ: R4134.2 R18066.1 U4100.59(PCM_OUT/I2S_SD_OUT/NC) U4100.A43(CLKREQ0/CLKREQ0)
R_SPK+: C3665.1 L3612.2 L3613.1
R_SPK+_R: C3664.2 CON3602.1 L3612.1
R_SPK-: C3668.1 L3611.2 L3614.1
R_SPK-_R: C3663.2 CON3602.2 L3611.1
R_WWAN_CONFIG_0: CON4201.21(CONFIG0) R4207.1
REC_MUTE_LED: Q6803.3(D) R6808.2 R6811.1
RECORD_MUTE_LED_CNTRL: Q6803.2(G) R6824.1 U3600.11(GPIO5)
REGN6V: PC11007.1 PD11002.1 PU11000.24(REGN)
RIGHT+: TP3603.1 U3600.27(PORTG RIGHT+)
RIGHT-: TP3602.1 U3600.25(PORTG RIGHT-)
ROM_SCLK: R2026.2 R2028.1 U2000.H4(ROM_SCLK)
ROM_SI: R2022.2 R2025.1 U2000.H5(ROM_SI)
ROM_SO: R2027.2 R2029.1 U2000.H7(ROM_SO)
RSMRST#: D6000.2(ANODE) R404.2 R6072.2 U9002.BA47(RSMRST#)
RSMRST#_R: R6072.1 R6077.1 U6001.M10(GPIO84)
RSMRST_PG: D6000.1(CATHODE) PR25019.2 PR25021.2 PU25000.7(OUTPUT) R6073.2
RSMRST_PG_R: R6073.1 U6001.H9(GPIOC1/I2C6_SDA0)
RTC_REST1#_CL: R6174.1 U6002.4(RST1#)
RTC_RST2_CL1: R6175.2 R6504.2 U6002.1(RST2)
RTC_RST2_CL2: Q6005.2(G) R6172.1 R6175.1
RTC_RST2_CL3: Q6004.2(G) R6173.1 R6504.1
RTC_RST#: C9188.1 CON401.9 J9000.1 Q6004.3(D) R9131.2 U9002.BE47(RTCRST#)
RTC_SR01#_CL: R6176.2 U6002.3(SR1#) U6002.7(SR0#)
RTC_X1: C9214.2 R9175.1 U9002.BA49(RTCX1) Y9001.1
RTC_X2: C9215.2 R9175.2 U9002.BA48(RTCX2) Y9001.2
RTD3_CIO_PWR_EN: R9358.2 R17979.2 U9002.AU24(GPP_C12/UART1_RXD/ISH_UART1_RXD) U12002.2
RTD3_CIO_PWR_EN_R: R8020.2 R9589.2 R17979.1 U8001.T5(RTD3_PWR_EN) U12002.4
RTD3_WAKE#: TP9019.1 U9002.BE19(GPP_D1/SPI1_CLK/SBK1_BK1)
RTS5237_AV12: C7323.1 C7324.2 C7325.2 U7301.10(AV12) U7301.14(DV12S)
RTS5237_GPIO: R7307.1 U7301.28(GPIO)
RTS5237_RREF: C7322.2 R7314.1 U7301.9(RREF)
RUNSCI_EC#: R18044.1 U9002.AV21(GPP_C23/UART2_CTS#)
SATA_LED#: D5100.2 D5101.2 R9148.1 R18047.1 U9002.AK48(GPP_E8/SATA_LED#)
SATA_ODD_DA#: R9620.1 R9621.1
SATA_ODD_PWR_EN: TP9031.1 U9002.AT49(GPP_F22/DDPF_CTRLCLK)
SATA_RXN3: C630.1 U9002.L41(PCIE16_RXN/SATA3_RXN)
SATA_RXN3_HDD: C631.2 CON5000.5(RXN)
SATA_RXN3_R1: C630.2 U603.4(B_OUTN)
SATA_RXN3_R2: C631.1 U603.12(B_INN)
SATA_RXP3: C632.1 U9002.M40(PCIE16_RXP/SATA3_RXP)
SATA_RXP3_HDD: C633.2 CON5000.6(RXP)
SATA_RXP3_R1: C632.2 U603.5(B_OUTP)
SATA_RXP3_R2: C633.1 U603.11(B_INP)
SATA_TXN3: C628.1 U9002.B41(PCIE16_TXN/SATA3_TXN)
SATA_TXN3_HDD: C629.2 CON5000.3(TXN)
SATA_TXN3_R1: C628.2 U603.2(A_INN)
SATA_TXN3_R2: C629.1 U603.14(A_OUTN)
SATA_TXP3: C625.1 U9002.C41(PCIE16_TXP/SATA3_TXP)
SATA_TXP3_HDD: C627.2 CON5000.2(TXP)
SATA_TXP3_R1: C625.2 U603.1(A_INP)
SATA_TXP3_R2: C627.1 U603.15(A_OUTP)
SC_PWRSV#: R7303.1 U9002.AH41(GPP_E0/SATAXPCIE0/SATAGP0)
SCARDC6: CON7300.7 U7300.2(SCARDC6)
SCARDC8: CON7300.3 U7300.1(SCARD0C8)
SCARDCLK: CON7300.6 U7300.6(SCARD0CLK)
SCARDDATA: C7311.1 CON7300.5 R7304.1
SCARDFCB: CON7300.4 U7300.3(SCARD0FCB)
SCARDRST: CON7300.8 U7300.5(SCARD0RST)
SCL_BAT_CHG: PD12000.3 PR11019.2 PR12015.2 Q3007.6(D) R6036.2 U6001.C12(GPIOB5/I2C0_SCL0)
SD_CD#: CON7301.18(CS_SW) D7306.2 Q7300.2(G) R7329.1 R7330.2
SD_CD#_R: Q7300.3(D) R7330.1 U7301.30(SD_CD#)
SD_CLK: CON7301.5(CLK/NA) D7305.2 EC9051.1 R7312.2
SD_CLK_R: R7312.1 U7301.17(SP3)
SD_CMD: CON7301.2(CMD/NA) D7304.2 R7311.2
SD_CMD_R: R7311.1 U7301.19(SP4)
SD_D0: CON7301.7(DAT0/RCLK+) D7300.2 EC9047.1 R7313.2
SD_D0+: CON7301.11(NA/DO+) U7301.26(SD_LN0_P)
SD_D0-: CON7301.12(NA/DO-) U7301.25(SD_LN0_M)
SD_D0_R: R7313.1 U7301.16(SP2)
SD_D1: CON7301.8(DAT1/RCLK-) D7301.2 EC9048.1 R7315.2
SD_D1+: CON7301.16(NA/D1+) U7301.22(SD_LN1_P)
SD_D1-: CON7301.15(NA/D1-) U7301.23(SD_LN1_M)
SD_D1_R: R7315.1 U7301.15(SP1)
SD_D2: CON7301.9(DAT2/NA) D7302.2 EC9049.1 R7309.2
SD_D2_R: R7309.1 U7301.21(SP6)
SD_D3: CON7301.1(CD_DAT3/NA) D7303.2 EC9050.1 R7310.2
SD_D3_R: R7310.1 U7301.20(SP5)
SD_WP: CON7301.19(SW_SW) Q7301.2(G) R7331.1 R7333.2
SD_WP_R: Q7301.3(D) R7333.1 U7301.29(SP7)
SDA_BAT_CHG: PD12001.3 PR11018.2 PR12016.2 Q3007.3(D) R6037.2 U6001.B12(GPIOB4/I2C0_SDA0)
SDREG2: C7318.1 U7301.24(SDREG2)
SEL_DP_MUX: Q3001.3(D) R517.2 R545.2 R3042.1
SEL_EDP_MUX: Q3002.3(D) Q9046.5(G) R3045.2 U3007.54(SW)
SEN_A0: R2502.1 VRAM2501.J10(SEN)
SEN_A2: R2501.1 VRAM2500.J10(SEN)
SEN_B0: R2521.1 VRAM2503.J10(SEN)
SEN_B2: R2516.1 VRAM2502.J10(SEN)
SER_IRQ: R9056.2 U9002.AW35(GPP_A6/SERIRQ/ESPI_CS1#)
SKTOCC_N: TP9003.1 U9001.BR33(SKTOCC#)
SLP_A#: CON401.6 PR25013.2 R9095.2
SLP_A#_L: R9095.1 R9595.1 U9002.BE40(GPD6/SLP_A#)
SLP_LAN#: PR22005.2 R9598.1 TP22001.1 U9002.BF40(SLP_LAN#)
SLP_S3#: CON401.2 PQ14002.2(G) PR22006.2 PR22008.2 PR23028.1 PR25012.2 PU23000.2(B) PU23001.1(A) PU23001.2(B) R288.1 R3202.2 R8024.2 R8028.2 R9097.2 R9285.1 U3201.4(EN) U7005.6(CTL1)
SLP_S3#_KBC: R288.2 U6001.D6(KSO14/GPIO82)
SLP_S3#_L: R9097.1 R9593.1 U9002.BF42(GPD4/SLP_S3#)
SLP_S3_5R: PQ14002.5(G) PQ14002.6(D) PR14017.1 Q4105.2(G) Q8000.2(G)
SLP_S4#: CON401.5 D9001.3(CATHODE) PR15004.1 R6022.1 R9098.2 R9281.1 U7003.4(EN) U7004.4(EN) U7005.7(CTL2)
SLP_S4#_KBC: R6022.2 U6001.F11(GPIOA6/PS2_CLK3/TA2/S\H\D\_\C\S)
SLP_S4#_L: R9098.1 R9594.1 U9002.BE42(GPD5/SLP_S4#)
SLP_S5#: CON401.4 R9099.2
SLP_S5#_L: R9099.1 R9600.1 U9002.BC42(GPD10/SLP_S5#)
SLP_WLAN_N: R9596.1 TP9014.1 U9002.BD42(GPD9/SLP_WLAN#)
SM_INTRUDER#: Q9010.3(D) R9205.2 U9002.BB44(INTRUDER#)
SM_RCOMP_0: R9040.1 U9001.G1(DDR_RCOMP_0)
SM_RCOMP_1: R9041.2 U9001.H1(DDR_RCOMP_1)
SM_RCOMP_2: R9042.1 U9001.J2(DDR_RCOMP_2)
SMBCLK: Q9008.6(D1) R9116.1 U9002.BE26(GPP_C0/SMBCLK)
SMBDATA: Q9008.3(D2) R9118.1 U9002.BF26(GPP_C1/SMBDATA)
SMC: PC12007.2 PCN12000.5 PR12015.1
SMD: PC12006.2 PCN12000.6 PR12016.1
SMDDR_VREF_CA_A: C1000.1 R1012.1 U9001.BN13(DDR_VREF_CA)
SMDDR_VREF_DQ0_M3: TP9006.1 U9001.BP13(DDR0_VREF_DQ)
SMDDR_VREF_DQ1_M3: C1088.1 R1039.1 U9001.BR13(DDR1_VREF_DQ)
SML0ALERT#: R9120.1 R9121.1 U9002.BF24(GPP_C5/SML0ALERT#)
SML2ALERT#: R9193.1 R9195.1 U9002.AB47(GPP_H12/SML2ALERT#)
SP_CLK: R6224.2 U6001.H2(GPIO62/PS2_CLK1)
SP_DATA: R6225.2 U6001.J2(GPIO63/PS2_DAT1)
SPI1_CLK: R6016.2 R6190.1 R9200.1 R17980.1
SPI1_CLK_EC: R6016.1 U6001.F12(SHD_SCLK/GPIOA2)
SPI1_CLK_ROM: R6190.2 TP6201.1 U6202.6(CLK) U6204.6(CLK)
SPI1_CLK_TPM: R17980.2 U6500.19(SCLK)
SPI1_IO2: R6152.1 R6214.2 R6215.2 R9211.1 R9212.2 U9002.AY48(SPI0_IO2)
SPI1_IO3: R6218.2 R9214.1 R9216.1 U9002.BA46(SPI0_IO3)
SPI1_SI: R408.2 R6019.2 R6188.1 R9197.1 R17983.1
SPI1_SI_EC: R6019.1 R6229.2 U6001.H11(SHD_MOSI_DIO0/GPIOA4/TB1_TACH2P)
SPI1_SI_ROM: R6188.2 R6202.1 TP6202.1 U6202.5(DI(IO0)) U6204.5(DI(IO0))
SPI1_SI_TPM: R17983.2 U6500.21(MOSI)
SPI1_SO: R6035.2 R6189.1 R9335.1 R17982.1
SPI1_SO_EC: R6035.1 U6001.G12(SHD_MISO_DIO1/GPIO96)
SPI1_SO_ROM: R6189.2 TP6203.1 U6202.2(DO(IO1)) U6204.2(DO(IO1))
SPI1_SO_TPM: R17982.2 U6500.24(MISO)
SPI_CS0#: R6030.2 R6201.2 R9199.1 TP6204.1 U6202.1(C\S\) U6204.1(C\S\)
SPI_CS0#_EC: R6030.1 R6228.1 U6001.G11(S\H\D\_\C\S\0\/GPIOA0)
SPI_TPM_CS#: Q6501.1(S) R9202.1
SPI_TPM_CS#_L: R9202.2 U9002.AT40(SPI0_CS2#)
SPI_TPM_CS#_R: Q6501.3(D) R17981.1
SPI_TPM_CS#_TPM: R6502.2 R17981.2 U6500.20(CS#)
SRTC_RST#: C9190.1 Q6005.3(D) R9136.2 U9002.BD46(SRTCRST#)
SSD1_CLK_REQ0#: CON5100.52(CLKREQ#/NC_52) R9171.1 U9002.BF31(GPP_B5/SRCCLKREQ0#)
SSD1_IF: Q5101.3(D) R5111.1 R9142.1 U9002.AJ43(GPP_E1/SATAXPCIE1/SATAGP1)
SSD2_CLK_REQ6#: CON5101.52(CLKREQ#/NC_52) R9182.1 U9002.AE47(GPP_H0/SRCCLKREQ6#)
SSD2_IF: Q5102.3(D) R5103.1 R9144.1 U9002.AM46(GPP_F1/SATAXPCIE4/SATAGP4)
STRAP0: R2098.1 R2099.2 U2000.J2(STRAP0)
STRAP1: R2024.2 R2036.1 U2000.J7(STRAP1)
STRAP2: R2030.2 R2032.1 U2000.J6(STRAP2)
STRAP3: R2096.2 R2097.1 U2000.J5(STRAP3)
STRAP4: R2091.2 R2092.1 U2000.J3(STRAP4)
STRAP5: R2090.1 R2094.2 U2000.J1(STRAP5)
SUS_CLK_WLAN: R4113.1 R9122.2
SUSACK#: R9102.1 U9002.BE35(GPP_A15/SUSACK#)
SUSCLK32: R9100.1 R9122.1 U9002.BE45(GPD8/SUSCLK)
SUSCLK32_KBC: R9100.2 U6001.L5(GPIOE7/32KCLKIN)
SUSWARN#: R9102.2 U9002.BC37(GPP_A13/SUSWARN#/SUSPWRDNACK)
SWP_PWR: CON9500.4 TP9501.1
SYS_PEX_RST_MON#: R2023.2 R2038.2 U2001.4(OUT Y)
SYS_PEX_RST_MON#_R: R2035.2 U2000.R8(GPIO16)
TACH_FAN1_IN: C6301.1 C6303.2 CON6300.2 R6303.2 U6001.E10(GPIOD3/TB1_TACH2PWM_IN)
TACH_FAN2_IN: C6300.2 C6308.1 CON6301.2 R6305.2 U6001.E5(GPIO40/TA1_TACH1)
TB_HTPLG: D8000.2(ANODE) R9201.1 U9002.AE43(GPP_H16/SML4CLK)
TB_PWR: R8029.2 R9220.1 U8001.V4(FORCE_PWR) U9002.AJ46(GPP_H17/SML4DATA)
TBT_CIO_PLUG_EVENT: D8000.1(CATHODE) R8027.2 U8001.AA1(CIO_PLUG_EVENT#)
TBT_CLK_REQ5#: R9174.1 U8001.Y6(PCIE_CLKREQ#) U9002.AN29(GPP_B10/SRCCLKREQ5#)
TBT_EE_CLK: TP8010.1 U8000.6(CLK) U8001.Y16(EE_CLK)
TBT_EE_CS_N: R8034.2 U8000.1(C\S\) U8001.W18(EE_CS#)
TBT_EE_DI: TP8009.1 U8000.5(DI) U8001.Y18(EE_DI)
TBT_EE_DO: R8037.2 U8000.2(DO) U8001.W16(EE_DO)
TBT_EE_WP_N: R8036.2 U8000.3(W\P\) U8001.W4(EE_WP#)
TBT_GPIO0: R8031.1 U8001.W1(GPIO_0)
TBT_GPIO1: R8032.1 U8001.W2(GPIO_1)
TBT_GPIO8: R8041.2 R8042.2 U8001.W6(GPIO_8)
TBT_HOLD_N: R8039.2 U8000.7(H\O\L\D\)
TBT_I2C_SCL: R8022.1 TP8525.1 U8001.V2(I2C_SCL) U8500.E2(I2C_SCL_SCB2_TBT/GPIO_P1.2)
TBT_I2C_SDA: R8021.1 TP8524.1 U8001.V1(I2C_SDA) U8500.D2(I2C_SDA_SCB2_TBT/GPIO_P1.1)
TBT_MRESET_EC: R6164.2 R6165.1 U6001.J9(GPIO86/I2C4_SDA0/TXD) U8001.E5(RESET#)
TBT_PA_USB2_MXCTL: R8006.1 U8001.R2(PA_USB2_MXCTL)
TBT_PB_USB2_MXCTL: R8007.1 U8001.R1(PB_USB2_MXCTL)
TBT_PERST#: R9586.2 R17978.2 U8001.T4(PERST#) U12001.4(OUT Y)
TBT_PWR_GOOD: R8038.1 U8001.W5(TEST_PWR_GOOD)
TBT_RBIAS: R8033.1 U8001.J6(RBIAS)
TBT_REN_09V: Q7151.2(BASE) R7322.1
TBT_RSENSE: R8033.2 U8001.J5(RSENSE)
TBT_SNK0_AUX_N: C8027.1 R10026.1
TBT_SNK0_AUX_P: C8025.1 R10027.1
TBT_SNK0_AUXN_R: R520.1 R10026.2 U500.57(DP_AUXN_SDA)
TBT_SNK0_AUXP_R: R523.1 R10027.2 U500.58(DP_AUXP_SCL)
TBT_SNK0_HPD: R8005.1 R10038.1 U8001.AA2(DPSNK1_HPD)
TBT_SNK0_HPD_L: R10000.2 R10038.2 U500.49(OUT_HPD)
TBT_SNK0_ML0_N: C8014.1 R10019.1
TBT_SNK0_ML0_N_L: R10019.2 U500.53(OUT_D0N)
TBT_SNK0_ML0_P: C8008.1 R10018.1
TBT_SNK0_ML0_P_L: R10018.2 U500.54(OUT_D0P)
TBT_SNK0_ML1_N: C8010.1 R10021.1
TBT_SNK0_ML1_N_L: R10021.2 U500.50(OUT_D1N)
TBT_SNK0_ML1_P: C8016.1 R10020.1
TBT_SNK0_ML1_P_L: R10020.2 U500.51(OUT_D1P)
TBT_SNK0_ML2_N: C8019.1 R10023.1
TBT_SNK0_ML2_N_L: R10023.2 U500.47(OUT_D2N)
TBT_SNK0_ML2_P: C8018.1 R10022.1
TBT_SNK0_ML2_P_L: R10022.2 U500.48(OUT_D2P)
TBT_SNK0_ML3_N: C8023.1 R10025.1
TBT_SNK0_ML3_N_L: R10025.2 U500.44(OUT_D3N)
TBT_SNK0_ML3_P: C8021.1 R10024.1
TBT_SNK0_ML3_P_L: R10024.2 U500.45(OUT_D3P)
TBT_SNK1_AUX_N: C8042.1 R10037.1
TBT_SNK1_AUX_P: C8040.1 R10036.1
TBT_SNK1_AUXN_R: R542.1 R10037.2 U501.57(DP_AUXN_SDA)
TBT_SNK1_AUXP_R: R544.1 R10036.2 U501.58(DP_AUXP_SCL)
TBT_SNK1_HPD: R8002.1 R10039.1 U8001.Y4(DPSNK2_HPD)
TBT_SNK1_HPD_L: R10011.2 R10039.2 U501.49(OUT_HPD)
TBT_SNK1_ML0_N: C8029.1 R10029.1
TBT_SNK1_ML0_N_L: R10029.2 U501.53(OUT_D0N)
TBT_SNK1_ML0_P: C8028.1 R10028.1
TBT_SNK1_ML0_P_L: R10028.2 U501.54(OUT_D0P)
TBT_SNK1_ML1_N: C8031.1 R10031.1
TBT_SNK1_ML1_N_L: R10031.2 U501.50(OUT_D1N)
TBT_SNK1_ML1_P: C8030.1 R10030.1
TBT_SNK1_ML1_P_L: R10030.2 U501.51(OUT_D1P)
TBT_SNK1_ML2_N: C8035.1 R10033.1
TBT_SNK1_ML2_N_L: R10033.2 U501.47(OUT_D2N)
TBT_SNK1_ML2_P: C8033.1 R10032.1
TBT_SNK1_ML2_P_L: R10032.2 U501.48(OUT_D2P)
TBT_SNK1_ML3_N: C8039.1 R10035.1
TBT_SNK1_ML3_N_L: R10035.2 U501.44(OUT_D3N)
TBT_SNK1_ML3_P: C8037.1 R10034.1
TBT_SNK1_ML3_P_L: R10034.2 U501.45(OUT_D3P)
TBT_TCK: R8016.1 TP8001.1 U8001.W19(TCK)
TBT_TDI: R8014.1 TP8000.1 U8001.W20(TDI)
TBT_TDO: R8017.1 TP8003.1 U8001.Y19(TDO)
TBT_TMS: R8015.1 TP8002.1 U8001.Y20(TMS)
TBT_TMU_CLK_OUT: R8040.1 U8001.Y1(GPIO_3)
TBT_USB_FORCE_PWR: R8035.1 U8001.V5(USB_FORCE_PWR)
TBT_WAKE#: Q8000.1(S) Q8012.1(EMITTER) Q9043.3(D) R8010.2 R8530.1 U8001.Y2(PEWAKE#)
TBT_XTAL_25_IN: L8000.3 R8018.2 U8001.D22(XTAL_25_IN)
TBT_XTAL_25_OUT: L8000.2 R8019.2 U8001.D23(XTAL_25_OUT)
TBTA_AUX_N: C8026.2 U8001.J4(ASBU2)
TBTA_AUX_P: C8024.2 U8001.H4(ASBU1)
TBTA_CA2HD_1_RX_N: C8013.1 CON7100.A10(RX2N) D7112.2(CATHODE) R17931.1
TBTA_CA2HD_1_RX_P: C8012.1 CON7100.A11(RX2P) D7110.2(CATHODE) R17930.1
TBTA_CA2HD_2_RX_N: C8011.1 CON7100.B10(RX1N) D7111.2(CATHODE) R17933.1
TBTA_CA2HD_2_RX_P: C8017.1 CON7100.B11(RX1P) D7113.2(CATHODE) R17932.1
TBTA_CC1: C8507.2 CON7100.B5(CC2) D7103.1 U8500.K2(CC1_P1)
TBTA_CC2: C8512.2 CON7100.A5(CC1) D7102.1 U8500.H2(CC2_P1)
TBTA_DPSRC_AUX_N: C8026.1 R8575.1 R8682.1 U8500.C11(AUX_N_P1/GPIO_P4.3)
TBTA_DPSRC_AUX_P: C8024.1 R8574.1 R8684.1 U8500.B11(AUX_P_P1/GPIO_P4.2)
TBTA_HD2CA_1_TX_N: C8015.1 CON7100.B3(TX2N) D7108.2(CATHODE)
TBTA_HD2CA_1_TX_P: C8009.1 CON7100.B2(TX2P) D7106.2(CATHODE)
TBTA_HD2CA_2_TX_N: C8022.1 CON7100.A3(TX1N) D7115.2(CATHODE)
TBTA_HD2CA_2_TX_P: C8020.1 CON7100.A2(TX1P) D7117.2(CATHODE)
TBTA_HPD: R8501.2 R8557.1 U8001.T2(PA_HPD) U8500.K7(HPD_P1/GPIO_P3.0)
TBTA_I2C_INT#: R8008.2 U8001.M4(PA_I2C_INT) U8500.F2(I2C_INT_TBT_P1/GPIO_P1.3)
TBTA_RX1_N: C8013.2 R8049.1
TBTA_RX1_P: C8012.2 R8048.1
TBTA_RX1N_R: R8049.2 U8001.A21(ASSRXN1)
TBTA_RX1P_R: R8048.2 U8001.B21(ASSRXP1)
TBTA_RX2_N: C8011.2 R8053.1
TBTA_RX2_P: C8017.2 R8052.1
TBTA_RX2N_R: R8053.2 U8001.B15(ASSRXN2)
TBTA_RX2P_R: R8052.2 U8001.A15(ASSRXP2)
TBTA_SBU1: D7114.2(CATHODE) R7176.2 R8533.2
TBTA_SBU1_L: CON7100.B8(RFU2) R7176.1
TBTA_SBU1_R: R8533.1 U8500.A3(SBU1_P1)
TBTA_SBU2: D7116.2(CATHODE) R7175.2 R8534.2
TBTA_SBU2_L: CON7100.A8(RFU1) R7175.1
TBTA_SBU2_R: R8534.1 U8500.A4(SBU2_P1)
TBTA_TX1_N: C8015.2 R8051.1
TBTA_TX1_P: C8009.2 R8050.1
TBTA_TX1N_R: R8051.2 U8001.B19(ASSTXN1)
TBTA_TX1P_R: R8050.2 U8001.A19(ASSTXP1)
TBTA_TX2_N: C8022.2 R8055.1
TBTA_TX2_P: C8020.2 R8054.1
TBTA_TX2N_R: R8055.2 U8001.B17(ASSTXN2)
TBTA_TX2P_R: R8054.2 U8001.A17(ASSTXP2)
TBTA_VBUS_L: C7102.2 C7103.2 C7104.2 C7105.2 C7110.2 CON7100.A4(VBUS) CON7100.A9(VBUS1) CON7100.B4(VBUS2) CON7100.B9(VBUS3) D7101.1 PC10000.1 PC25008.2 PQ10000.1(S1) PQ10000.2(S2) PQ10000.3(S3) PQ10002.1(S) PR10000.2 PR10002.2 PR26013.2 R7101.2 U7112.C2(VBUS #1) U7112.D1(VBUS #2) U7112.D2(VBUS #3) U8500.D1(VBUS_P1)
TBTB_AUX_N: C8047.2 U8001.L5(BSBU2)
TBTB_AUX_P: C8046.2 U8001.L4(BSBU1)
TBTB_CA2HD_1_RX_N: C8034.1 CON7101.A10(RX2N) D7128.2(CATHODE) R17935.1
TBTB_CA2HD_1_RX_P: C8032.1 CON7101.A11(RX2P) D7126.2(CATHODE) R17934.1
TBTB_CA2HD_2_RX_N: C8043.1 CON7101.B10(RX1N) D7127.2(CATHODE) R17937.1
TBTB_CA2HD_2_RX_P: C8041.1 CON7101.B11(RX1P) D7129.2(CATHODE) R17936.1
TBTB_CC1: C8508.2 CON7101.B5(CC2) D7100.1 U8500.K9(CC1_P2)
TBTB_CC2: C8511.2 CON7101.A5(CC1) D7119.1 U8500.K10(CC2_P2)
TBTB_DPSRC_AUX_N: C8047.1 R8573.2 R8681.1 U8500.E11(AUX_N_P2/GPIO_P5.0)
TBTB_DPSRC_AUX_P: C8046.1 R8572.2 R8683.1 U8500.D11(AUX_P_P2/GPIO_P4.6)
TBTB_HD2CA_1_TX_N: C8038.1 CON7101.B3(TX2N) D7124.2(CATHODE)
TBTB_HD2CA_1_TX_P: C8036.1 CON7101.B2(TX2P) D7122.2(CATHODE)
TBTB_HD2CA_2_TX_N: C8045.1 CON7101.A3(TX1N) D7131.2(CATHODE)
TBTB_HD2CA_2_TX_P: C8044.1 CON7101.A2(TX1P) D7133.2(CATHODE)
TBTB_HPD: R8511.2 R8556.1 U8001.T1(PB_HPD) U8500.E10(HPD_P2/GPIO_P3.4)
TBTB_I2C_INT#: R8009.2 U8001.M5(PB_I2C_INT) U8500.G2(I2C_INT_TBT_P2/GPIO_P2.1)
TBTB_RX1_N: C8034.2 R8057.1
TBTB_RX1_P: C8032.2 R8056.1
TBTB_RX1N_R: R8057.2 U8001.B13(BSSRXN1)
TBTB_RX1P_R: R8056.2 U8001.A13(BSSRXP1)
TBTB_RX2_N: C8043.2 R8061.1
TBTB_RX2_P: C8041.2 R8060.1
TBTB_RX2N_R: R8061.2 U8001.A7(BSSRXN2)
TBTB_RX2P_R: R8060.2 U8001.B7(BSSRXP2)
TBTB_SBU1: D7130.2(CATHODE) R7178.2 R8531.1
TBTB_SBU1_L: CON7101.B8(RFU2) R7178.1
TBTB_SBU1_R: R8531.2 U8500.E1(SBU1_P2)
TBTB_SBU2: D7132.2(CATHODE) R7177.2 R8532.1
TBTB_SBU2_L: CON7101.A8(RFU1) R7177.1
TBTB_SBU2_R: R8532.2 U8500.F1(SBU2_P2)
TBTB_TX1_N: C8038.2 R8059.1
TBTB_TX1_P: C8036.2 R8058.1
TBTB_TX1N_R: R8059.2 U8001.B11(BSSTXN1)
TBTB_TX1P_R: R8058.2 U8001.A11(BSSTXP1)
TBTB_TX2_N: C8045.2 R8063.1
TBTB_TX2_P: C8044.2 R8062.1
TBTB_TX2N_R: R8063.2 U8001.B9(BSSTXN2)
TBTB_TX2P_R: R8062.2 U8001.A9(BSSTXP2)
TBTB_VBUS_L: C7100.2 C7107.2 C7108.2 C7109.2 C7111.2 CON7101.A4(VBUS) CON7101.A9(VBUS1) CON7101.B4(VBUS2) CON7101.B9(VBUS3) D7118.1 PC10001.1 PC25009.2 PQ10001.1(S1) PQ10001.2(S2) PQ10001.3(S3) PQ10003.1(S) PR10001.2 PR10003.2 PR26015.2 R7100.2 U7113.C2(VBUS #1) U7113.D1(VBUS #2) U7113.D2(VBUS #3) U8500.L3(VBUS_P2)
THER_ALERT#: R2095.2 U2000.M2(GPIO9)
THERM#: R6301.2 R6401.2 U6401.4(OVERT#)
THERM_SCI#: R6300.2 R9033.2 U6401.6(ALERT#)
THERM_SCL: Q6402.1(S) R6406.2 U6401.8(SCLK)
THERM_SDA: Q6402.4(S) R6405.2 U6401.7(SDA)
THERM_SHDWN_R: R2132.2 R2133.2 R2137.1 U2008.2(INA)
THERMDA_1: C6402.1 Q6401.2(BASE) Q6401.3(COLLECTOR) U6401.2(DXP)
THERMDC_1: C6402.2 Q6401.1(EMITTER) U6401.3(DXN)
THERMDN: TP2011.1 U2000.K4(THERMDN)
THERMDP: TP2006.1 U2000.K3(THERMDP)
THRMTRIP#: Q9000.1(EMITTER) R9019.1 U9001.J31(THERMTRIP#)
TLS_ENCRYPTION: R9135.1 R9138.2 U9002.BE25(GPP_C2/SMBALERT#)
TOUCH_INT#: CON3001.8 R3029.1 U9002.AP21(GPP_C13/UART1_TXD/ISH_UART1_TXD)
TOUCH_PWR_EN: R3019.2 R9231.1 U9002.BE14(GPP_D23/ISH_I2C2_SCL/I2C3_SCL)
TOUCH_RST#: C3041.2 CON3001.7 R9240.2 U9002.BB20(GPP_D10/ISH_SPI_CLK/GSPI2_CLK)
TP#AN35: TP9043.1 U9002.AN35(TP#AN35)
TP_SCAN_DISABLE#: R6167.2 R6359.1 U6001.D8(KSO17/GPIOB1)
TP_SCAN_DISABLE#_R: CON6351.8 Q6351.6(D) R6359.2
TP_SIGNAL1: CON6351.9 CON6352.4
TP_SIGNAL2: CON6351.10 CON6352.3
TP_SIGNAL3: CON6351.11 CON6352.2
TP_SIGNAL4: CON6351.12 CON6352.1
TPCLK-1: C6351.1 CON6351.6 R6353.2
TPDATA-1: C6355.1 CON6351.7 R6354.2
TPEV_PEG_VIEW_2: R9347.2 R9348.2 U9001.E3(IST_TRIG)
TPM_CLKRUN_N: R9082.1 U9002.AV32(GPP_A8/CLKRUN#)
TPM_PLTRST#: Q6500.6(D) R6507.1 R6510.2 U6500.17(RST#)
TPM_PP: R6500.1 R6509.1 U6500.7(PP)
TPM_R_IRQ#: R6501.1 R9252.2 U6500.18(PIRQ#) U9002.AL15(GPP_I3/DPPE_HPD3/DISP_MISC3)
TPM_VDD1: C6501.2 R6503.1 R6508.2 U6500.1(VDD#1)
TS_STOP_EN_IN: CON3001.9 R3023.1
TS_VREF: TP2008.1 U2000.AP9(TS_VREF)
TYPEC1_USB0: PD11008.2(CATHODE2) PQ10000.5(D) PQ10011.5(D) PQ10014.3(D)
TYPEC2_USB0: PD11008.1(CATHODE1) PQ10001.5(D) PQ10012.5(D) PQ10015.3(D)
TYPEC_DET#: PQ26002.2(BASE) PR26003.2 Q7130.3(D) Q7130.6(D) Q7151.3(COLLECTOR)
UART0_RXD: R9021.1 R9032.2 U9002.BE23(GPP_C8/UART0_RXD)
UART0_RXD_R: JCN9000.29(UART0_RXD) R9021.2 TP9001.1
UART0_TXD: R9020.1 R9031.2 U9002.BB24(GPP_C9/UART0_TXD)
UART0_TXD_R: JCN9000.28(UART0_TXD) R9020.2 TP9000.1
UART_WAKE#: R4123.1 U4100.53(UART_WAKE#_3.3V/NC)
UIM_CLK: C4214.2 CON4200.5(CLK) CON4201.32(SIM_CLK) ESD4200.3
UIM_DATA: C4207.2 CON4200.4(I_O) CON4201.34(SIM_IO) ESD4200.1 R4212.1
UIM_RESET: C4210.2 CON4200.7(RST) CON4201.30(SIM_RST) ESD4200.6
UIM_VPP: CON4200.6(VPP) ESD4200.4 TP4200.1
UMA_DIS#_GPU: R6045.2 R6047.1 R17984.1
UMA_ONLY#: Q3002.1(S) R3048.1 U3008.6(S) U3009.6(S) U3010.6(S) U9002.AN47(GPP_F0/SATAXPCIE3/SATAGP_3)
UMA_SKU_ONC: Q3001.2(G) Q3002.2(G) Q3003.3(D) R3047.2
USB2_COMP: R9058.1 U9002.F4(USB2_COMP)
USB30_RX1+: CON7001.6 U7002.4(IN3) U7002.7(NC_7) U9002.C11(USB31_1_RXP)
USB30_RX1-: CON7001.5 U7002.5(IN4) U7002.6(NC_6) U9002.D11(USB31_1_RXN)
USB30_RX3+: C612.1 U9002.C10(USB31_3_RXP)
USB30_RX3+_C: CON7000.6 R9526.2 U7001.2(IN2) U7001.9(NC_9)
USB30_RX3-: C615.1 U9002.B10(USB31_3_RXN)
USB30_RX3-_C: CON7000.5 R9525.2 U7001.1(IN1) U7001.10(NC_10)
USB30_RX4+: C613.1 U9002.J15(USB31_4_RXP)
USB30_RX4+_C: CON7002.6 R9528.2 U7000.2(IN2) U7000.9(NC_9)
USB30_RX4-: C616.1 U9002.K16(USB31_4_RXN)
USB30_RX4-_C: CON7002.5 R9527.2 U7000.1(IN1) U7000.10(NC_10)
USB30_RXN3-_C: C615.2 U601.7(BOUT-)
USB30_RXN3-_R: R9525.1 U601.5(BIN-)
USB30_RXN4-_C: C616.2 U600.7(BOUT-)
USB30_RXN4-_R: R9527.1 U600.5(BIN-)
USB30_RXP3+_C: C612.2 U601.8(BOUT+)
USB30_RXP3+_R: R9526.1 U601.4(BIN+)
USB30_RXP4+_C: C613.2 U600.8(BOUT+)
USB30_RXP4+_R: R9528.1 U600.4(BIN+)
USB30_TX1+: C602.1 U9002.F7(USB31_1_TXP)
USB30_TX1-: C610.1 U9002.F9(USB31_1_TXN)
USB30_TX3+: C1121.1 U9002.G12(USB31_3_TXP)
USB30_TX3+_C_R: C607.2 CON7000.9 U7001.5(IN4) U7001.6(NC_6)
USB30_TX3-: C1122.1 U9002.F11(USB31_3_TXN)
USB30_TX3-_C_R: C605.2 CON7000.8 U7001.4(IN3) U7001.7(NC_7)
USB30_TX4+: C1119.1 U9002.C14(USB31_4_TXP)
USB30_TX4+_C_R: C608.2 CON7002.9 U7000.5(IN4) U7000.6(NC_6)
USB30_TX4-: C1120.1 U9002.B14(USB31_4_TXN)
USB30_TX4-_C_R: C609.2 CON7002.8 U7000.4(IN3) U7000.7(NC_7)
USB30_TXN1-_C: C610.2 CON7001.8 U7002.2(IN2) U7002.9(NC_9)
USB30_TXN3-_C: C1122.2 U601.10(AIN-)
USB30_TXN3-_R: C605.1 U601.2(AOUT-)
USB30_TXN4-_C: C1120.2 U600.10(AIN-)
USB30_TXN4-_R: C609.1 U600.2(AOUT-)
USB30_TXP1+_C: C602.2 CON7001.9 U7002.1(IN1) U7002.10(NC_10)
USB30_TXP3+_C: C1121.2 U601.11(AIN+)
USB30_TXP3+_R: C607.1 U601.1(AOUT+)
USB30_TXP4+_C: C1119.2 U600.11(AIN+)
USB30_TXP4+_R: C608.1 U600.1(AOUT+)
USB_C_INT#: D6001.2(ANODE) R6018.2 U6001.J11(GPIOA7/PS2_DAT3/TB2/SHD_DIO3)
USB_CHARGER_STATUS#: R6062.2 U6001.G2(GPIO66) U7005.9(/STATUS)
USBP1+: L7002.4 U9002.J2(USB2P_1)
USBP1+_C: C7012.1(K1) CON7001.3 L7002.3
USBP1-: L7002.1 U9002.J3(USB2N_1)
USBP1-_C: C7012.2(K2) CON7001.2 L7002.2
USBP2+: R4217.2 U9002.N15(USB2P_2)
USBP2+_C: CON4201.7(USB_DP) R4217.1
USBP2-: R4224.2 U9002.N13(USB2N_2)
USBP2-_C: CON4201.9(USB_DN) R4224.1
USBP4+: U7005.3(DP_OUT) U9002.L9(USB2P_4)
USBP4+_C: C7010.2(K2) CON7000.3 L7000.3
USBP4+_CHA: L7000.4 U7005.10(DP_IN)
USBP4-: U7005.2(DM_OUT) U9002.M10(USB2N_4)
USBP4-_C: C7010.1(K1) CON7000.2 L7000.2
USBP4-_CHA: L7000.1 U7005.11(DM_IN)
USBP5+: L7001.1 U9002.L2(USB2P_5)
USBP5+_C: C7011.2(K2) CON7002.3 L7001.2
USBP5-: L7001.4 U9002.M1(USB2N_5)
USBP5-_C: C7011.1(K1) CON7002.2 L7001.3
USBP7+: L3004.1 U9002.L3(USB2P_7)
USBP7+_C: CON3000.31 L3004.2
USBP7-: L3004.4 U9002.L4(USB2N_7)
USBP7-_C: CON3000.32 L3004.3
USBP8+: R7202.2 U9002.G5(USB2P_8)
USBP8+_C: CON7200.5 ESD7200.3 R7202.1
USBP8-: R7201.2 U9002.G4(USB2N_8)
USBP8-_C: CON7200.6 ESD7200.1 R7201.1
USBP9+: R7306.2 U9002.N8(USB2P_9)
USBP9+_R: R7306.1 U7300.9(DP)
USBP9-: R7305.2 U9002.M6(USB2N_9)
USBP9-_R: R7305.1 U7300.8(DM)
USBP11+: U8500.A6(D+_SYS_P1) U9002.P9(USB2P_11)
USBP11+_BOT: CON7100.A6(DP1) D7109.2(CATHODE) U8500.B1(D+_B_P1)
USBP11+_TOP: CON7100.B6(DP2) D7104.2(CATHODE) U8500.A1(D+_T_P1)
USBP11-: U8500.A7(D-_SYS_P1) U9002.R10(USB2N_11)
USBP11-_BOT: CON7100.A7(DN1) D7107.2(CATHODE) U8500.C1(D-_B_P1)
USBP11-_TOP: CON7100.B7(DN2) D7105.2(CATHODE) U8500.A2(D-_T_P1)
USBP13+: U8500.F11(D+_SYS_P2) U9002.N2(USB2P_13)
USBP13+_BOT: CON7101.A6(DP1) D7125.2(CATHODE) U8500.K1(D+_B_P2)
USBP13+_TOP: CON7101.B6(DP2) D7120.2(CATHODE) U8500.G1(D+_T_P2)
USBP13-: U8500.G11(D-_SYS_P2) U9002.N3(USB2N_13)
USBP13-_BOT: CON7101.A7(DN1) D7123.2(CATHODE) U8500.L1(D-_B_P2)
USBP13-_TOP: CON7101.B7(DN2) D7121.2(CATHODE) U8500.H1(D-_T_P2)
USBP14+: L4100.3 L4100.4 TP4107.1 U4100.70(USB_D+/NC) U9002.F6(USB2P_14)
USBP14-: L4100.1 L4100.2 TP4106.1 U4100.69(USB_D-/NC) U9002.E5(USB2N_14)
USIM_DETECT: C4200.1 CON4200.1(CD) CON4201.66(SIM_DET) R4204.1
VADPBL: PD11007.2(ANODE) PQ10006.5(D) PQ10007.5(D) PQ10013.5(D) PQ10016.3(D)
VCORE_CS1: PR19013.1 PR20002.1 PU19000.5(CS1)
VCORE_CS2: PR19015.2 PR20020.1 PU19000.4(CS2)
VCORE_CS3: PR19018.1 PR20032.1 PU19000.3(CS3)
VCORE_CS4: PR19020.2 PR20047.1 PU19000.2(CS4)
VCORE_CS_SUM: PR19013.2 PR19015.1 PR19018.2 PR19020.1 PU19000.18(CS_SUMA)
VCORE_PE: PR19057.1 U6001.G3(GPIOF1/ADC8)
VCORE_PWM1: PR20001.1 PU19000.43(PWM1)
VCORE_PWM2: PR20016.1 PU19000.42(PWM2)
VCORE_PWM3: PR20031.1 PU19000.41(PWM3)
VCORE_PWM4: PR20045.1 PU19000.40(PWM4)
VCORE_VDIFF: PR19026.1 PU19000.6(VDIFFA)
VCORE_VFB: PR19026.2 PR19027.1 PU19000.7(VFBA)
VCORE_VORTN: PR19035.1 PU19000.9(VORTNA)
VCORE_VOSEN: PR19033.1 PU19000.8(VOSENA)
VGA_XTALIN: C2183.1 U2000.H3(XTAL_IN) Y2000.1
VGA_XTALOUT: C2182.1 U2000.H2(XTAL_OUT) Y2000.3
VGPU_CORE_SENSE: PR9023.1 PR9025.2 U2000.L4(VDD_SENSE)
VGPU_CORE_SENSE_S: U2000.U1(VDDS_SENSE)
VGT_VCCSENSE: PR19040.1 PR19042.2 U9001.AH38(VCCGT_SENSE)
VGT_VSSSENSE: PR19044.2 PR19046.1 U9001.AH37(VSSGT_SENSE)
VID0_VCCIO: PR17002.1 PR17003.2 PR17004.1 PU17000.4(C0)
VID1_VCCIO: PR17000.1 PR17001.2 PR17005.1 PU17000.3(C1)
VMA_CLK0: R2511.2 U2000.R30(FBA_CLK0) VRAM2501.J12(CK)
VMA_CLK0#: R2512.2 U2000.R31(FBA_CLK0*) VRAM2501.J11(CK#)
VMA_CLK1: R2509.2 U2000.AB31(FBA_CLK1) VRAM2500.J12(CK)
VMA_CLK1#: R2510.2 U2000.AC31(FBA_CLK1*) VRAM2500.J11(CK#)
VMA_DQ0: U2000.L28(FBA_D0) VRAM2501.A4(DQ0 | DQ24)
VMA_DQ1: U2000.M29(FBA_D1) VRAM2501.A2(DQ1 | DQ25)
VMA_DQ2: U2000.L29(FBA_D2) VRAM2501.B4(DQ2 | DQ26)
VMA_DQ3: U2000.M28(FBA_D3) VRAM2501.B2(DQ3 | DQ27)
VMA_DQ4: U2000.N31(FBA_D4) VRAM2501.E4(DQ4 | DQ28)
VMA_DQ5: U2000.P29(FBA_D5) VRAM2501.E2(DQ5 | DQ29)
VMA_DQ6: U2000.R29(FBA_D6) VRAM2501.F4(DQ6 | DQ30)
VMA_DQ7: U2000.P28(FBA_D7) VRAM2501.F2(DQ7 | DQ31)
VMA_DQ8: U2000.J28(FBA_D8) VRAM2501.A11(DQ8 | DQ16)
VMA_DQ9: U2000.H29(FBA_D9) VRAM2501.A13(DQ9 | DQ17)
VMA_DQ10: U2000.J29(FBA_D10) VRAM2501.B11(DQ10 | DQ18)
VMA_DQ11: U2000.H28(FBA_D11) VRAM2501.B13(DQ11 | DQ19)
VMA_DQ12: U2000.G29(FBA_D12) VRAM2501.E11(DQ12 | DQ20)
VMA_DQ13: U2000.E31(FBA_D13) VRAM2501.E13(DQ13 | DQ21)
VMA_DQ14: U2000.E32(FBA_D14) VRAM2501.F11(DQ14 | DQ22)
VMA_DQ15: U2000.F30(FBA_D15) VRAM2501.F13(DQ15 | DQ23)
VMA_DQ16: U2000.C34(FBA_D16) VRAM2501.U11(DQ16 | DQ8)
VMA_DQ17: U2000.D32(FBA_D17) VRAM2501.U13(DQ17 | DQ9)
VMA_DQ18: U2000.B33(FBA_D18) VRAM2501.T11(DQ18 | DQ10)
VMA_DQ19: U2000.C33(FBA_D19) VRAM2501.T13(DQ19 | DQ11)
VMA_DQ20: U2000.F33(FBA_D20) VRAM2501.N11(DQ20 | DQ12)
VMA_DQ21: U2000.F32(FBA_D21) VRAM2501.N13(DQ21 | DQ13)
VMA_DQ22: U2000.H33(FBA_D22) VRAM2501.M11(DQ22 | DQ14)
VMA_DQ23: U2000.H32(FBA_D23) VRAM2501.M13(DQ23 | DQ15)
VMA_DQ24: U2000.P34(FBA_D24) VRAM2501.U4(DQ24 | DQ0)
VMA_DQ25: U2000.P32(FBA_D25) VRAM2501.U2(DQ25 | DQ1)
VMA_DQ26: U2000.P31(FBA_D26) VRAM2501.T4(DQ26 | DQ2)
VMA_DQ27: U2000.P33(FBA_D27) VRAM2501.T2(DQ27 | DQ3)
VMA_DQ28: U2000.L31(FBA_D28) VRAM2501.N4(DQ28 | DQ4)
VMA_DQ29: U2000.L34(FBA_D29) VRAM2501.N2(DQ29 | DQ5)
VMA_DQ30: U2000.L32(FBA_D30) VRAM2501.M4(DQ30 | DQ6)
VMA_DQ31: U2000.L33(FBA_D31) VRAM2501.M2(DQ31 | DQ7)
VMA_DQ32: U2000.AG28(FBA_D32) VRAM2500.U4(DQ24 | DQ0)
VMA_DQ33: U2000.AF29(FBA_D33) VRAM2500.U2(DQ25 | DQ1)
VMA_DQ34: U2000.AG29(FBA_D34) VRAM2500.T4(DQ26 | DQ2)
VMA_DQ35: U2000.AF28(FBA_D35) VRAM2500.T2(DQ27 | DQ3)
VMA_DQ36: U2000.AD30(FBA_D36) VRAM2500.N4(DQ28 | DQ4)
VMA_DQ37: U2000.AD29(FBA_D37) VRAM2500.N2(DQ29 | DQ5)
VMA_DQ38: U2000.AC29(FBA_D38) VRAM2500.M4(DQ30 | DQ6)
VMA_DQ39: U2000.AD28(FBA_D39) VRAM2500.M2(DQ31 | DQ7)
VMA_DQ40: U2000.AJ29(FBA_D40) VRAM2500.U11(DQ16 | DQ8)
VMA_DQ41: U2000.AK29(FBA_D41) VRAM2500.U13(DQ17 | DQ9)
VMA_DQ42: U2000.AJ30(FBA_D42) VRAM2500.T11(DQ18 | DQ10)
VMA_DQ43: U2000.AK28(FBA_D43) VRAM2500.T13(DQ19 | DQ11)
VMA_DQ44: U2000.AM29(FBA_D44) VRAM2500.N11(DQ20 | DQ12)
VMA_DQ45: U2000.AM31(FBA_D45) VRAM2500.N13(DQ21 | DQ13)
VMA_DQ46: U2000.AN29(FBA_D46) VRAM2500.M11(DQ22 | DQ14)
VMA_DQ47: U2000.AM30(FBA_D47) VRAM2500.M13(DQ23 | DQ15)
VMA_DQ48: U2000.AN31(FBA_D48) VRAM2500.A11(DQ8 | DQ16)
VMA_DQ49: U2000.AN32(FBA_D49) VRAM2500.A13(DQ9 | DQ17)
VMA_DQ50: U2000.AP30(FBA_D50) VRAM2500.B11(DQ10 | DQ18)
VMA_DQ51: U2000.AP32(FBA_D51) VRAM2500.B13(DQ11 | DQ19)
VMA_DQ52: U2000.AM33(FBA_D52) VRAM2500.E11(DQ12 | DQ20)
VMA_DQ53: U2000.AL31(FBA_D53) VRAM2500.E13(DQ13 | DQ21)
VMA_DQ54: U2000.AK33(FBA_D54) VRAM2500.F11(DQ14 | DQ22)
VMA_DQ55: U2000.AK32(FBA_D55) VRAM2500.F13(DQ15 | DQ23)
VMA_DQ56: U2000.AD34(FBA_D56) VRAM2500.A4(DQ0 | DQ24)
VMA_DQ57: U2000.AD32(FBA_D57) VRAM2500.A2(DQ1 | DQ25)
VMA_DQ58: U2000.AC30(FBA_D58) VRAM2500.B4(DQ2 | DQ26)
VMA_DQ59: U2000.AD33(FBA_D59) VRAM2500.B2(DQ3 | DQ27)
VMA_DQ60: U2000.AF31(FBA_D60) VRAM2500.E4(DQ4 | DQ28)
VMA_DQ61: U2000.AG34(FBA_D61) VRAM2500.E2(DQ5 | DQ29)
VMA_DQ62: U2000.AG32(FBA_D62) VRAM2500.F4(DQ6 | DQ30)
VMA_DQ63: U2000.AG33(FBA_D63) VRAM2500.F2(DQ7 | DQ31)
VMA_WCK01: U2000.K31(FBA_WCK01) VRAM2501.D4(WCK01 | WCK23)
VMA_WCK01#: U2000.L30(FBA_WCK01*) VRAM2501.D5(WCK01# | WCK23#)
VMA_WCK23: U2000.H34(FBA_WCK23) VRAM2501.P4(WCK23 | WCK01)
VMA_WCK23#: U2000.J34(FBA_WCK23*) VRAM2501.P5(WCK23# | WCK01#)
VMA_WCK45: U2000.AG30(FBA_WCK45) VRAM2500.P4(WCK23 | WCK01)
VMA_WCK45#: U2000.AG31(FBA_WCK45*) VRAM2500.P5(WCK23# | WCK01#)
VMA_WCK67: U2000.AJ34(FBA_WCK67) VRAM2500.D4(WCK01 | WCK23)
VMA_WCK67#: U2000.AK34(FBA_WCK67*) VRAM2500.D5(WCK01# | WCK23#)
VMB_CLK0: R2520.2 U2000.D12(FBB_CLK0) VRAM2503.J12(CK)
VMB_CLK0#: R2519.2 U2000.E12(FBB_CLK0*) VRAM2503.J11(CK#)
VMB_CLK1: R2515.2 U2000.E20(FBB_CLK1) VRAM2502.J12(CK)
VMB_CLK1#: R2514.2 U2000.F20(FBB_CLK1*) VRAM2502.J11(CK#)
VMB_DQ0: U2000.G9(FBB_D0) VRAM2503.A4(DQ0 | DQ24)
VMB_DQ1: U2000.E9(FBB_D1) VRAM2503.A2(DQ1 | DQ25)
VMB_DQ2: U2000.G8(FBB_D2) VRAM2503.B4(DQ2 | DQ26)
VMB_DQ3: U2000.F9(FBB_D3) VRAM2503.B2(DQ3 | DQ27)
VMB_DQ4: U2000.F11(FBB_D4) VRAM2503.E4(DQ4 | DQ28)
VMB_DQ5: U2000.G11(FBB_D5) VRAM2503.E2(DQ5 | DQ29)
VMB_DQ6: U2000.F12(FBB_D6) VRAM2503.F4(DQ6 | DQ30)
VMB_DQ7: U2000.G12(FBB_D7) VRAM2503.F2(DQ7 | DQ31)
VMB_DQ8: U2000.G6(FBB_D8) VRAM2503.A11(DQ8 | DQ16)
VMB_DQ9: U2000.F5(FBB_D9) VRAM2503.A13(DQ9 | DQ17)
VMB_DQ10: U2000.E6(FBB_D10) VRAM2503.B11(DQ10 | DQ18)
VMB_DQ11: U2000.F6(FBB_D11) VRAM2503.B13(DQ11 | DQ19)
VMB_DQ12: U2000.F4(FBB_D12) VRAM2503.E11(DQ12 | DQ20)
VMB_DQ13: U2000.G4(FBB_D13) VRAM2503.E13(DQ13 | DQ21)
VMB_DQ14: U2000.E2(FBB_D14) VRAM2503.F11(DQ14 | DQ22)
VMB_DQ15: U2000.F3(FBB_D15) VRAM2503.F13(DQ15 | DQ23)
VMB_DQ16: U2000.C2(FBB_D16) VRAM2503.U11(DQ16 | DQ8)
VMB_DQ17: U2000.D4(FBB_D17) VRAM2503.U13(DQ17 | DQ9)
VMB_DQ18: U2000.D3(FBB_D18) VRAM2503.T11(DQ18 | DQ10)
VMB_DQ19: U2000.C1(FBB_D19) VRAM2503.T13(DQ19 | DQ11)
VMB_DQ20: U2000.B3(FBB_D20) VRAM2503.N11(DQ20 | DQ12)
VMB_DQ21: U2000.C4(FBB_D21) VRAM2503.N13(DQ21 | DQ13)
VMB_DQ22: U2000.B5(FBB_D22) VRAM2503.M11(DQ22 | DQ14)
VMB_DQ23: U2000.C5(FBB_D23) VRAM2503.M13(DQ23 | DQ15)
VMB_DQ24: U2000.A11(FBB_D24) VRAM2503.U4(DQ24 | DQ0)
VMB_DQ25: U2000.C11(FBB_D25) VRAM2503.U2(DQ25 | DQ1)
VMB_DQ26: U2000.D11(FBB_D26) VRAM2503.T4(DQ26 | DQ2)
VMB_DQ27: U2000.B11(FBB_D27) VRAM2503.T2(DQ27 | DQ3)
VMB_DQ28: U2000.D8(FBB_D28) VRAM2503.N4(DQ28 | DQ4)
VMB_DQ29: U2000.A8(FBB_D29) VRAM2503.N2(DQ29 | DQ5)
VMB_DQ30: U2000.C8(FBB_D30) VRAM2503.M4(DQ30 | DQ6)
VMB_DQ31: U2000.B8(FBB_D31) VRAM2503.M2(DQ31 | DQ7)
VMB_DQ32: U2000.F24(FBB_D32) VRAM2502.U4(DQ24 | DQ0)
VMB_DQ33: U2000.G23(FBB_D33) VRAM2502.U2(DQ25 | DQ1)
VMB_DQ34: U2000.E24(FBB_D34) VRAM2502.T4(DQ26 | DQ2)
VMB_DQ35: U2000.G24(FBB_D35) VRAM2502.T2(DQ27 | DQ3)
VMB_DQ36: U2000.D21(FBB_D36) VRAM2502.N4(DQ28 | DQ4)
VMB_DQ37: U2000.E21(FBB_D37) VRAM2502.N2(DQ29 | DQ5)
VMB_DQ38: U2000.G21(FBB_D38) VRAM2502.M4(DQ30 | DQ6)
VMB_DQ39: U2000.F21(FBB_D39) VRAM2502.M2(DQ31 | DQ7)
VMB_DQ40: U2000.G27(FBB_D40) VRAM2502.U11(DQ16 | DQ8)
VMB_DQ41: U2000.D27(FBB_D41) VRAM2502.U13(DQ17 | DQ9)
VMB_DQ42: U2000.G26(FBB_D42) VRAM2502.T11(DQ18 | DQ10)
VMB_DQ43: U2000.E27(FBB_D43) VRAM2502.T13(DQ19 | DQ11)
VMB_DQ44: U2000.E29(FBB_D44) VRAM2502.N11(DQ20 | DQ12)
VMB_DQ45: U2000.F29(FBB_D45) VRAM2502.N13(DQ21 | DQ13)

# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.05V_DEEP_SUS_S:
  vias: v1(289.34,64.48) v4(290.61,65.14) v4(291.37,65.14)
+1.05V_LAN: length 8.5
  BOTTOM w0.203: U4000.43 v1(25.74,119.98) ; v1(28.33,119.98) 28.14,120.17 U4000.37 ; v1(21.75,126.58) 21.75,126.38 22.29,125.84 U4000.11 ; U4000.40 v1(26.94,119.99) ; U4000.8 21.91,124.64 v1(21.5,125.06) ; U4000.16 v1(24.94,128.74) ; U4000.22 v1(27.34,128.08)
  vias: v1(17.69,122.52) v1(17.69,121.88) v1(18.32,122.52) v1(18.32,121.88) v1(23.02,127.34) v1(23.91,119.09) v1(24.54,119.09)
+1.5V_S:
  vias: v1(103.28,35.02)
+1.8V: length 577.1
  TOP w0.152: 238.28,4.41 238.1,4.6 U6004.1
  TOP w0.203: U12003.5 50.66,63.35 50.46,63.56 R18003.1 ; v1(242.27,3.67) 242.01,3.93 R9502.2 R9514.1 240.95,3.93 240.62,3.6 239.99,3.6 239.65,3.93 R9513.1 238.76,3.93 238.28,4.41
  TOP w0.457: v1(288.68,61.71) 289.05,61.34 289.05,60.58 289.31,60.31 289.31,57.34 287.92,55.95 287.92,51.79 286.84,50.71 v1(284.21,50.71)
  TOP w0.508: R3609.2 332.4,13.34 332.4,13.34 332.37,13.34 332.15,13.12 332.15,13.09 v1(332.15,13.09) ; v1(300.77,20.92) 300.77,25.87 300.07,26.57 299.41,26.57 298.86,27.12 298.86,28.54 298.1,29.3 297.59,29.3 v1(296.83,30.06) ; v1(351.47,8.19) 351.75,7.91 R3683.2 ; R9533.1 22.52,105.89 v1(22.38,105.75) ; v1(332.42,3.9) 332.31,4.01 R3622.1 ; R9535.1 25.05,90.65 v1(25.05,90.18) ; R18003.1 50.71,64.45 51.25,65 R18024.2 52.22,65 v1(52.23,64.99) ; v1(347.3,4.64) 346.98,4.64 R3604.1 ; R3601.1 v1(347.5,7.36) ; v1(184.51,30.91) 184.56,30.86 184.56,18.53 182.53,16.5 182.53,10 183.42,9.11 v1(184.18,9.11)
  IN1 w0.508: v1(351.47,8.19) 351.46,8.2 348.34,8.2 v1(347.5,7.36) ; v1(69.5,67.2) 70.69,66 75.98,66 77.63,64.35 77.63,62.07 79.15,60.54 79.15,59.78 80.17,58.76 80.93,58.76 81.57,58.13 81.57,57.62 81.9,57.29 87.97,57.29 88.39,57.71 88.39,58.1 91.22,60.94 91.22,61.56 91.73,62.07 92.76,62.07 93.14,61.68 94.44,61.68 95.57,60.54 98.09,60.54 98.46,60.91 98.46,60.92 99.12,61.58 103.26,61.58 104.91,59.93 104.91,50.54 107.39,48.06 107.39,38.53 108.9,37.02 108.9,36.16 110.19,34.87 110.19,32.68 112.86,30.01 176.44,30.01 176.97,29.48 180.42,29.48 181.86,30.91 v1(184.51,30.91)
  IN2 w0.508: v1(288.68,61.71) 285.88,64.51 282.76,64.51 281.2,66.07 281.2,67.21 277.36,71.06 276.42,71.06 275.41,72.07 274.69,72.07 272.98,73.78 271.53,73.78 269.91,75.4 v3(269.91,75.5) ; v1(22.38,105.75) 23.96,104.18 23.96,102.1 24.87,101.18 24.87,99.74 23.04,97.91 23.04,93.87 25.05,91.86 v1(25.05,90.18) 28.76,90.18 29.67,89.27 29.67,83.43 32.94,80.16 32.94,77.8 34.65,76.09 34.65,75.55 38.74,71.46 40.32,71.46 41.1,70.68 41.1,70.02 42.23,68.89 46.76,68.89 50.65,64.99 v1(52.23,64.99) 53.35,64.99 58.4,70.04 61.91,70.04 62.69,69.26 67.11,69.26 67.65,68.72 68.54,68.72 69.5,67.76 v1(69.5,67.2) ; v1(332.42,3.9) 332.42,3.98 333.11,4.67 335.83,4.67 336.58,5.42 336.58,7.08 337.5,8 341.07,8 342.43,9.36 344.8,9.36 346.16,8 346.87,8 v1(347.5,7.36) ; v1(268.38,6.19) 268.57,6.38 268.57,6.94 269.73,8.09 270.29,8.09 276.26,14.06 276.26,18.12 278.8,20.66 278.8,23.2 279.83,24.23 279.83,24.79 279.39,25.23 279.39,27.38 279.65,27.64 279.65,29.23 v1(279.18,29.7) 279.22,29.75 279.3,29.75 279.91,30.36 279.91,33.21 281.46,34.76 281.46,37.68 285.15,41.37 v1(285.15,41.62) 284.21,42.56 v1(284.21,50.71)
  IN4 w0.508: v1(296.83,30.06) 294.61,30.06 293.78,29.24 291.23,29.24 289.83,30.64 285.62,30.64 284.89,29.91 284.89,28.79 284.49,28.39 282.89,28.39 281.77,29.5 279.37,29.5 v1(279.18,29.7) ; v1(347.3,4.64) 347.5,4.84 v1(347.5,7.36) ; v1(268.38,6.19) 268.38,5.55 266.35,3.52 250.02,3.52 249.87,3.67 v1(242.27,3.67) 241.21,3.67 241,3.47 234.44,3.47 233.31,4.6 216.46,4.6 215.96,5.09 206.86,5.09 198.58,13.38 198.58,14.01 197.56,15.04 187.84,15.04 185.31,12.51 185.31,10.24 v1(184.18,9.11) ; v1(300.77,20.92) 303.56,23.71 315.37,23.71 317.54,21.54 318.51,21.54 319.16,22.19 321.88,22.19 322.97,21.1 325.74,21.1 332.15,14.69 v1(332.15,13.09) 332.77,12.46 332.77,7.84 332.62,7.69 332.62,6.9 333.08,6.44 333.08,4.66 332.42,4 v1(332.42,3.9)
  BOTTOM w0.254: CON10002.1 246.83,6.05 246.56,5.78 246.56,4.84 245.4,3.67 v1(242.27,3.67)
  BOTTOM w0.381: R9352.2 269.57,75.17 v3(269.91,75.5)
  BOTTOM w0.508: PR25004.2 296.58,30.32 v1(296.83,30.06)
  vias: v1(285.15,42.38) v1(285.27,40.22)
+1.8V_AMP: length 55.7
  TOP w0.381: v1(192.82,153.89) 193.33,154.4 Q9042.5 ; Q9042.2 v1(193.33,152.14)
  IN1 w0.508: v1(224.56,157.45) 223.43,157.45 222.92,156.94 222.92,154.52 222.08,153.68 217.3,153.68 216.71,154.28 212.95,154.28 210.6,151.93 204.93,151.93 203.68,150.67 198.32,150.67 197.44,151.55 196.48,152.52 v1(195.59,152.52)
  IN2 w0.508: v1(194.88,155.16) 194.09,155.16 v1(192.82,153.89)
  IN4 w0.508: v1(193.33,152.14) 193.33,152.74 192.82,153.25 v1(192.82,153.89) ; v1(195.59,152.52) 195.28,152.82 195.28,154.75 v1(194.88,155.16) 196.39,156.67 198.29,156.67 198.33,156.63 198.34,156.63 198.91,156.06 v1(199.38,156.06) v1(199.38,156.69)
  BOTTOM w0.254: v1(192.82,153.89) 192.95,153.89 193.33,154.27 Q9042.5 ; v1(195.59,152.52) 195.23,152.87 195.23,153.9 R3646.1 ; R3647.1 v1(194.88,155.16) ; v1(224.56,157.45) U3603.G3 U3603.F3 ; Q9042.2 v1(193.33,152.14)
  vias: v1(198.79,156.3)
+1.8V_CPAVDD18:
  vias: v1(333.23,3.62)
+1.8V_DEEP_SUS: length 592.5
  TOP w0.381: R9057.1 267.44,73.8 267.46,73.8 R9056.1 268.29,73.92 v3(268.32,73.92) 269.17,74.77 270.03,74.77 270.49,75.23 271.63,75.23 v1(271.66,75.25) ; 247.13,85.18 247.18,85.12 247.18,84.61 R17947.1 ; v1(246.59,82.69) 246.2,82.31 245.98,82.31 245.57,82.72 245.57,83.58 245.52,83.63 245.52,83.73 246.05,84.26 246.1,84.26 246.11,84.27 246.3,84.27 246.41,84.16 R17947.1 ; R9545.1 248.55,82.19 248.55,82.77 248.57,82.79 247.93,83.43 247.46,83.43 R17948.1 246.91,83.66 246.91,83.98 R17947.1 ; v1(249.33,70.58) 249.76,70.14 249.76,70.11 R17902.1
  TOP w0.508: v1(195.74,100.42) 195.74,99.15 194.09,97.5 188.34,97.5 188.3,97.54 187.79,97.54 187.75,97.5 186.62,97.5 185.83,98.29 v1(185.83,98.49) ; v1(260.47,19.27) 261.36,18.38 264.57,18.38 265.21,17.74 265.21,17.11 266.1,16.22 272.7,16.22 274.78,18.3 v1(274.78,18.51) ; v3(258.82,69.65) 258.82,69.61 R9341.1 ; 283.5,42.76 284.11,43.38 286.23,43.38 PR22012.1 290.58,41.6 v1(290.68,41.49) ; R3643.2 195.28,155.67 v1(194.88,156.07) ; v1(266.63,75.61) 266.48,75.61 266.07,75.19 ; R618.1 v1(22.52,108.94) ; v1(25.13,87.34) 24.81,87.66 R621.1
  IN1 w0.508: v1(114.77,83.33) 114.43,82.99 114.43,79.63 112.38,77.57 v1(112.38,76.65) ; v1(194.67,152.62) 194.04,151.98 194.04,151.55 193.28,150.79 191.95,150.79 190.91,149.75 190.91,141.31 190.41,140.81 190.41,134.08 191.22,133.26 193.38,133.26 197.31,129.33 v1(197.75,129.33)
  IN2 w0.381: v3(258.82,69.65) 258.25,69.65 256.82,71.08 256.24,71.08 255.45,70.29 255.45,69.85 255.66,69.63 255.66,68.16 255.25,67.76 255.25,66.72 255.53,66.44 255.53,64.15 254.31,62.93 250.07,62.93 247.67,65.33 247.67,68.02 248.06,68.42 248.06,68.67 248.95,69.56 248.95,70.19 v1(249.33,70.58) 249.33,70.83 249.71,71.21 249.71,71.85 248.89,72.67 248.89,73.31 247.94,74.26 247.94,75.15 246.67,76.42 246.67,76.54 245.9,77.31 245.9,78.07 246.29,78.45 246.29,82.39 v1(246.59,82.69)
  IN2 w0.508: v3(268.32,73.92) v1(266.63,75.61) ; v1(22.52,108.94) 22.52,106.93 21.79,106.2 21.79,103.1 22.1,102.78 22.1,93.72 24.19,91.63 24.19,89.75 25.13,88.81 v1(25.13,87.34) 26.07,87.34 28.07,85.33 28.07,80.86 31.86,77.08 v1(32.39,77.08) 32.77,77.08 33.48,76.37 33.48,71.92 35.05,70.36 36.8,70.36 40.13,67.03 46.25,67.03 49.52,63.76 54.68,63.76 59.11,68.19 61.98,68.19 62.36,68.57 66.33,68.57 68.33,66.56 69.71,66.56 70.43,67.28 78.75,67.28 83.97,72.5 84.52,72.5 84.94,72.91 86.21,72.91 86.65,72.48 90.5,72.48 92.15,74.13 92.97,74.13 95.18,76.34 96.71,76.34 97.57,75.48 v1(97.57,75.27) ; v1(260.47,19.27) 260.31,19.43 260.31,21.03 259.26,22.07 259.26,23.69 259.05,23.91 259.05,26.85 257.71,28.19 v1(257.71,30.37) ; v1(197.75,129.33) 197.75,127.5 196.84,126.59 196.84,117.88 195.74,116.78 195.74,102.95 195.07,102.28 195.07,100.83 195.49,100.42 v1(195.74,100.42) ; v1(282.1,43.27) 282.1,42.25 279.04,39.19 279.04,33.92 279.32,33.64 279.32,32.49 278.44,31.62 278.44,28.12 278.19,27.88 278.19,20.91 275.79,18.51 v1(274.78,18.51)
  IN3 w0.508: v1(118.74,87.81) 118.74,86.69 115.37,83.33 v1(114.77,83.33) ; v1(97.57,75.27) 97.61,75.32 97.68,75.32 98.32,75.95 102.2,75.95 102.9,76.65 v1(112.38,76.65) 162.78,76.65 181.21,95.09 182.05,95.09 185.46,98.49 v1(185.83,98.49)
  IN4 w0.508: v1(249.33,70.58) 249.64,70.88 249.64,72.05 248.85,72.84 247.58,72.84 246.03,74.38 246.03,75.09 245.72,75.4 245.72,76.73 243.95,78.5 242.65,78.5 242.17,78.98 240.28,78.98 236.11,83.15 231.87,83.15 231.08,82.36 226.37,82.36 224.78,80.77 223.34,80.77 222.66,80.08 220.35,80.08 218.11,82.32 204.18,82.32 203.86,82 203.11,82 202.39,82.72 202.39,83.56 199.68,86.27 199.68,86.86 197.62,88.92 197.62,90.09 196.03,91.69 196.03,95.45 195.35,96.14 195.35,100.03 v1(195.74,100.42) ; v1(194.67,152.62) 194.67,154.07 194.04,154.7 194.04,155.23 v1(194.88,156.07)
  BOTTOM w0.203: v1(260.47,19.27) 260.47,18.93 260.74,18.65 R9001.1
  BOTTOM w0.254: R9079.2 270.42,74.89 270.91,74.89 271.26,75.25 v1(271.66,75.25)
  BOTTOM w0.305: U3011.5 20.24,67.65
  BOTTOM w0.381: v1(290.68,41.49) 290.74,41.54 290.74,42.64 PR25005.1
  BOTTOM w0.508: R17985.2 125.36,91.72 124.3,90.65 123.46,90.65 123.21,90.41 123.21,87.89 122.82,87.49 119.06,87.49 v1(118.74,87.81) ; R9196.1 273,75.79 274.26,74.53 274.26,74.36 R9065.2 274.74,74.26 275.64,74.26 280.39,69.5 280.39,67.58 280.97,67 280.97,63.7 278.93,61.66 278.93,56.66 281.04,54.54 281.04,54 281.64,53.41 281.64,49.44 282.86,48.22 282.86,44.92 281.46,43.52 v1(281.46,43.27) ; v1(257.71,30.37) 257.71,30.3 257.33,29.93 R6098.1 ; 20.24,67.65 20.24,71.84 25.48,77.08 v1(32.39,77.08)
  vias: v1(281.46,41.87) v1(282.73,43.27) v1(283.37,43.27) v1(283.88,40.22) v3(271.96,76.85)
+1.8V_DEEP_SUS_P1: length 12.2
  TOP w0.381: R17902.2 250.98,69.91 250.98,70.46 250.96,70.48 250.96,70.86 250.66,71.15 R9591.1 250.66,71.99 250.48,72.18 250.48,73.24 v1(250.35,73.37) 250.35,73.62 250.98,74.26 C9225.2 251.23,74.46 251.23,74.82 v1(251.34,74.93)
  IN2 w0.508: v1(253.32,78.53) 253.22,78.53 252.72,78.03 252.72,77.73 252.38,77.38 252.38,76.67 251.62,75.91 251.62,75.21 v1(251.34,74.93)
  BOTTOM w0.254: U9002.BB11 253.31,78.53 v1(253.32,78.53) ; U9002.AR15 251.61,75.2 v1(251.34,74.93) 251.12,74.71 U9002.AN15
+1.8V_SM:
  vias: v1(279.41,19.14)
+1.8V_USBP3: length 15.3
  TOP w0.508: R9533.2 21.74,107.24 v1(21.5,107.48) 21.74,107.73 R618.2
  IN1 w0.508: v1(22.77,111.47) 21.5,110.2 v1(21.5,107.48) 21.5,104.86 v1(22.89,103.46)
  BOTTOM w0.203: U601.3 21.93,107.15 21.57,106.8 21.22,106.8 C618.1
  BOTTOM w0.457: R602.2 v1(22.89,103.46)
  BOTTOM w0.508: v1(21.5,107.48) 21.2,107.48 C618.1 ; R9531.2 v1(22.77,111.47)
+1.8V_USBP4: length 15.4
  TOP w0.508: v1(23.4,91.02) 23.9,91.02 R9535.2 ; R621.2 23.78,89.5 v1(23.4,89.12)
  IN2 w0.508: v1(23.4,91.02) 23.37,91.02 23.4,91 v1(23.4,89.12) 23.4,85.69 v1(24.54,84.55)
  BOTTOM w0.203: 23.92,88.67 24.11,88.86 U600.3
  BOTTOM w0.508: R615.2 24.12,92.43 23.4,91.71 v1(23.4,91.02) ; R604.2 v1(24.54,84.55) ; 23.92,88.67 23.7,88.46 22.93,88.46 C619.1 22.65,88.74 23.03,89.12 v1(23.4,89.12)
+1.8V_VDD18: length 4.8
  TOP w0.203: U3600.50 344.02,9.08
  TOP w0.254: R3601.2 C3603.1 346.02,8.77 345.98,8.73 C3604.2 345.25,8.73 v1(344.81,8.3) 344.02,9.08
+1.8VPCU: length 434.8
  TOP w0.254: 340.72,74.41 340.64,74.32 U4103.5 339.44,74.32 339.02,73.9 339.02,72.76 338.79,72.53 338.79,70.86 338.95,70.69 U4102.5
  TOP w0.381: 340.72,74.41 340.72,74.82 339.91,75.63 337.9,75.63 v1(337.32,76.21) ; v1(348.47,28.31) 348.75,28.59 348.75,28.92 348.93,29.1 348.93,30.22 349.87,31.16 349.87,31.31 350.19,31.64 350.91,31.64 v1(351.36,32.09)
  TOP w0.508: v1(281.26,28.31) 281.24,28.34 281.24,28.39 280.28,29.34 R6237.1 ; PR22012.2 288.21,40.4 288.71,39.89 288.71,37.69 287.48,36.46 287.48,34.33 287.33,34.18
  IN2 w0.381: v1(347.5,59.65) 347.5,58.64 351.44,54.7 351.44,50.51 352.71,49.24 354.03,49.24 357.94,45.33 357.94,37.51 v1(357.38,36.95)
  IN2 w0.508: v1(348.47,28.31) 347.81,28.31 346.56,27.07 346.56,19.27 348.06,17.77 348.06,12.33 346.23,10.5 344.23,10.5 343.69,11.04 341.38,11.04 339.5,9.16 330,9.16 327.36,6.52 325.86,6.52 323.58,8.8 321.67,8.8 321.14,8.27 319.03,8.27 318.01,9.29 313.65,9.29 309.92,5.56 301.26,5.56 298.14,8.69 297.47,8.69 297.38,8.6 288.53,8.6 288.44,8.51 285.24,8.51 283.93,9.82 ; v1(264.83,11.77) 264.19,12.41 264.19,13.63 263.3,14.52 263.3,14.9 262.41,15.79 261.55,15.79 260.61,16.73 260.61,18.4 261.14,18.94 261.14,19.44 260.9,19.68 260.9,21.28 260.54,21.65 260.54,24.45 260.46,24.53 260.46,26.35 258.98,27.83 v1(258.98,30.39)
  IN2 w1.016: 182.66,13.3 179.94,10.58 135.85,10.58 133,13.43 108.36,13.43
  IN3 w0.381: v1(357.38,36.95) 354.46,34.03 353.3,34.03 v1(351.36,32.09) ; 186.68,99.46 186.66,99.48 184.79,99.48 184.23,98.92 181.67,98.92 v1(179.71,96.97)
  IN3 w1.016: 190.23,85.89 190.23,88.15 187.48,90.9 187.48,94.2 186.21,95.47 186.21,97.67 186.68,98.14 186.68,100.59 185.33,101.94 185.33,103.62 184.2,104.75 184.2,121.97 185.77,123.53 186.6,123.53 187.15,124.09 187.15,128.95 188.09,129.88 188.09,136.44 189.57,137.92 189.57,139.22 189.3,139.49 189.3,141.27 189.51,141.48 189.51,146.88 188.79,147.6 188.79,149.79
  IN4 w0.381: v1(337.32,76.21) 336.73,76.8 332.42,76.8 331.12,75.5 331.12,72.81 331.25,72.68 331.25,69.05 330.61,68.42 330.61,64.18 332.34,62.45 335.69,62.45 336.07,62.83 337.22,62.83 338.23,61.81 340.65,61.81 341.92,63.08 344.33,63.08 347.5,59.91 v1(347.5,59.65)
  BOTTOM w0.254: v1(179.71,96.97) 179.71,95.82 174.27,90.38 174.27,88.25 173.54,87.52 130.72,87.52 128.47,89.77 126.38,89.77 R17907.2
  BOTTOM w0.508: R6097.1 258.86,29.77 258.98,29.89 v1(258.98,30.39) ; v1(264.83,11.77) 265.08,11.77 265.65,11.2 265.65,10.52 265.13,10 v1(265.13,5.09)
  vias: v1(105.82,22.06) v1(105.87,14.01) v1(106.51,13.98) v1(183.04,32.6) v1(183.17,10.5) v1(183.34,33.16) v1(183.52,82.27) v1(183.52,81.45) v1(183.52,80.7) v1(183.67,32.6) v1(183.8,11.14) v1(183.8,10.5) v1(183.98,33.16) v1(184.31,32.6) v1(184.44,11.77) v1(184.44,11.14) v1(184.44,10.5) v1(193.1,83.17) v1(193.55,83.63) v1(193.96,156.81) v1(194.6,156.81) v1(197.39,84.04) v1(197.39,83.4) v1(281.21,33.49) v1(281.21,32.86) v1(281.85,33.49) v1(281.85,32.86) v1(286.29,33.41) v1(286.29,32.77) v1(286.93,33.41) v1(286.93,32.77)
+1.8VPCU_S:
  vias: v1(294.16,27.52) v4(292.77,25.62) v4(293.53,25.62) v4(294.29,25.62)
+2.5VSUS:
  vias: v1(175.17,22.65) v1(175.8,22.65) v1(182.68,48.53) v1(182.68,47.89) v1(182.79,40.91) v1(182.79,40.27) v1(183.17,46.32) v1(183.97,59.02) v1(183.97,58.38) v1(187.38,36.67) v1(187.38,36.03) v1(187.38,35.4) v1(187.38,34.76) v1(187.38,34.13)
+2.5VSUS_S:
  vias: v1(191.84,28.84)
+3V: length 1240.2
  TOP w0.102: R1045.1 158.55,45.26 v1(158.22,45.58)
  TOP w0.114: v1(342.68,19.12) 342.31,18.75 R3602.2
  TOP w0.152: U6004.8 236.36,4.6 236.18,4.41
  TOP w0.191: 61.65,61.15 61.83,61.33 U3007.49 ; v1(65.82,70.32) 65.44,69.94 64.98,69.94 64.73,69.69 U3007.26
  TOP w0.203: R6225.1 261.53,31.21 261.17,31.56 R6224.1 259.95,31.56 v1(259.87,31.49) ; 249.05,38.19 249.05,37.4 249.32,37.14 249.35,37.14 249.63,36.86 249.63,36.47 249.61,36.46 R17888.2 ; 249.05,38.19 249.08,38.22 U3009.5 ; 249.05,38.19 v1(249.05,38.95) ; R6091.2 193.04,22.22 193.58,21.68 193.58,20.92
  TOP w0.254: U3607.5 341.61,22.6 341.28,22.93 341.28,23.33 341.03,23.59 v1(341.03,23.76) ; R9052.1 262.94,57.41 262.46,57.89 262.46,58.21 C2230.2 ; R9187.2 264.47,77.02 v1(264.83,77.38) 265.16,77.38 R9172.2 ; Q9008.2 264.7,82.39 264.87,82.39 R9126.1 265.23,83.02 265.28,83.07 v3(265.28,83.63) ; JDIM1000.255 179.1,47.26 179.03,47.18 ; v1(263.18,7.46) 263.18,6.82 259.53,3.18 236.76,3.18 236.18,3.76 236.18,4.41 ; U3008.5 v1(253.52,38.95) ; U3010.5 257.21,43.91 257.72,44.41 258.86,44.41 ; v1(178.72,30.7) 178.72,30.8 179.1,31.18 JDIM1003.255
  TOP w0.279: U603.16 63.9,48.87 64.04,48.73 64.04,48.35 ; R2132.1 223.29,81.19 223.14,81.35 223.14,81.95 223.43,82.24 U2008.5
  TOP w0.305: v3(267.91,77.43) 267.91,77.6 269,78.69 269,79.19 v3(269.08,79.27)
  TOP w0.381: PR9819.1 200.7,55.02 v1(200.32,54.64) 199.92,54.24 PR9811.1 ; v1(349.92,59.5) 350.81,60.42 v1(350.81,63.08) ; 264.45,62.07 263.94,62.07 R9543.2 ; v1(243.75,46.83) 243.52,46.6 R6824.2 243.58,45.95 244.13,45.4 244.13,44.9 244.51,44.52 R911.1 ; 193.58,20.92 Q9032.2 ; 193.58,20.92 193.58,20.11 v1(192.97,19.5) 193.25,19.5 R6090.2 192.75,18.28 R9508.1 ; 193.58,20.92 Q9032.5 ; v1(269.52,59.21) 269.46,59.21 R9077.2 ; v1(256.9,34.53) 256.83,34.6 R9330.2 ; v1(226.25,87.69) 226.25,88.01 226.51,88.27 228.76,88.27 229.13,87.9 R2146.1 229.13,86.56 v1(229.11,86.32) ; v1(272.12,51.81) 272.02,51.81 270.95,52.87 268.38,52.87 ; R2132.1 222.66,80.86 v1(222.54,80.99) 222.54,80.48 222.8,80.22 C2228.2
  TOP w0.508: R9002.2 131.39,110.07 131.35,110.11 R9301.2 129.93,109.45 v1(129.93,108.96) ; R3060.2 58.55,69.81 57.89,69.15 v1(57.89,67.88) 57.89,67.26 ; v1(60.13,60.68) C3047.1 61.18,60.68 61.65,61.15 ; R3059.2 58.97,58.64 58.83,58.5 58.83,57.71 59.77,56.77 v1(60.98,56.77) 60.98,57.36 61.21,57.59 R3068.1 R3067.1 ; v1(65.98,57.51) 65.82,57.67 R3064.1 ; v1(65.98,57.51) 65.98,57.33 66.43,56.89 67.38,56.89 R3063.1 68.1,57.36 R3062.1 ; v1(65.98,57.51) 65.33,56.86 R3065.1 ; v1(183.97,60.56) 183.84,60.7 v1(180.22,60.7) ; v1(272.61,44.9) 272.61,45.78 269.21,49.18 269.21,50.57 267.98,51.81 ; R631.1 R633.1 R634.1 54.86,49.87 55.25,50.26 56.32,50.26 56.94,50.87 56.94,50.89 57.17,51.12 C653.2 ; C1103.1 187.86,60.03 v1(187.48,60.03) 187.48,60.7 188.09,61.3 190.38,61.3 ; v1(123.76,153) 123.76,152.58 PR19017.1 ; v1(191.09,68.65) 190.38,67.93 190.38,61.3 ; v1(182.79,41.59) 180.83,41.59 180.52,41.9 179.2,41.9 178.48,42.63 C1026.2 C1072.1 179.5,45.11 179.03,45.58 179.03,47.18 ; R3619.2 333.71,13.96 333.66,14.01 332.1,14.01 330.95,15.15 328.5,15.15 328.12,15.53 v1(328.12,16.93) ; PR9820.2 203.2,54.48 v1(202.85,54.83) ; R18011.1 53.49,63.97 R3058.2 53.49,65.74 55.01,67.26 57.89,67.26 ; 190.38,61.3 190.38,55.74 191.68,54.45 v1(194.22,54.45) ; R9075.2 259.85,66.59 v1(259.64,66.59) ; R3066.1 v1(59.16,66.64) 58.52,66.64 57.89,67.26 ; R7331.2 31.03,79.21 v1(30.89,79.21) ; v1(245.02,83.35) 245.02,82.39 246.03,81.37 246.03,80.42 246.41,80.04 246.41,79.59 247.43,78.58 247.43,78.4 R9247.2 247.62,77.88 247.62,77.33 248.09,76.86 248.09,76.19 247.67,75.77 R9245.2 247.67,75.18 248.34,74.51 R9246.2 R9244.2 ; R3606.2 335.46,17.71 335.46,18.67 335.98,19.19 336.57,19.19 336.87,19.49 336.87,21.26 v1(335.64,22.49) ; R9234.1 v1(103.92,2.3) ; C621.2 64.17,46.32 63.91,46.57 v1(63.91,46.95) 64.04,47.08 64.04,48.35 ; R3045.1 R3047.1 78.78,61.81 v1(79.42,61.18) ; R6179.1 251.87,43.01 v1(251.87,42.49) ; R7329.2 35.85,76.54 34.98,75.68 33.15,75.68 v1(32.54,75.07) ; R3042.2 v1(84.11,61.08) ; v1(178.72,30.7) 178.72,30.29 175.42,26.99 v1(175.42,25.49) ; R9232.1 v1(105.92,2.3) ; v1(105.56,9.51) 105.56,8.65 106.03,8.18 106.03,7.56 105.44,6.97 C6353.1 105.94,6.32 v1(106.08,6.19) ; R626.1 66.37,51.74 66.71,51.4 66.71,50.74 67.27,50.18 67.27,49.04 ; R3048.2 82.12,61.75 v1(82.12,61.18) 82.46,61.18 82.96,61.69 R3043.2
  IN1 w0.508: v1(24.42,93.69) 24.42,91.66 25.76,90.31 25.76,87.57 28,85.33 28,82.11 v1(30.89,79.21) 28.78,77.1 v1(28.78,74.03) 31.5,74.03 v1(32.54,75.07) ; 105.32,3.24 105.92,2.63 v1(105.92,2.3) ; 105.32,3.24 105.67,3.24 106.81,4.38 106.81,5.7 106.36,6.16 106.1,6.16 v1(106.08,6.19) ; 105.32,3.24 104.6,3.24 103.92,2.55 v1(103.92,2.3) ; v1(198.92,49.74) 199.16,49.74 200.32,50.9 200.32,54.31 ; 200.32,54.31 v1(200.32,54.64) 199.88,55.08 197.77,55.08 196.88,54.19 194.47,54.19 v1(194.22,54.45) ; 200.32,54.31 200.82,53.81 202.22,53.81 202.85,54.45 v1(202.85,54.83) ; v1(265.72,58.38) 266.1,58 267.68,58 v1(268,57.69) ; v1(182.79,39) 183.24,39 184.5,37.75 184.5,35.19 181.09,31.78 181.09,31.16 179.99,30.06 179.1,30.06 178.72,30.44 v1(178.72,30.7) ; v1(349.92,35.27) 349.92,34.63 348.44,33.16 346.54,33.16 344.05,30.67 340.73,30.67 340.63,30.57 340.39,30.57 339.25,29.43 335.82,29.43 335.32,28.93 330.71,28.93 v1(329.44,30.19) ; v1(183.97,60.56) 184.5,60.03 v1(187.48,60.03) 187.48,72.3 186.52,73.27 186.52,78.42 188.91,80.81 188.91,83.82 188.9,83.83 188.9,87.32 v1(187.61,88.61) ; v1(257.72,38.66) 257.72,39.08 256.19,40.6 253.75,40.6 v1(251.87,42.49)
  IN2 w0.254: v1(264.83,77.38) 262.58,79.63 262.58,80.41 260.73,82.26 v1(259.98,82.26)
  IN2 w0.381: v1(204.27,89.98) 203.71,89.98 201.58,87.85 198.79,87.85 198.07,87.13 198.07,86.66 198.46,86.27 198.9,86.27 199.86,85.32 199.86,82.83 195.61,78.58 191.65,78.58 189.3,76.23 189.3,71.48 191.09,69.69 v1(191.09,68.65) ; 269.33,79.82 269.33,79.39 269.2,79.27 v3(269.08,79.27) ; v1(222.54,80.99) 222.54,81.57 221.8,82.31 221.8,83.35 220.25,84.9 220.25,86.7 v1(220.08,86.87) ; v1(260.1,85.16) 260.13,85.18 260.13,85.21 260.48,85.56 261.98,85.56 262.76,84.78 263.42,84.78 264.57,83.63 v3(265.28,83.63) ; v1(263.43,56.17) 263.43,56.15 v1(262.67,55.39)
  IN2 w0.508: v1(123.76,153) 123.76,152.47 124.75,151.47 124.75,142.46 124.24,141.95 124.24,141.31 123.48,140.55 v1(123.48,139.66) ; 236.28,85.64 236.79,85.64 239.29,83.13 241.94,83.13 242.43,83.63 243.2,83.63 243.54,83.29 244.95,83.29 v1(245.02,83.35) ; 236.28,85.64 236.28,86.38 236.86,86.97 246.66,86.97 249.46,89.77 250.95,89.77 251.19,90.01 v1(251.24,90.01) 251.24,89.91 251.9,89.24 254.71,89.24 254.78,89.18 255.27,89.18 255.96,89.87 258.74,89.87 259.42,89.19 259.42,88.03 259.77,87.67 260.33,87.67 v1(260.46,87.8) 260.64,87.97 260.64,88.53 261.27,88.53 265.28,84.52 v3(265.28,83.63) 265.03,83.38 265.03,82.93 265.87,82.09 266.48,82.09 266.51,82.13 267.01,82.13 269.33,79.82 ; 236.28,85.64 231.59,85.64 230.91,86.32 v1(229.11,86.32) ; v1(232.21,61.38) 231.58,62.02 231.58,64.56 230.83,65.31 230.83,67.45 226.87,71.4 226.87,76.54 227.12,76.79 227.12,77.82 226.87,78.07 226.87,78.63 226.74,78.77 226.12,78.77 225.17,79.72 225.17,80.13 224.42,80.88 222.64,80.88 v1(222.54,80.99) ; v1(328.12,16.93) 328.28,16.93 328.45,17.11 328.45,20.28 329.47,21.3 333.55,21.3 333.67,21.42 334.57,21.42 v1(335.64,22.49) 336.89,21.25 336.89,19.22 337.37,18.73 342.29,18.73 v1(342.68,19.12) 342.26,19.54 342.26,20.44 341.03,21.67 v1(341.03,23.76) ; v1(243.75,46.83) 243.75,47.33 244.38,47.97 244.38,49.37 246.54,51.53 246.54,57.75 242.63,61.66 v1(237.65,61.66) ; v1(355.51,78.58) 354.55,77.62 354.55,72.16 355.51,71.21 v1(355.61,71.21) 355.61,66.87 v1(354.49,65.75) 353.47,64.73 353.47,63.12 355.04,61.56 356.78,61.56 357.45,60.89 357.45,56.92 356.36,55.83 356.36,49.44 359.61,46.19 359.61,36.73 357.95,35.07 350.11,35.07 v1(349.92,35.27)
  IN2 w1.016: 330.23,82.14 332.11,84.02 333.53,84.02 335.22,85.71 335.22,91.12 336.83,92.73 336.83,95.28 337.83,96.28 337.83,101.89 338.44,102.5 338.44,120.06 339.12,120.74 352.08,120.74
  IN3 w0.508: v1(123.48,139.66) 123.48,133.24 117.46,127.22 117.46,112.16 119.48,110.14 119.48,107.72 v1(120.81,106.39) 123.93,106.39 126.51,108.96 v1(129.93,108.96) ; v1(232.21,61.38) 233.02,62.19 237.12,62.19 v1(237.65,61.66) ; v1(109.96,10.58) 106.62,10.58 v1(105.56,9.51) ; v1(158.22,45.58) 158.22,44.24 156.62,42.64 156.62,38.7 157.64,37.68 157.64,33.49 155.48,31.33 155.48,29.05 155.96,28.56 v1(158.04,28.56) ; v1(257.72,38.66) 257.72,38.95 257.07,39.6 254.17,39.6 v1(253.52,38.95) 252.36,38.95 251.54,39.77 249.87,39.77 v1(249.05,38.95) 247.94,38.95 246.03,40.86 246.03,43.1 243.49,45.64 243.49,46.57 v1(243.75,46.83) ; v1(182.79,41.59) 183.45,42.25 183.45,46.74 183.95,47.25 183.95,48.05 185.17,49.27 185.2,49.27 185.2,59.34 v1(183.97,60.56)
  IN4 w0.381: v1(204.27,89.98) 205.95,89.98 207.42,88.51 v1(208.31,88.51) 208.89,88.51 210.06,87.34 219.61,87.34 v1(220.08,86.87)
  IN4 w0.508: v1(187.61,88.61) 187.61,95.77 v1(188.1,96.26) ; v1(58.05,52.11) 59.72,50.43 59.72,49.37 60.61,48.48 62.39,48.48 v1(63.91,46.95) v1(66.58,46.95) ; v1(65.82,70.32) 65.82,69.31 65.18,68.67 63.13,68.67 62.64,68.19 58.2,68.19 v1(57.89,67.88) ; v1(103.84,18.12) 103.84,17.11 104.59,16.36 105.68,16.36 109.96,12.08 v1(109.96,10.58) ; v1(265.72,58.38) 265.97,58.13 267.55,58.13 v1(268,57.69) ; v1(59.16,66.64) 58.2,65.67 58.2,64.43 58.83,63.79 58.83,60.42 60.98,58.27 v1(60.98,56.77) 61.54,56.77 63.15,58.38 65.1,58.38 v1(65.98,57.51)
  BOTTOM w0.203: v1(164.88,23.33) 164.88,23.97 165.23,24.32 R1047.1 R1046.1 ; R1021.1 178.82,43.33 179.89,42.25 182.12,42.25 v1(182.79,41.59) 182.79,42.25 183.63,43.1 C1024.2 R1020.1 ; v1(258.88,18.94) 259.09,18.94 260.12,19.97 260.95,19.97 261.81,20.83 R6132.2 R6133.2 ; v3(269.08,79.27) 269.08,79.79 268.81,80.06 268.47,80.06 268.15,79.74 R9171.2 ; U7301.11 29.94,66.23
  BOTTOM w0.254: v1(158.22,45.58) 158.58,45.58 159.21,44.95 159.54,44.95 159.9,44.6 R1019.1 ; 231.7,86.78 231.76,86.72 U2011.5 ; 231.7,86.78 231.7,88.71 232.16,89.17 U2009.5 ; 231.7,86.78 231.7,86.14 231.48,85.92 229.85,85.92 ; R9178.2 268.6,79.07 268.88,79.07 v3(269.08,79.27) ; JDIM1002.255 179.1,39.2 179.61,38.7 180.63,38.7 180.75,38.83 ; R9323.1 264.52,76.95 264.52,77.08 v1(264.83,77.38) ; JDIM1001.255 179.1,58.04 ; 229.37,85.89 229.37,85.06 228.97,84.66 PC25014.1 227.23,84.66 226.82,84.25 226.82,83.06 226.99,82.88 PU25002.5
  BOTTOM w0.279: Q4101.5 353.85,71.06 354.08,70.83 355.23,70.83 v1(355.61,71.21)
  BOTTOM w0.305: C2147.2 221.13,84.55 220.87,84.81 U2005.5 ; 207.69,89.02 207.69,88.89 207.27,88.48 205.94,88.48 205.5,88.91 203.58,88.91 203.37,89.12 201.84,89.12 201.44,89.51 U2004.5 ; CON6351.1 108.48,6.56 108.8,6.24 108.8,5.17 v1(105.92,2.3) ; R5100.2 328.43,24.22 329.09,24.88 329.09,25.9 328.25,26.74 328.25,27.7 328.81,28.26 v1(328.81,30.22) ; v3(276.64,69.61) 277.69,68.56 277.69,64.84 276.76,63.91 276.07,63.91 275.5,63.34 275.49,63.34 274.78,62.63 274.78,60.88 274.63,60.72 274.63,56.97 274.64,56.96 274.64,56.47 274.35,56.17 272.62,56.17 272.23,56.57 271.34,56.57 270.44,57.47 269.52,57.47
  BOTTOM w0.381: v1(263.43,56.17) 263.4,56.17 R9364.2 ; v1(266.25,52.58) 266.25,52.72 R9208.1 266.47,53.76 266.6,53.76 ; R9243.2 245.02,82.72 v1(245.02,83.35) ; v1(262.67,55.39) 262.67,55.46 R9365.2 ; R9229.2 v1(260.46,87.8) ; v1(349.92,59.5) 349.8,59.61 Q9047.5 ; v1(266.77,56.06) 266.14,56.69 R9160.2 ; v1(200.32,54.64) 200.66,54.98 PR9821.1 ; PR25002.2 298.61,29.9 298.52,29.81 R9374.2 298.52,28.79 298.94,28.37 298.94,27.45 299.24,27.14 300.01,27.14 300.18,27.32 v1(300.18,27.73) ; v3(267.91,77.43) 267.91,76.95 267.65,76.69 R9103.2 ; Q6402.2 190.02,89.4 189.38,88.75 R6406.1 v1(187.61,88.61) 188.25,89.24 R6405.1 189.38,90.63 190.02,91.28 Q6402.5 ; R9182.2 v1(260.33,53.1) R9183.2 R9184.2 ; R3052.2 66.12,69.65 65.56,69.65 ; v1(32.54,75.07) 32.54,74.73 R7328.2 ; v1(350.81,63.08) R9242.2 349.93,62.72 349.8,62.59 349.8,62.07 ; 65.56,69.65 65.56,70.07 v1(65.82,70.32) ; 65.56,69.65 R2102.2 ; R9231.2 258.1,87.09 v1(258.22,87.09) ; R9151.1 R9077.2 269.1,59.63 v1(269.52,59.21) 269.52,57.47 268.59,57.47 268.59,57.47 268.22,57.47 v1(268,57.69) ; PR9815.2 v1(198.92,49.74) 199.42,49.74 PR9813.2 ; R9355.2 v1(263.38,52.97) ; v1(259.98,82.26) 260.21,82.5 260.21,84.05 R9227.2 260.33,84.34 260.33,84.93 v1(260.1,85.16) ; R9176.2 264.47,51.76 264.47,51.53 v1(264.19,51.25) ; v1(208.31,88.51) 207.8,89.02 207.69,89.02 ; v1(272.12,51.81) 272.12,52.11 R2135.1 ; 226.25,88.49 R2078.1 ; R9354.2 v1(262.62,52.34)
  BOTTOM w0.406: U6401.1 171.43,87.98 171.23,88.18 170.91,88.18
  BOTTOM w0.508: 180.75,38.83 180.93,39 v1(182.79,39) 183.09,39 183.55,39.46 183.55,41.21 183.17,41.59 v1(182.79,41.59) ; R6303.1 24.8,94.07 v1(24.42,93.69) ; R6305.1 334.7,84.06 331.62,80.99 v1(330.36,80.99) 329.98,81.37 325.03,81.37 323.37,79.72 323.37,78.97 323.64,78.7 R6304.1 ; C2147.2 221.13,83.89 221.89,83.13 221.89,82.23 222.54,81.59 v1(222.54,80.99) 224.7,80.99 225.2,81.5 225.2,82.13 225.86,82.79 225.86,86.81 226.25,87.19 v1(226.25,87.69) 226.25,88.49 ; v1(268,57.69) 267.58,58.11 R9149.1 ; R4104.2 355.25,78.83 v1(355.51,78.58) ; v1(328.61,46.17) 328.81,46.17 329.34,46.7 329.34,47.97 330.44,49.06 330.44,49.76 R500.1 ; v1(256.9,34.53) 256.93,37.87 v1(257.72,38.66) ; 170.47,91.91 169.07,93.31 167.1,93.31 163.42,89.63 142.25,89.63 140.64,88.01 130.93,88.01 128.94,90.01 128.94,98.95 123.86,104.03 122.16,104.03 120.81,105.37 v1(120.81,106.39) ; 170.47,91.91 169.7,91.14 R6401.1 169.7,89.25 170.47,88.47 C6401.1 170.91,88.18 ; 170.47,91.91 174.14,91.91 178.4,96.17 178.4,97.54 179.27,98.41 182.62,98.41 182.86,98.17 183.91,98.17 185.12,96.96 185.31,96.96 186.35,95.92 187.75,95.92 v1(188.1,96.26) ; v1(158.04,28.56) 158.19,28.42 158.19,27.31 157.76,26.88 R1027.1 157.51,25.87 158.4,24.98 v1(158.4,22.98) ; EC9034.1 66.54,47 v1(66.58,46.95) ; EC9032.1 57.92,67.91 v1(57.89,67.88) ; PR25020.2 300.13,34.63 300.9,33.87 300.9,31.85 PR25000.2 301.65,31.6 301.91,31.33 301.91,29.66 300.18,27.93 v1(300.18,27.73) ; PR12011.1 270.16,11.8 272.37,14.01 v1(272.37,14.82) ; R4201.1 R4215.1 335.93,22.2 v1(335.64,22.49) ; 305.21,36.41 303.05,38.57 R6511.1 ; R9361.2 v1(265.72,58.38) ; R1006.1 R1005.1 168.47,21.71 165.61,21.71 164.88,22.44 v1(164.88,23.33) ; R18067.2 364.4,64.35 363.63,65.11 355.12,65.11 v1(354.49,65.75) 353.47,65.75 v1(350.81,63.08) ; R7307.2 29.8,74.19 28.95,74.19 v1(28.78,74.03) ; R9375.2 272.52,45.51 272.52,44.98 v1(272.61,44.9) ; R17987.1 v1(275.62,15.71) ; R1004.1 139.48,25.74 139.86,25.36 v1(140.11,25.36) ; 179.1,58.04 179.1,59.58 v1(180.22,60.7) ; 305.21,35.65 v1(305.21,28.41) ; v1(251.24,90.01) R9145.2 ; R9181.2 v1(259.59,52.44)
  vias: v1(11.22,57.23) v1(11.87,57.24) v1(25.56,51.27) v1(26.55,49.65) v1(27.21,49.62) v1(27.9,49.62) v1(28.81,73.37) v1(29.88,62.83) v1(30.51,62.83) v1(45.07,58.13) v1(45.7,58.13) v1(58.22,53.23) v1(256.09,66.96) v1(258.6,31.49) v1(259.24,31.49) v1(262.29,42.76) v1(263.81,7.46) v1(287.81,13.81) v1(288.45,13.81) v1(305.85,28.41) v1(313.85,17.24) v1(313.85,16.6) v1(313.85,15.97) v1(314.48,17.24) v1(314.48,16.6) v1(314.48,15.97) v1(317.1,8.35) v1(317.1,7.71) v1(317.1,5.3) v1(317.74,8.35) v1(317.74,7.71) v1(317.74,5.3) v1(318.32,43.75) v1(328.81,30.85) v1(329.44,30.85) v1(353.42,119.8) v1(354.06,119.8)
+3V_8409: length 4
  BOTTOM w0.178: 361.02,61.74 U12006.24 360.5,62.11 360.59,62.19 360.97,62.19
  BOTTOM w0.381: v1(351.44,59.15) 351.56,59.03 R18069.2 ; R18072.2 v1(364.65,58.76) ; R18073.2 v1(364.65,57.75) ; R18079.2 v1(364.65,56.73)
  vias: v1(350.18,56.72) v1(351.45,56.72) v1(364.65,61.94) v1(364.65,61.3)
+3V_ALW: length 602.9
  TOP w0.254: 252.62,50.76 U6002.5 252.04,50.12 252,50.16 C6033.2 250.89,50.16 250.6,49.87 250.6,49.11 251.1,48.62 v1(251.76,48.62) U6002.8
  TOP w0.381: R6169.1 R6170.1 255.44,52.95 252.76,52.95 252.25,52.44 252.25,51.13 252.62,50.76
  TOP w0.508: v1(319.64,14.62) 320.2,14.62 321.44,13.38 R9130.1 ; v1(190.89,28.78) 190.89,27.75 192.08,26.56 196.4,26.56 199.12,23.84 199.12,21.04 R9276.1 199.82,17.81 198.51,16.5 198.51,14.48 200.83,12.16 204.11,12.16 204.87,11.39 208.43,11.39 208.95,11.91 209.59,11.91 210.09,12.41 v1(213.9,12.41) v1(219.11,12.41) ; v1(85.1,60.97) 85.1,61.65 85.25,61.8 PR14017.2 ; PR16000.1 v1(289.08,16.14) ; v1(251.92,28.69) 253.03,29.8 R6053.1
  IN1 w0.508: v1(92.11,61.25) 92.39,60.97 94.32,60.97 95.33,59.96 98.33,59.96 99.04,60.67 99.04,60.68 99.36,61 103.02,61 104.32,59.69 104.32,50.23 106.8,47.75 106.8,38.29 108.31,36.78 108.31,33.73 112.62,29.43 176.19,29.43 176.73,28.89 186.61,28.89 186.72,28.78 v1(190.89,28.78) 190.89,30.19 191.31,30.61 191.31,40.52 v1(191.55,40.76)
  IN2 w0.508: v1(319.64,14.62) 319.21,14.62 312.2,21.63 312.2,25.62 310.8,27.01 309.66,27.01 305.59,31.08 305.59,34.13 304.83,34.89 299.12,34.89 296.96,32.73 v1(296.96,32.22) 296.96,31.97 291.5,26.51 291.5,23.46 290.48,22.44 290.48,21.05 291.37,20.16 291.37,16.35 291.17,16.14 v1(289.08,16.14) ; v1(191.17,152.74) 190.91,152.49 190.91,151.3 190.51,150.9 190.51,133.64 191.3,132.86 191.3,129.21 192.7,127.81 192.7,120.62 191.71,119.63 190.82,119.63 190.1,118.91 190.1,100.56 184.89,95.35 183,95.35 182.73,95.08 182.18,95.08 180.27,93.17 180.27,89.35 181.85,87.77 181.85,70.49 v1(184.06,68.29)
  IN3 w0.508: v1(296.96,32.22) 296.96,32.48 296.4,33.03 295.66,33.03 294.99,33.71 289.34,33.71 287.17,31.54 286.68,31.54 286.54,31.68 282.87,31.68 282.45,31.27 280.82,31.27 279.61,32.48 276.84,32.48 276.18,33.14 271.29,33.14 269.99,34.43 266.2,34.43 265.96,34.67 264.45,34.67 263.88,35.24 v1(262.67,35.24) 261.72,35.24 261.33,34.85 259.23,34.85 258.92,35.16 255.4,35.16 254.97,34.74 251.42,34.74 250.18,33.5 v1(249.13,33.5) ; v1(184.06,68.29) 184.06,63.46 185.96,61.56 185.96,46.8 188.8,43.96 188.8,43.27 191.32,40.76 v1(191.55,40.76) ; v1(220,46.06) 220.89,46.06 221.27,46.45 221.27,49.42 223.5,51.65 228.12,51.65 228.95,50.83 228.95,34.92 227.4,33.38 227.02,33.38 226.81,33.16 224.84,33.16 223.3,31.63 v1(223.3,31.4)
  IN4 w0.508: v1(92.11,61.25) 88.98,58.13 88.98,56.07 88.12,55.21 87.66,55.21 87.18,55.69 87.18,56.49 86.38,57.29 84.87,57.29 84.23,57.93 84.23,60.11 v1(85.1,60.97) ; 226.12,26.91 216.44,17.24 216.44,15.08 v1(219.11,12.41) ; 226.12,26.91 227.9,28.69 v1(251.92,28.69) ; 226.12,26.91 223.3,29.73 v1(223.3,31.4)
  BOTTOM w0.254: v1(262.67,35.24) 263.1,35.68 263.1,37.32 263.68,37.9 263.68,38.69 265.64,40.65 266.27,40.65 268.94,43.32 272.4,43.32 272.7,43.02 272.7,40.86 272.97,40.59 PU25001.5 ; PC13015.2 219.1,46.06 PU13001.6
  BOTTOM w0.508: PR24002.1 191.29,152.87 v1(191.17,152.74) ; PD12000.1 223.68,12.03 222.41,12.03 PD12001.1 221.14,11.39 220.12,12.41 v1(219.11,12.41) ; PC13015.2 219.73,46.33 v1(220,46.06) ; v1(251.92,28.69) 251.92,30.22 249.13,33.01 v1(249.13,33.5) 248.91,33.73 248.91,34.57 247.82,35.65 244.7,35.65 243.92,36.44 243.92,38.04 242.97,38.98 242.97,39.8 245.7,42.52 246.64,42.52 249.18,45.06 249.66,45.06 250.86,46.26 250.86,46.7 251.76,47.6 v1(251.76,48.62) ; v1(296.96,32.22) 297.6,32.87 PR25009.1
+3V_AR: length 12.4
  TOP w0.381: v3(348.08,114.58) 348.01,114.58 347.6,114.99 C8062.2 ; v1(350.45,105.88) 350.72,105.61 R8026.1
  IN2 w0.381: 351.92,114.92 351.92,113.86 350.43,112.36 350.43,108.85 350.43,108.85 350.43,107.73 350.7,107.46 350.7,106.14 v1(350.45,105.88)
  BOTTOM w0.254: U8001.E6 v3(348.08,117.18) ; U8001.L6 v3(348.08,114.58)
  vias: v1(351.9,118.07) v3(350.68,116.55) v3(351.21,116.55)
+3V_CAM:
  vias: v1(47.54,52.76) v1(47.66,53.68) v1(48.17,52.79)
+3V_DEEP_SUS: length 963
  TOP w0.254: R9358.1 282.81,53.28 283.14,53.61 v1(283.22,53.61) ; U9003.5 262.75,76.6 262.44,76.6 262.05,76.21 C9217.2 262.19,76.19 262.92,76.19 264.8,78.07 265.08,78.07 265.72,78.71 v3(265.72,79.42) ; v1(349.82,100.64) 349.51,100.64 348.65,101.5 Q9043.2
  TOP w0.305: R9142.2 263.71,56.81 263.96,56.56 263.96,54.56 R18023.1 ; v1(283.22,53.61) 283.29,53.68 Q9009.2 ; v3(259.26,79.59) 259.01,79.59 258.42,79 R9326.1 ; v1(302.17,58.21) 299.42,58.21 299.09,58.54 R9370.2 ; Q9009.5 v1(286.09,53.68)
  TOP w0.381: R9214.2 271.04,60.68 v1(271.02,60.68) ; v1(350.43,11.9) 351.17,11.16 R17956.2 ; PR24000.2 193.24,157.49 v1(193.91,157.49) ; v1(250.88,78.54) 251.13,78.54 R17898.1 ; v1(183.6,97.55) 183.78,97.37 184.56,97.37 188.94,92.98 v1(190.33,92.98) ; R9203.2 268.49,58.51 v1(270.08,56.91) ; R18023.1 264.07,53.94 v1(264.07,53.68) ; R17977.1 276.94,54.83 278.32,53.45 U12001.5 279.26,53.45 280.09,52.62 280.75,52.62 281.31,52.06 282.44,52.06 284.65,52.06 285.28,52.68 285.92,52.68 286.09,52.85 v1(286.09,53.68) ; R9192.2 267.93,62.93 v1(267.67,63.18) 267.57,63.09 R17958.2 ; 256.33,82.88 v1(256.34,82.88) ; R9339.1 261.72,65.69 262.1,65.69 v1(262.29,65.88) ; R9379.2 259.91,49.93 v1(260.43,50.46)
  TOP w0.508: v1(190.23,157.44) 189.77,156.99 PR17000.2 ; v1(347.58,88.25) 347.58,93.23 348.8,94.45 348.8,97.45 v1(348.22,98.03) ; R9287.1 310.04,59.26 309.63,58.85 v1(309.66,58.85) 309.63,58.83 309.63,57.96 310.33,57.26 310.33,48.32 309.32,47.31 v1(309.32,46.69) ; R9201.2 v1(261.14,53.81) ; v1(190.33,92.98) 190.95,92.98 R9308.2 ; v1(189.87,152.62) 189.77,152.73 PR17002.2 ; v1(173.49,19.42) 173.49,18.66 173.79,18.35 180.83,18.35 183.05,20.58 183.05,28.65 182.51,29.2 v1(182.51,30.16) ; v3(265.72,79.42) 265.72,79.85 R9113.2 266.56,79.72 266.69,79.72 R9110.2 ; R8043.1 354.44,113.35 354.68,113.59 v1(354.68,114.15)
  IN1 w0.381: v1(297.67,44.54) 297.69,44.52 300.62,44.52 300.78,44.68 304.84,44.68 305.72,45.56 306.41,45.56 307.54,46.69 v1(309.32,46.69)
  IN2 w0.381: v3(263.56,85.33) 263.48,85.25 262.95,85.25 261.88,86.32 258.93,86.32 v1(258.91,86.35) ; v3(259.26,79.59) 258.1,79.59 256.21,81.48 ; 256.21,81.48 256.34,81.61 v1(256.34,82.88) ; 256.21,81.48 255.57,81.48 255.07,80.98 255.07,79.39 255.28,79.19 255.28,77.09 254.6,76.41 254.6,76.04 254.31,75.75 254.31,75.61 254.13,75.43 254.13,74.41 254.17,74.38 254.17,74.34 254.48,74.03 254.51,74.03 254.54,74 255.63,74 v1(255.86,73.78)
  IN2 w0.508: v1(183.6,97.55) 183.6,97.6 184.44,98.44 184.44,98.64 185.96,100.17 185.96,121.5 187.4,122.94 187.4,124.36 189.16,126.13 189.16,127.47 188.49,128.15 188.49,131.7 186.85,133.34 186.85,136.87 184.89,138.82 182.35,138.82 181.07,140.11 181.07,149.89 180.68,150.28 180.68,152.29 181.26,152.87 181.77,152.87 182.28,153.38 183.93,153.38 186.97,150.34 v1(187.48,150.34) ; 289.47,44.54 288.07,45.94 288.07,47.26 v1(288.86,48.05) ; 289.47,44.54 286.04,44.54 285.44,45.14 285.44,50.55 284.49,51.5 284.49,52.34 v1(283.22,53.61) 283.22,49.72 280.32,46.83 275.36,46.83 v1(274.81,46.28) ; 289.47,44.54 v1(290.86,44.54) 295.28,44.54 296.02,43.8 297.26,43.8 297.67,44.21 v1(297.67,44.54) ; v1(348.22,98.03) 348.9,98.77 348.9,99.72 v1(349.82,100.64) 349.41,101.04 349.41,101.94 351.28,103.81 351.28,105 352.2,105.93 352.2,109.59 353.04,110.43 353.04,112.28 354.68,113.92 v1(354.68,114.15) ; v1(108.36,87.21) 109.89,88.74 112.25,88.74 113.7,90.18 114.26,90.18 115.26,91.19 115.26,93.12 122.94,100.8 122.97,100.8 126.85,104.69 130.44,104.69 v1(131.86,106.11) ; v1(105.75,17.01) 105.75,18.43 106.2,18.89 172.96,18.89 v1(173.49,19.42) 173.69,19.22 173.69,18.89 174.25,18.33 180.66,18.33 182.03,19.71 191.49,19.71 192.14,20.36 198.62,20.36 198.81,20.16 205.07,20.16 205.54,19.69 214.72,19.69 216.22,21.19 218.62,21.19 223.39,25.95 232.37,25.95 234.49,28.08 236.85,28.08 238.16,29.39 245.02,29.39 248.49,32.86 249.33,32.86 249.76,33.28 v1(249.76,34.12) 250.36,34.12 251.57,35.34 252.68,35.34 253.23,35.88 253.23,36.9 253.63,37.3 254.16,37.3 254.69,37.82 257.73,37.82 258.45,38.54 v1(258.45,39.29) 258.45,40.01 258.92,40.48 258.92,42.31 264.26,47.66 264.88,47.66 265.68,48.46 265.68,49.53 v1(266.22,50.08) ; v1(355.51,83.15) 356.01,83.66 359.19,83.66 360.59,82.26 360.59,69.56 360.97,69.18 360.97,65.75 361.22,65.5 362.2,65.5 362.71,64.99 362.71,42.72 360.59,40.6 360.59,34.76 355.68,29.85 351.82,29.85 351.43,29.47 349.04,29.47 348.47,30.04 347.02,30.04 345.89,31.17 345.59,31.17 344.9,31.17 344.53,30.8 344.53,28.89 343.92,28.28 343.16,28.28 342.19,27.31 342.19,27.05 342.18,27.04 342.18,26.14 340.37,24.32 340.37,23.58 340.14,23.35 340.14,21.81 v1(339.73,21.4) 339.38,21.05 338,21.05 337.55,21.5 337.55,22.47 335.57,24.45 334.63,24.45 334.19,24.01 333.69,24.01 333.69,24.02 332.77,24.02 332.34,23.59 v1(328.58,23.59) 328.58,23.99 328.35,24.22 326.55,24.22 326.04,24.73 326.04,25.49 325.03,26.51 324.01,26.51 321.22,29.3 315.47,29.3 314.1,30.67 314.1,41.15 309.32,45.94 v1(309.32,46.69) ; v1(255.81,85.87) 257.38,85.87 257.98,85.27 258.34,85.27 259.67,83.94 260,83.94 ; v1(266.86,50.08) 266.86,51.99 269.32,54.46 269.32,55.28 270.08,56.04 v1(270.08,56.91) 270.08,58.02 271.1,59.03 271.1,60.61 v1(271.02,60.68)
  IN3 w0.508: v1(267.67,63.18) 269.42,61.43 270.27,61.43 v1(271.02,60.68) ; v1(339.73,21.4) 345.37,21.4 348.52,18.25 348.52,13.17 349.79,11.9 v1(350.43,11.9) ; v1(256.83,15.17) 258.05,16.4 260,16.4 ; 260,16.4 260,17.41 261.07,18.48 261.07,22.16 259.09,24.14 259.09,25.11 258.66,25.54 254.83,25.54 v1(254.59,25.77) ; 260,16.4 260.56,15.84 273.84,15.84 275.5,17.49 275.5,19.65 v1(275.22,19.93) ; v1(108.36,87.21) 108.64,86.93 114.31,86.93 115.98,88.61 v1(119.16,88.61)
  IN4 w0.381: v1(262.29,65.88) 262.29,65.55 262.85,64.99 263.43,64.99 265.23,63.18 v1(267.67,63.18)
  IN4 w0.508: v1(286.09,53.68) 283.29,53.68 v1(283.22,53.61) ; v1(190.33,92.98) 190.33,88.12 189.05,86.83 189.05,79.84 188.1,78.89 187.42,78.89 186.85,78.32 186.85,51.85 188.6,50.1 188.6,46.66 186.3,44.36 186.3,31.24 184.56,29.5 183.17,29.5 v1(182.51,30.16) ; v1(347.58,88.25) 347.4,88.08 347.4,87.06 348.65,85.82 352.2,85.82 354.87,83.15 v1(355.51,83.15)
  BOTTOM w0.203: R9210.2 269.32,78.37 270.01,78.37 270.11,78.48 270.54,78.48 270.85,78.17 270.85,77.87 270.46,77.48 269.9,77.48
  BOTTOM w0.254: U9002.AT44 262.1,65.69 v1(262.29,65.88) ; v1(297.67,44.54) 297.67,44.62 296.97,45.31 PR25021.1 ; U9002.V23 v1(249.32,66.23) ; U9002.AW9 251.12,78.54 v1(250.88,78.54) ; v1(274.81,46.28) 275.75,47.22 275.75,51.35 274.25,52.85 R9380.2 ; U9002.AN21 v1(253.66,72.33) v1(254.14,71.86) 254.14,71.35 U9002.AN24 254.19,71.37 254.73,71.37 v1(254.87,71.22) 254.99,71.11 254.99,70.52 U9002.AN26 U9002.AP26 ; R9106.1 330.23,25.26 328.58,23.61 v1(328.58,23.59)
  BOTTOM w0.305: R9119.2 268.56,75.83 268.79,75.83 v3(269.12,76.16) 269.31,76.16 269.97,76.81 269.97,77.42 269.9,77.48 ; CON401.1 257.9,39.83 v1(258.45,39.29)
  BOTTOM w0.381: R9120.2 262.87,82.93 262.87,82.39 v3(262.67,82.18) ; v1(302.17,58.21) 302.67,58.71 302.67,60.54 303.46,61.33 308.03,61.33 309.63,59.73 309.63,58.88 v1(309.66,58.85) ; v1(309.32,46.69) 309.32,45.71 308.82,45.22 R6203.2 ; R9338.2 265.28,78.98 v3(265.72,79.42) ; R9193.2 R9255.2 259.92,50.46 v1(260.43,50.46) 260.66,50.46 261.14,49.98 261.14,49.32 R9067.1 ; 273.21,48.1 273.97,48.86 273.97,50.76 272.85,51.88 272.85,53.15 R9241.2 ; R9118.2 v3(263.98,80.65) 264.85,81.52 R9116.2 ; R9144.2 268.39,56.27 269.09,56.98 270.02,56.98 v1(270.08,56.91) ; v1(288.86,48.05) 288.33,48.57 R9105.2 ; v3(263.56,85.33) 263.38,85.15 262.85,85.15 R9135.2 ; R9237.1 v1(258.91,86.35) ; v1(271.02,60.68) 270.86,60.85 270.86,60.86 R9214.2 ; PR25003.1 v1(290.86,44.54)
  BOTTOM w0.508: v1(339.73,21.4) 339.33,21 R4227.2 ; v1(131.86,106.11) R9313.1 131.22,107.27 R9312.1 ; v1(249.76,34.12) 250.04,33.84 250.04,33.3 252.79,30.56 252.79,27.92 254.59,26.12 v1(254.59,25.77) ; v1(119.16,88.61) 119.31,88.76 119.49,88.76 119.92,89.19 R17908.2 ; v1(105.75,17.01) 105.75,17.87 106.51,18.63 106.51,24.7 105.61,25.61 105.61,45.88 106.41,46.68 106.41,57.24 106.36,57.3 106.36,86.44 107.13,87.21 v1(108.36,87.21) ; v1(256.34,82.88) v1(256.34,83.85) 256.34,85.33 v1(255.81,85.87) ; R9067.1 261.8,48.46 R9368.2 263.01,47.97 264.34,47.97 v1(264.93,48.55) ; PR17011.1 v1(187.48,150.34) ; v1(355.51,83.15) 353.35,81 R4107.2 ; R17992.1 275.25,19.89 v1(275.22,19.93) ; v1(256.83,15.17) 256.83,13.68 256.31,13.16 PR11012.2
  vias: v1(248.49,87.09) v1(249.26,86.43) v1(250.27,93.49) v1(250.28,92.74) v1(253.78,64.05) v1(254.16,63.54) v1(254.62,64.89) v1(255,64.38) v1(259.62,85.59) v1(261.02,84.29) v1(266.35,42.64) v1(266.86,49.24)
+3V_DP: length 195.2
  TOP w0.508: v1(341.67,48.73) 340.91,47.97 340.24,47.97 339.48,48.73 v1(339.2,48.73) ; v1(350.43,31.08) 351.75,31.08 352.25,31.59 352.25,37.81 350.98,39.08 v1(350.04,39.08) 350.04,41.72 348.98,42.79 348.98,44.08 v1(349.41,44.52) 350.93,46.04 v1(350.93,46.32) 351.39,46.32 354.06,43.65 356.39,43.65 358.17,41.87 359.19,41.87
  IN1 w0.508: v1(346.62,48.12) 345.7,48.12 345.09,47.51 345.09,46.42 343.4,44.73 343.4,32.62 v1(344.08,31.94) ; v1(335.54,47.82) 332.77,50.59 v1(332.77,52.29) ; v1(350.43,31.08) 353.07,31.08 353.63,31.64 354.42,31.64 v1(356.27,33.49) 360.46,37.68 v1(360.46,41.49) ; v1(332.98,37.43) 332.98,38.37 333.66,39.05 v1(333.66,39.28)
  IN2 w0.508: v1(335.85,38.22) 336.01,38.05 336.01,35.23 v1(337.73,33.52) ; v1(335.54,47.82) 336.2,47.16 338.18,47.16 339.2,48.17 v1(339.2,48.73) ; v1(316.39,59.4) 315.88,59.4 315.37,59.91 v1(315.37,64.35) ; v1(344.08,31.94) 344.14,32.01 349.5,32.01 v1(350.43,31.08)
  IN3 w0.508: v1(335.85,38.22) 335.74,38.32 335.69,38.32 334.55,39.46 333.84,39.46 v1(333.66,39.28) ; v1(316.39,59.4) 316.82,59.4 317.25,59.83 317.25,60.64 v1(318.52,61.91) 321.55,58.89 v1(333.23,58.89) 333.24,58.88 333.24,58.81 334.03,58.03 334.03,57.18 333.79,56.94 333.79,53.3 v1(332.77,52.29) ; v1(337.73,33.52) 338.03,33.21 338.03,32.45 338.47,32.01 341.4,32.01 341.83,32.44 343.53,32.44 344.08,31.89 v1(344.08,31.94)
  BOTTOM w0.178: U500.29 319.24,57.06 319.06,57.24 ; U501.29 340.97,46.26
  BOTTOM w0.254: TP22066.1 349.54,31.08 v1(350.43,31.08)
  BOTTOM w0.381: v1(356.27,33.49) 356.27,32.92 R10055.2 ; R515.2 R514.2 315.96,56.76 v1(315.75,56.96) 315.56,57.16 315.56,57.89 314.02,59.42 R513.2 314.02,60.57 314.36,60.91 R518.2 315.33,60.91 315.57,60.66 315.57,59.6 315.78,59.4 v1(316.39,59.4) ; v1(350.04,39.08) 350.54,39.58 R549.2 ; v1(350.93,46.32) 350.93,45.91 350.76,45.74 R534.1 351.47,45.4 351.49,45.38 R10052.2 ; v1(349.41,44.52) 349.38,44.54 R532.1 ; R17950.2 344.69,45.67 345.43,46.4 345.43,47.24 345.66,47.47 R529.1 ; 319.06,57.24 318.48,57.81 318.48,58.05 317.79,58.74 C501.1
  BOTTOM w0.508: R17952.2 R17951.2 318.92,61.52 v1(318.52,61.91) ; R524.2 321.55,69.69 320.2,69.69 319.31,68.8 R506.1 R508.1 R502.1 R503.1 315.89,67.79 315.63,67.53 315.63,65.84 315.41,65.63 315.41,64.39 v1(315.37,64.35) ; v1(332.98,37.43) 332.26,37.43 R537.2 ; 340.97,46.26 340.97,46.89 C533.1 341.65,47.33 342.04,47.72 342.04,48.5 341.81,48.73 v1(341.67,48.73) 341.42,48.99 R546.2 343.57,49.49 344.2,48.86 344.2,48.61 R17949.2 345.35,48.11 R529.1 ; C501.1 317.79,59.01 317.41,59.4 v1(316.39,59.4) ; v1(344.08,31.94) 343.57,32.45 R542.2 ; R520.2 v1(333.23,58.89) ; v1(346.62,48.12) 346.62,47.45 346.97,47.09 347.21,47.09 347.22,47.08 R527.1 ; v1(339.2,48.73) 339.2,48.28 R540.2 ; v1(333.66,39.28) 334.34,39.28 R536.2 ; R541.2 R510.2 336.08,47.75 335.68,47.75 335.62,47.82 v1(335.54,47.82) 335.54,48.15 334.99,48.7 R511.2 334.68,48.43 333.98,47.73 R539.2
  vias: v1(360.46,42.13)
+3V_DREAM: length 12.4
  IN1 w0.508: 17.18,63.34 20.1,63.34 v1(21.11,62.32)
  BOTTOM w0.381: Q3007.2 v1(12.61,64.86) Q3007.5 ; Q3008.2 v1(16.16,64.86) Q3008.5
  BOTTOM w0.508: R3086.2 R3085.2 v1(16.81,62.24) ; R3093.1 21.11,62.99 v1(21.11,62.32) ; R3084.2 R3083.2 v1(13.1,62.31)
  vias: v1(14.54,57.39) v1(15.17,57.39) v1(17,56.63)
+3V_ECACC: length 1
  BOTTOM w0.254: v1(264.32,25.57) 264.4,25.64 U6001.D1
  vias: v1(263.81,25.11)
+3V_FP: length 1.9
  BOTTOM w0.508: v1(290.48,11.27) 290.35,11.39 R7200.2 290.74,11.89 290.85,11.77 ESD7200.5
  vias: v1(288.96,7.58) v1(289.59,7.58) v1(290.86,8.98)
+3V_RTC: length 204.4
  TOP w0.254: v1(278.29,57.67) 277.02,57.67 276.28,58.41 275.84,58.85 275.84,64.04 276.79,64.99 276.79,65.98 275.67,67.1 274.94,67.1 v1(274.61,67.43) ; D9000.3 321.35,10.26 v1(321.06,10.56) ; R9136.1 309.59,16.14 R9131.1 310.7,15.04 v1(310.7,14.49) 310.75,14.44 C9189.1 311.45,19 310.7,19.75 310.7,25.39 v1(310.8,25.49) ; C6004.2 266.54,32.87 v1(266.87,32.54) 267.49,33.17 C9304.1
  IN2 w0.254: v1(278.29,57.67) 278.92,57.04 278.92,50.13 276.38,47.59 274.01,47.59 271.23,44.81 271.23,44.47 272.75,42.95 272.75,39.08 270.17,36.5 270.17,34.83 269.14,33.8 268.12,33.8 v1(266.87,32.54)
  IN2 w0.508: v1(321.06,10.56) 320.17,11.44 315.78,11.44 312.73,14.49 v1(310.7,14.49)
  IN3 w0.254: v1(348.52,31.21) 348.52,31.43 347.76,32.2 346.21,32.2 344.37,30.36 341.43,30.36 340.7,29.62 336.03,29.62 335.33,28.93 332.24,28.93 329.28,25.97 319.64,25.97 318.61,24.94 314.66,24.94 314.1,25.49 v1(310.8,25.49) 310.67,25.49 307.25,28.92 304.58,28.92 303.46,30.04 301.81,30.04 300.55,31.31 295.08,31.31 294.52,30.75 292.28,30.75 291.34,31.69 288.87,31.69 287.63,30.45 286.12,30.45 286.11,30.46 285.34,30.46 284.37,29.49 283.81,29.49 283.55,29.22 278.97,29.22 278.38,29.82 274.21,29.82 272.93,31.1 269.68,31.1 267.8,32.98 267.31,32.98 v1(266.87,32.54)
  IN4 w0.254: v1(353.65,13.56) 353.68,13.56 350.73,16.51 350.73,17.69 350.32,18.1 349.79,18.1 346.73,21.16 346.73,28.65 348.52,30.44 v1(348.52,31.21)
  BOTTOM w0.114: 266.73,31.46 266.95,31.24 266.95,30.51 U6001.L4
  BOTTOM w0.254: U9002.BC49 U9002.BD49 267.15,66.33 269.05,66.33 269.61,66.89 270.42,66.89 271.19,67.66 272.75,67.66 C9233.2 273.13,67.94 273.13,67.95 273.56,68.38 274.48,68.38 ; 266.73,31.46 266.6,31.59 266.6,32.17 266.87,32.43 v1(266.87,32.54) ; 274.48,68.38 274.63,68.52 R9205.1 ; 274.48,68.38 274.76,68.1 274.76,67.58 v1(274.61,67.43) ; v1(353.65,13.56) R4203.2
+3V_RTC_0: length 6.5
  TOP w0.508: CON9000.1 360.13,46.95 360.63,46.45 D9004.2 360.63,44.96 360.2,44.54 359.57,44.54 359.19,44.16 R18105.1
+3V_RTC_0_R: length 62.2
  TOP w0.508: R9137.1 v1(322.99,15.71) 322.99,17.49 324.44,18.94 324.44,20.13 325.41,21.1 325.41,22.16 v1(325.1,22.47) ; v1(361.4,40.32) 361.4,42.08 360.63,42.85 D9004.1 360.05,43.24 359.7,42.89 R18105.2
  IN3 w0.508: v1(325.1,22.47) 325.48,22.09 328.92,22.09 330.52,23.68 334.19,23.68 335.08,24.58 336.18,24.58 336.79,25.19 340.06,25.19 342.51,27.64 346.63,27.64 347.4,28.41 347.4,29.1 347.82,29.52 349.04,29.52 349.43,29.12 351.42,29.12 351.8,29.5 351.8,30.06 355.82,34.09 358,34.09 360.59,36.67 360.59,39.51 v1(361.4,40.32)
+3V_RTC_1: length 1.9
  TOP w0.508: R9137.2 v1(322.99,11.27) 322.88,11.15 D9000.1
+3V_RTC_2: length 6.2
  TOP w0.254: v1(323.84,9.02) D9000.2
  TOP w0.508: D9000.2 322.12,9.85 322.12,10.92 R9130.2 R9133.1 320.43,10.92 C9301.1
+3V_SM: length 19.5
  TOP w0.508: C7312.1 C7304.1 282.2,13.78 v1(282.63,13.35) ; C7312.1 280.17,13.31 v1(280.16,13.3) ; C7312.1 C7313.1
  IN3 w0.508: v1(282.63,13.35) 282.63,14.24 283.27,14.87 283.27,19.55 v1(283.7,19.98)
  BOTTOM w0.381: v1(280.16,13.3) 280.02,13.16 280.02,12.44 280.16,12.29 U7300.14 ; U7300.18 282.11,19.71 281.85,19.98 C7306.1 ; U7300.10 282.76,13.22 v1(282.63,13.35)
  BOTTOM w0.508: C7306.1 R7302.1 283.3,20.38 v1(283.7,19.98)
+3V_THR: length 3.8
  TOP w0.114: R6402.1 C6403.1 122.33,112.2 U6402.5 123.4,111.13 v1(123.4,110.3)
+3V_TS: length 35.9
  TOP w0.508: v1(55.15,44.79) 55.02,44.92 R3016.1 ; R3017.1 49.05,48.4 v1(48.65,48.81)
  IN1 w0.508: v1(55.15,44.79) 53.88,46.06 51.72,46.06 48.98,48.81 v1(48.65,48.81)
  IN3 w0.508: v1(48.65,48.81) 48.65,47.82 48.17,47.33 45.5,47.33 44.74,48.1 41.69,48.1 41.09,47.5 35.43,47.5 31.72,51.2 31.72,53.92 v1(31.27,54.37)
  BOTTOM w0.508: R3029.2 32.72,55.26 31.83,54.37 v1(31.27,54.37)
  vias: v1(27.83,53.85) v1(28.48,54.8) v1(28.48,54.04) v1(28.71,51.81) v1(28.71,51.07)
+3V_VCC: length 241.7
  TOP w0.203: C6031.2 274.04,25.97 v1(273.72,25.64) ; C6030.2 269.15,21.4 v1(269.25,21.3) ; v1(264.19,23.71) 264.09,23.81 C6015.2
  TOP w0.508: PQ26006.2 344.81,149.45 PR10023.1 345.72,149.7 v1(346.23,149.7)
  IN1 w0.508: v1(320.76,28.08) 322.17,28.08 v1(324.92,30.82)
  IN2 w0.508: v1(346.23,149.7) 345.85,149.7 345.47,149.32 345.47,144.36 337.8,136.69 337.8,133.72 333.87,129.79 333.87,119.61 334.98,118.5 334.98,93.12 333.53,91.68 333.53,86.24 333.03,85.74 331.61,85.74 329.21,83.33 328.04,83.33 323.02,78.31 323.02,76.7 315.94,69.62 315.94,65.35 316.37,64.92 316.37,62.34 319.44,59.27 319.44,58 321.22,56.22 322.23,56.22 322.61,55.84 322.61,55.34 323.21,54.74 323.89,54.74 324.83,53.8 324.83,52.22 326.22,50.84 326.22,49.44 327.03,48.63 327.03,47.67 326.4,47.03 324.64,47.03 323.09,45.47 323.09,32.65 v1(324.92,30.82) ; v1(269.25,21.3) 269.28,21.34 269.91,21.34 270.92,22.35 270.92,23.33 271.43,23.84 272.19,23.84 272.89,24.54 272.89,25.3 273.23,25.64 v1(273.72,25.64) 274,25.64 274.35,26 274.35,26.59 273.21,27.73 273.21,28.41 273.81,29.01 273.81,33.91 273.23,34.48 273.23,35.63 272.96,35.9 272.45,35.9 272.07,36.29 v1(272.07,36.54)
  IN3 w0.508: v1(320.76,28.08) 320.33,28.08 320.2,28.21 309.97,28.21 307.6,30.57 305.18,30.57 304.35,31.4 302.37,31.4 301.06,32.71 299.07,32.71 296.77,35.02 287,35.02 286.2,35.82 283.47,35.82 283.06,36.23 277.17,36.23 275.98,37.42 272.69,37.42 272.07,36.79 v1(272.07,36.54)
  IN4 w0.508: v1(269.25,21.3) 269.02,21.53 269.02,23.16 268.47,23.71 265.84,23.71 265.46,24.09 264.57,24.09 v1(264.19,23.71)
  BOTTOM w0.254: U6001.D12 v1(273.72,25.64) ; v1(269.25,21.3) 269.11,21.43 269.11,23.23 269.22,23.33 U6001.A7 ; v1(264.19,23.71) 264.82,24.34 U6001.B1
  BOTTOM w0.305: C6016.2 270.26,32.32 269.87,31.93 U6001.M8
  vias: v1(271.81,35.9)

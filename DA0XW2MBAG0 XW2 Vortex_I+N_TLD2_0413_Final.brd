# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N36798889: length 2.2
  TOP w0.114: v1(233.08,152.36) 233.08,151.75 v1(233.1,151.73)
  TOP w0.254: PQ8004.3 233.21,151.62 v1(233.1,151.73)
  BOTTOM w0.254: PR8013.2 233.59,151.25 v1(233.1,151.73)
N36798895: length 4.2
  TOP w0.114: PQ8004.2 232.68,150.32 v1(232.44,150.08) 232.44,148.94 PC8017.1 PR8021.1 231.3,149.19 231.17,149.32 PR8018.2
N36799059: length 4.7
  BOTTOM w0.508: PQ8002.2 231.8,146.86 PR8012.1 PR8010.2 231.66,149.03 v1(230.92,149.77) 230.92,150.37 PQ8003.3
N36799063: length 2.3
  BOTTOM w0.508: PQ8002.3 232.57,143.42 232.69,143.31 PR8022.2
N36799154: length 2.1
  BOTTOM w0.254: PU8001.6 236.62,150.17 PR8001.1
N36871877: length 7.4
  TOP w0.203: PR9816.1 201.45,56.1 v1(200.95,56.1) 200.69,56.1 199.92,55.33 PR9819.2 199.3,54.58 v1(199.3,54.07)
  BOTTOM w0.203: PU9802.16 197.48,54.35 197.86,54.73 198.91,54.73 199.3,54.35 v1(199.3,54.07) PC9804.1
N36874414: length 4.8
  BOTTOM w0.203: PC9809.1 197.14,55.01 196.83,54.7 PU9802.15 ; PC9809.1 196.38,55.33 v1(196.25,55.46) ; PC9809.1 PC9808.2 198.66,55.33 198.92,55.59 PR9821.2
N36891973: length 3.4
  TOP w0.114: PR23014.2 113.83,93.7 v1(113.19,93.05) 112.54,92.4 PQ23007.3
N36893850: length 4.6
  TOP w0.114: PR22010.1 267.49,38.07 v1(267.75,37.81)
  TOP w0.178: PR22010.1 PC22029.1 265.46,38.45 265.46,38.9 264.72,39.65 PU22002.5
N36893866: length 2.5
  TOP w0.178: PC22027.1 263.86,43.9 263.68,43.72 v1(263.68,43.65) 263.68,43.14 263.92,42.91 PU22002.12
N36893870: length 2.5
  TOP w0.178: PC22028.1 264.83,43.78 v1(264.95,43.65) 264.95,43.12 264.72,42.89 PU22002.10
N36893880: length 4.1
  TOP w0.114: PR22008.1 v1(261.79,38.07)
  TOP w0.178: PU22002.3 263.92,39.59 263.68,39.35 PC22022.1 PR22008.1
N37010922: length 2
  TOP w0.203: TP22069.1 350,112.65 v3(349.38,112.65) 349.01,113.02 R18064.2
  BOTTOM w0.254: v3(349.38,112.65) 349.08,112.95 U8001.R4
N37114488: length 2.9
  BOTTOM w0.114: U12006.36 361.64,56.57 363.24,54.96 R18078.1
N37514618: length 2.9
  TOP w0.114: U9500.11 187.81,20.28 187.71,20.18 187.71,17.92 TP9502.1
N37516232: length 2.9
  BOTTOM w0.114: U501.31 341.77,45.54 342.32,46.09 342.32,46.97 R548.2
N37516240: length 1.7
  BOTTOM w0.114: TP505.1 341.37,45.9 U501.30
N37705554: length 6
  BOTTOM w0.114: v1(316.14,60.67) 316.26,60.54 317.29,60.54 R522.1 317.92,59.91 318.55,59.91 319.23,59.23 319.23,58.34 319.71,57.86 U500.31
N37705574: length 2.5
  BOTTOM w0.114: U500.30 319.6,57.46 318.68,58.38 TP503.1
N37711258: length 6.6
  TOP w0.114: R7205.1 354.14,144.21 353.88,144.46 351.47,144.46 351.34,144.34 351.34,142.94 352.03,142.25 v1(352.38,142.25) 352.38,141.93 352.46,141.85 U7112.B4
N37711431: length 2.3
  TOP w0.114: U7112.A4 351.1,142.29 v1(351.1,142.43) 350.91,142.62 R7187.2
N37711689: length 3.2
  TOP w0.114: U7112.D4 353.51,141.43 354.3,142.22 354.83,142.22 v1(354.98,142.36) C7152.2
N37712209: length 3.6
  TOP w0.114: U7112.A3 351.27,140.93 v1(351.06,141.14) 350.55,141.65 350.55,142.65 R7188.1
N37713533: length 5.3
  TOP w0.114: U7113.B4 v1(346.13,129.76) 346,129.63 343.03,129.63 R7206.1
N37713562: length 2.9
  TOP w0.114: R7189.1 348.51,130.79 v1(348.32,130.6) 348.29,130.57 347.4,130.57 U7113.A4
N37713602: length 2.1
  TOP w0.114: U7113.A3 v1(347.61,131.84) 347.93,131.84 R7190.1
N37973156: length 2.9
  TOP w0.114: v1(358.53,122.24) 358.22,122.56 358.22,123.35 358.4,123.53 Q7130.5
  BOTTOM w0.114: v1(358.53,122.24) 358.68,122.09 D7170.1
N37973157: length 4.2
  TOP w0.114: v1(360.15,122.44) 359.52,122.44 359.44,122.52 359.44,123.28 359.7,123.53 Q7130.2
  BOTTOM w0.114: D7171.1 359.74,122.35 359.82,122.44 v1(360.15,122.44) 360.15,121.83 v1(359.7,121.38)
N38208157: length 2.7
  BOTTOM w0.114: R4112.2 349.02,83.67 Q4103.2 348.04,83.66 v1(347.89,83.5)
N38208218: length 5.9
  BOTTOM w0.114: R4114.1 R4110.2 350.92,76.93 350.81,77.05 348.65,77.05 v1(348.01,77.69) 348.14,77.81 Q4102.3
N38214825: length 2.5
  TOP w0.114: v1(341.39,74) 341.39,74.74 v1(341.36,74.77) 342.08,74.77 R4119.2
  BOTTOM w0.114: U4100.A15 v1(341.39,74)
N40748080: length 5.6
  BOTTOM w0.114: PQ10004.3 337.76,137.11 338.13,137.48 338.91,137.48 339.06,137.63 PQ10004.6 339.06,138.56 339.2,138.7 339.63,138.7 339.88,138.44 339.88,137.58 340.3,137.17 PR10004.2
N42587939: length 2.6
  TOP w0.178: PC9511.1 196.42,88.36 v1(196.42,87.64) 196.42,87.29 196.01,86.88 PU9501.10
N42587941: length 2.1
  TOP w0.178: PU9501.12 195.21,86.95 195.26,87 v1(195.26,87.11) 195.16,87.21 194.77,87.58 194.75,87.58 PC9510.1
N42628948: length 5.6
  TOP w0.114: U3007.48 61.57,61.73 61.02,61.18 59.97,61.18 R3040.2 58.97,61.18 57.69,61.18 v1(57.56,61.05)
N42837801: length 3.6
  BOTTOM w0.114: R2078.2 223.95,90.78 v1(223.92,90.81) ; R2078.2 223.95,89.63 223.69,89.37 Q2010.2 ; R2078.2 223.34,90.01 222.92,89.58 Q2013.3
N43915287: length 10.7
  BOTTOM w0.114: v1(71.92,64.74) R401.2 72.55,65.62 74.02,67.1 79.48,67.1 79.73,67.34 CON400.48
N46097153: length 1.8
  TOP w0.127: R2504.2 214.82,142.52 v1(215.34,143.04)
  BOTTOM w0.305: v1(215.34,143.04) 215.44,142.95 VRAM2501.J1
N46097158: length 1.3
  TOP w0.114: v1(225.97,142.52) 225.98,142.54 R2500.2
  BOTTOM w0.127: v1(225.97,142.52) 225.97,142.56 VRAM2501.J13
N46097163: length 4.3
  TOP w0.127: v1(196.38,143.35) 196.38,142.55 196.11,142.28 195.07,142.28 194.81,142.02 R2506.2
  BOTTOM w0.406: v1(196.38,143.35) 196.78,142.95 VRAM2500.J13
N46097165: length 1.5
  TOP w0.127: R2503.2 205.85,142.68 v1(205.98,142.55)
  BOTTOM w0.127: VRAM2500.J1 v1(205.98,142.55)
N46098616: length 1.6
  TOP w0.114: v1(245.32,99.34) 244.85,99.81 R2522.2
  BOTTOM w0.127: v1(245.32,99.34) 244.92,99.74 VRAM2503.J13
N46098640: length 1.6
  TOP w0.114: R2518.2 245.26,110.37 v1(244.79,109.9)
  BOTTOM w0.127: VRAM2503.J1 244.93,109.76 v1(244.79,109.9)
N46098642: length 1.9
  TOP w0.114: R2517.2 245.01,116.34 v1(244.98,116.36)
  BOTTOM w0.127: v1(244.98,116.36) 244.93,116.42 VRAM2502.J1
N46098644: length 2.4
  TOP w0.508: v1(244.12,128.35) 243.91,128.55 R2513.2
  BOTTOM w0.127: v1(244.12,128.35) 244.51,127.95 244.51,127.43 VRAM2502.J13
N46263503: length 6.7
  IN1 w0.203: v1(210.22,47.05) 210.22,51.37 v1(210.47,51.62)
  BOTTOM w0.254: PU9001.6 210.2,52.15 210.47,51.87 v1(210.47,51.62) ; v1(210.22,47.05) 210.08,47.18 PR9017.2
N52951734: length 4
  TOP w0.178: PU14000.14 99.88,63.84 100.44,64.4 v1(100.44,64.43) 100.8,64.79 100.8,66.32 PR14008.2
N53913035: length 9.3
  TOP w0.508: PD11003.1 PD11001.1 249.12,14.15 v1(248.57,14.7) 248.44,14.82 246.92,14.82 246.15,15.6 246.15,16.36 246.58,16.79 246.82,16.79 PR11007.1
N53993617: length 3.6
  TOP w0.114: R6828.1 R6827.1 189.9,48.48 189.39,48.99 v1(188.88,48.99) 188.64,49.22 Q6800.3
N54010638: length 2.9
  TOP w0.114: v1(94.77,70.06) PR14012.1
  TOP w0.254: PR14012.1 93.75,70.06 92.49,68.8 PR14015.2
N54011668: length 3
  TOP w0.254: PQ14000.3 91.22,70.19 91.35,70.32 v1(91.85,70.32) 92.23,70.32 92.5,70.06 PR14013.1
N54024226: length 2.2
  BOTTOM w0.114: PD25000.1 294.15,29.19 294.29,29.05 PR25013.1 293.66,28.55 v1(293.4,28.28)
N54024229: length 10.7
  BOTTOM w0.114: PU25000.6 295.43,39.84 296.7,38.57 PU25000.2 296.7,36.16 296.82,36.04 PC25000.1 PR25010.2 PR25009.2 296.82,32.98 v1(296.63,32.78)
N54024270: length 8
  IN3 w0.089: v1(296.2,35.68) 296.22,35.65 296.68,35.65 298.71,33.62 v1(300.26,33.62)
  BOTTOM w0.114: PU25000.3 295.43,35.79 PR25014.2 296.17,35.65 v1(296.2,35.68) ; PR25018.1 v1(300.26,33.62)
N54024274: length 6.8
  BOTTOM w0.114: PU25000.5 294.16,43.78 294.29,43.91 295.05,43.91 295.18,44.03 295.56,44.03 295.69,44.16 295.69,44.75 295.18,45.26 PR25015.1 295.23,45.36 295.23,46.83 v1(295.48,47.08) 295.54,47.14 PR25019.1
N54025517: length 6.3
  TOP w0.114: PR24000.1 192.7,156.17 191.92,156.17 PR24001.1 191.41,157.05 191.55,157.19 PC24000.1 191.12,157.69 v1(190.87,157.44)
  BOTTOM w0.114: v1(190.87,157.44) 190.87,156.51 v1(190.79,156.43) 190.53,156.17 PU24000.5
N54025545: length 2.5
  BOTTOM w0.114: PU24000.1 186.81,155.52 v1(186.47,155.18) 186.47,154.75 186.81,154.4 PR24003.2
N54025557: length 3.7
  BOTTOM w0.114: PU24000.6 190.25,155.52 190.36,155.41 190.36,154.94 v1(190.05,154.62) 190.05,154.01 190.51,153.56 PR24004.2
N54989092: length 1.5
  TOP w0.114: R6828.2 191.42,47.2 191.67,46.95 Q6806.2
N55136487: length 3
  BOTTOM w0.254: PR17012.2 PR17011.2 v1(187.31,149.56) 186.98,149.56 186.71,149.84 PU17000.6
N55136655: length 30.6
  IN4 w0.254: v1(192.06,129.33) 191.73,129.33 187.51,133.54 187.51,136.54 184.26,139.79 182.66,139.79 182.15,140.3 182.15,151.6 v1(182.53,151.98)
  BOTTOM w0.254: PR17017.1 182.14,152.37 v1(182.53,151.98) ; PR17014.1 190.54,129.88 191.09,129.33 v1(192.06,129.33)
N55154530: length 4.6
  BOTTOM w0.114: v1(268.26,41.87) 268,41.62 PR25024.1 PR25022.1 PC25005.1 270.17,40.99 270.42,41.24 PU25001.2
N55387237: length 3
  TOP w0.114: C9249.2 R9276.2 R9277.1 201.75,19.69 v1(201.58,19.52)
N56147095: length 2.6
  TOP w0.254: R3637.1 348.49,25.65 349.08,25.06 v1(349.33,25.06) 349.33,24.53 349.53,24.33 U3601.11
N56147100: length 2.1
  TOP w0.254: C3632.1 351.61,20.03 351.45,20.19 v1(351.45,20.21) U3601.17
N56147116:
  vias: v1(349.41,20.66)
N56147163: length 2.1
  TOP w0.254: R3636.1 348.76,22.15 v1(348.95,22.34) 349.44,22.83 U3601.14
N56147202: length 3.1
  TOP w0.114: C3632.2 352.39,18.57 v1(352.46,18.51)
  TOP w0.254: C3632.2 352.39,19.77 351.95,20.21 U3601.18
N56148149: length 3.2
  TOP w0.254: C3638.1 355.75,24.71 v1(355.45,25.01) 354.95,25.01 354.27,24.33 U3601.5
N56148151: length 3.3
  TOP w0.254: C3634.1 355.5,20.16 v1(354.93,20.72) 354.44,21.21 354.44,22.21 354.32,22.33 U3601.1
N56962017: length 3.8
  TOP w0.254: PR16009.1 297.21,12.53 297.21,13.04 v1(296.83,13.43) 296.55,13.71 296.55,14.72 296.4,14.87 PU16000.3
N56962020: length 5.7
  TOP w0.114: PR16010.1 297.79,12.85 298.1,12.54 298.99,12.54 299.17,12.71 v1(299.75,12.71)
  TOP w0.254: PU16000.4 296.66,15.37 296.93,15.1 296.93,14.11 297.79,13.26 PR16010.1
N56962461: length 3.2
  TOP w0.254: PU16000.7 295.19,16.84 295.38,17.03 297.03,17.03 v1(297.16,16.91) PR16007.2
N57264302: length 3.6
  TOP w0.114: v1(95.89,65.75) 95.51,66.13 PR14000.1
  TOP w0.254: PU14000.3 96.06,64.84 95.79,65.11
  TOP w0.508: PR14000.1 95.03,66.12 PC14000.1 95.04,65.11 95.79,65.11
N57531109: length 2.6
  BOTTOM w0.254: PC17000.1 181.92,149.84 PU17000.10
  BOTTOM w0.508: PC17000.1 PR17006.2
N62824235: length 5.2
  BOTTOM w0.114: Q6301.2 v1(324.53,78.07) 324.53,78.18 324.12,78.59 Q6300.3 325.14,80.48 326.03,80.48 R6302.2
N67022652: length 2.7
  TOP w0.114: v1(262.92,23.33) 262.58,22.99 R6034.2
  TOP w0.508: L6000.1 261.2,23.09 261.31,22.99 R6034.2
N215281515: length 1.8
  BOTTOM w0.114: U4100.11 338.39,75.63 338.03,75.99 TP4108.1
N215281516: length 1.2
  BOTTOM w0.114: U4100.12 338.89,75.55 339.2,75.86 TP4109.1
N215281517: length 6.1
  BOTTOM w0.114: TP4110.1 344.58,76.32 340.42,76.32 339.39,75.29 U4100.13
N1682558515: length 3.1
  TOP w0.114: C7153.2 343.82,131.42 v1(343.82,131.03) 344.81,131.03 U7113.D4

## Copper pours and planes (outline as drawn)
1V8_AON on TOP (solid shape): 199.42,92.04 199.42,91.45 199.41,91.42 199.39,91.4 199.18,91.07 199.39,90.73 199.41,90.71 199.42,90.69 199.42,90.59 199.41,90.56 199.39,90.54 199.25,90.42 199.18,90.24 199.16,90.22 198.49,90.22 198.38,90.33 198.38,91.2 198.3,91.28 197.9,91.28 197.75,91.42 197.75,91.68 198.37,92.29 199.17,92.29
1V8_AON on TOP (solid shape): 221.27,105.85 221.27,104.51 221.57,104.21 222.04,104.21 222.26,103.99 222.26,103.54 222.01,103.28 221.97,103.27 221.94,103.28 221.67,103.34 221.43,103.2 221.41,103.19 221.39,103.18 221.17,103.18 221.15,103.19 221.13,103.2 220.93,103.33 220.69,103.3 220.66,103.3 220.63,103.31 220.38,103.56 220.38,103.7 220.39,103.79 220.38,103.87 220.38,105.98 220.5,106.1 221.01,106.1
1V8_AON on BOTTOM (solid shape): 234.35,91.4 234.35,90.68 234.34,90.66 234.26,90.53 234.23,90.4 234.24,90.31 234.26,90.23 234.12,90.08 232.75,90.08 232.06,90.77 231.43,90.77 231.3,90.64 231.3,90.24 231.16,90.1 230.83,90.1 230.66,90.26 230.66,91.15 230.79,91.28 232.82,91.28 233.08,91.53 234.22,91.53
1V8_AON on BOTTOM (solid shape): 221.14,105.09 221.14,104.71 221.9,103.94 221.9,103.69 221.77,103.56 221.55,103.56 221.53,103.57 221.51,103.58 221.28,103.69 221.05,103.58 221.03,103.57 221.01,103.56 220.76,103.56 220.25,104.07 220.25,104.83 220,105.09 219.23,105.09 219.11,105.21 219.11,105.47 219.23,105.6 220.63,105.6
1V8_AON on BOTTOM (solid shape): 200.95,88.83 203.28,88.83 203.47,88.65 205.39,88.65 205.83,88.21 206.14,88.21 206.17,88.19 206.19,88.16 206.19,87.88 205.99,87.69 204.85,87.69 204.82,87.7 204.8,87.74 204.8,87.92 204.51,88.21 204.51,88.34 203.03,88.34 203.03,88.25 203.02,88.21 202.98,88.2 202.72,87.94 202.72,87.43 202.47,87.18 201.2,87.18 200.3,88.09 200.29,88.1 200.23,88.23 200.11,88.29 200.09,88.29 200.06,88.32 199.68,88.32 199.55,88.45 199.55,88.96 199.68,89.09 200.69,89.09
1V8_AON on BOTTOM (solid shape): outline of 213 points within 222.28,81.36 225.31,88.99
1V8_AON on IN2 (solid shape): outline of 122 points within 219.87,87.34 234.22,93.93
1V8_AON on IN3 (solid shape): 228.14,77.91 230.59,77.91 230.98,77.53 230.98,77.23 230.98,77.22 231.38,76.77 231.54,77.35 231.51,77.42 231.54,77.49 231.63,77.64 231.64,77.81 231.66,77.88 231.74,77.92 233.01,77.92 233.09,77.89 233.12,77.81 233.37,77.46 233.76,77.63 233.78,77.66 234.02,77.66 234.07,77.63 234.22,77.48 234.22,76.42 234.07,76.27 233.69,76.27 233.68,76.27 233.33,76.21 233.21,75.89 233.19,75.8 233.11,75.76 228.9,75.76 228.13,76.54 228.13,76.9 228.13,76.91 228.08,77.27 227.73,77.38 227.7,77.38 227.43,77.65 227.43,77.7 227.65,77.92 228.14,77.92
1V8_AON on IN3 (solid shape): outline of 722 points within 217.88,90.8 222.79,106.01
1V8_AON on IN4 (solid shape): outline of 136 points within 215.42,90.9 221.77,93.7
1V8_AON on IN4 (solid shape): outline of 132 points within 195.49,80.41 224.57,102.2
1V8_AON_S on TOP (solid shape): 198,91.01 198,90.22 198.03,90.17 198.03,88.7 198.28,88.45 198.28,86.42 198.15,86.29 197.77,86.29 197.74,86.26 197.7,86.25 197.66,86.24 197.63,86.22 197.6,86.19 197.57,86.16 197.55,86.13 197.54,86.09 197.53,86.05 197.06,85.58 197.03,85.56 196.97,85.58 196.32,85.58 196.28,85.64 196.29,85.68 196.31,85.7 196.71,85.7 196.71,86.5 196.51,86.5 196.51,85.7 196.31,85.7 196.31,86.5 196.27,86.51 196.25,86.52 196.25,86.55 196.25,86.8 196.76,87.31 196.76,87.48 196.77,87.51 196.78,87.56 196.79,87.62 196.79,87.67 196.78,87.73 196.77,87.78 196.76,87.81 196.76,88.76 196.78,88.8 196.81,88.82 196.85,88.86 196.88,88.91 196.91,88.95 196.93,89 196.94,89.06 196.95,89.11 196.94,89.17 196.93,89.22 196.91,89.27 196.88,89.32 196.85,89.36 196.81,89.4 196.78,89.42 196.76,89.46 196.76,89.5 196.78,89.54 196.81,89.59 196.84,89.64 196.85,89.69 196.86,89.74 196.85,89.8 196.84,89.85 196.83,89.9 196.8,89.95 196.77,89.99 196.76,90.01 196.76,90.68 197.19,91.12 197.9,91.12
1V8_MAIN on TOP (solid shape): 191.6,87.21 191.6,86.15 192.06,85.69 192.06,84.48 192.05,84.44 192.05,84.42 192.05,84.14 192.05,84.11 192.06,84.07 192.06,83.7 192.05,83.66 192.05,83.64 192.05,83.36 192.05,83.33 192.06,83.25 191.72,82.91 191.72,80.35 191.71,80.34 191.71,80.29 191.27,79.85 191.27,79.14 191.17,79.03 189.62,79.03 189.41,79.24 189.41,85.51 190.43,86.53 190.43,86.97 190.51,87.06 190.51,87.3 190.56,87.34 191.47,87.34
1V8_MAIN on TOP (solid shape): 208.42,113.49 208.42,111.92 208.06,111.56 208.06,108.85 208.4,108.51 208.4,107.31 208.24,107.15 208.03,107.15 207.92,107.25 207.92,107.94 207.79,107.94 207.65,108.08 207.23,108.08 207.22,108.07 206.94,108.07 206.58,107.72 206.25,107.72 206.09,107.88 206.09,108.33 205.98,108.44 205.96,108.47 205.98,108.51 205.99,108.52 206.08,108.6 206.15,108.7 206.19,108.96 206.07,109.19 206.03,109.23 206.02,109.26 206.03,109.3 206.21,109.47 206.21,109.7 206.01,110.07 205.59,110.09 205.55,110.06 205.44,110.06 205.39,110.15 205.39,110.92 205.44,111 205.54,111 206.1,111.11 206.06,111.68 206.04,111.7 206.03,111.73 206.04,111.77 206.21,111.94 206.21,112.2 206.02,112.55 205.63,112.6 205.59,112.58 205.55,112.56 205.44,112.56 205.39,112.65 205.39,113.09 205.59,113.29 206.96,113.29 207.32,113.65 208.26,113.65
1V8_MAIN on BOTTOM (solid shape): 219.1,104.98 219.85,104.98 220.09,104.75 220.09,104.27 219.97,104.15 219.95,104.15 219.84,104.1 219.75,104.03 219.74,104.01 219.71,104.01 219.5,104.01 219.47,104.01 219.46,104.03 219.18,104.16 218.91,104.03 218.89,104.01 218.87,104.01 218.65,104.01 218.14,104.52 218.1,104.52 218.09,104.52 217.85,104.52 217.71,104.66 217.71,105 217.9,105.19 218.89,105.19
1V8_MAIN on BOTTOM (solid shape): outline of 183 points within 201.71,108.05 207.68,121.25
1V8_MAIN on IN2 (solid shape): outline of 4405 points within 190.35,83.5 207.64,120.07
1V8_MAIN on IN4 (solid shape): outline of 2828 points within 202.72,104.23 219.87,120.23
1V8_MAIN_S on TOP (solid shape): outline of 116 points within 190.61,85.43 194.98,88.91
+0.6V_DDR_VTT on TOP (solid shape): 189.52,58.64 189.52,55.84 188.63,54.95 187.65,54.95 187.64,54.96 187.51,54.99 187.37,54.98 187.35,54.98 187.32,54.99 187.23,55.08 187.23,55.46 187.36,55.59 188.25,55.59 188.88,56.22 188.88,58.64 189.01,58.76 189.39,58.76
+0.6V_DDR_VTT on TOP (solid shape): 179.93,56.86 179.97,56.85 179.98,56.81 179.98,55.79 179.99,55.79 179.99,55.59 180.37,55.21 182.4,55.21 183.55,56.35 184.18,56.35 184.31,56.22 184.31,55.46 184.18,55.34 183.8,55.34 182.91,54.45 180.37,54.45 179.74,55.08 179.74,56.81 179.75,56.85 179.79,56.86
+0.6V_DDR_VTT on TOP (solid shape): 92.87,66.51 92.87,64.23 93.12,63.97 96.14,63.97 96.14,63.97 96.81,63.97 96.83,63.95 96.83,63.74 96.81,63.72 96.04,63.72 95.91,63.58 95.69,63.58 95.57,63.46 94.65,63.46 94.01,62.83 91.73,62.83 91.09,63.46 90.08,63.46 89.95,63.59 89.95,63.97 90.08,64.1 90.58,64.1 91.35,64.86 91.35,66.13 91.6,66.38 92.11,66.38 92.14,66.42 92.16,66.42 92.29,66.49 92.34,66.62 92.36,66.64 92.74,66.64
+0.6V_DDR_VTT on BOTTOM (solid shape): 179.98,49.12 179.98,47.59 179.99,47.59 180.13,47.45 180.13,47.13 180.26,46.99 180.27,46.96 180.29,46.82 180.37,46.7 180.37,46.47 180.52,46.32 182.28,46.32 182.43,46.17 182.43,45.71 182.33,45.61 181.69,45.61 181.34,45.25 181.34,43.78 180.55,43.78 180.12,44.21 180.12,44.85 180.04,44.92 180.03,44.92 179.72,45.23 179.72,45.7 179.71,45.71 179.71,47.21 179.69,47.33 179.62,47.44 179.61,47.46 179.61,47.54 179.62,47.58 179.66,47.59 179.73,47.59 179.73,49.23 179.74,49.24 179.86,49.24
+0.6V_DDR_VTT on BOTTOM (solid shape): 179.98,32.99 179.98,31.25 179.99,31.25 179.99,30.58 178.19,28.78 176.17,28.78 176.03,28.75 175.91,28.67 175.52,28.28 174.4,28.28 173.13,27.01 164.75,27.01 164.5,27.27 164.5,28.67 164.62,28.79 165.82,28.79 165.9,28.75 165.92,28.66 166.28,28.2 166.63,28.66 166.65,28.75 166.73,28.79 170.47,28.79 171.86,30.19 178.21,30.19 178.43,30.41 178.47,30.43 178.5,30.41 178.93,30.41 179.06,30.82 179.07,30.91 179.15,30.95 179.36,30.95 179.56,31.15 179.58,31.15 179.58,31.18 179.61,31.21 179.62,31.23 179.64,31.25 179.73,31.25 179.73,33.01 179.72,33.01 179.71,33.04 179.71,33.07 179.72,33.09 179.74,33.11 179.86,33.11
+0.6V_DDR_VTT on IN1 (solid shape): 93.93,66.85 93.93,66.83 94.26,66.55 94.58,66.83 94.6,66.86 94.63,66.87 95.15,66.87 95.2,66.84 95.2,66.83 95.4,66.66 95.66,66.66 95.74,66.65 95.79,66.58 96.17,66.26 96.55,66.58 96.6,66.65 96.68,66.66 96.72,66.65 96.74,66.63 96.75,66.6 96.74,66.57 96.72,66.55 96.96,65.85 97.1,66.58 97.04,66.65 97.07,66.74 97.11,66.79 97.14,66.84 97.16,66.86 97.19,66.87 101.77,66.87 101.8,66.84 102.74,66.84 104.35,65.24 104.35,63.64 104.06,63.35 103.37,63.35 103.28,63.36 103.19,63.35 101.91,63.35 101.4,63.86 100.88,64.39 96.11,64.39 96.08,64.4 96.06,64.43 95.74,64.67 95.42,64.43 95.4,64.4 95.37,64.39 94.72,64.39 93.83,65.28 92.47,65.28 92.26,65.49 92.26,66.52 92.45,66.71 92.91,66.71 93.07,66.87 93.9,66.87
+0.6V_DDR_VTT on IN2 (solid shape): 106.81,62.05 106.81,49.73 107.15,49.39 107.16,49.37 107.16,49.35 107.29,49.22 107.98,48.53 107.98,39.28 109.25,38.01 109.25,34.98 109.24,34.96 109.22,34.94 109.04,34.66 109.17,34.36 109.2,34.34 109.23,34.33 109.31,34.3 109.4,34.29 109.63,34.4 109.72,34.62 109.79,34.71 109.9,34.69 109.95,34.63 109.95,34.59 113.02,31.52 113.02,31.13 112.69,30.8 110.99,30.8 107.62,34.17 107.62,37.86 106.74,38.75 106.74,47.57 105.53,48.78 105.53,61.28 103.45,63.35 103.4,63.35 103.39,63.36 103.28,63.38 103.17,63.36 103.16,63.35 102.93,63.35 102.78,63.51 102.78,63.99 103.16,64.38 104.48,64.38
+0.6V_DDR_VTT on IN4 (solid shape): 165.77,29.66 165.77,27.93 165.59,27.75 164.02,27.75 163.12,28.65 163.12,30.13 163.24,30.24 165.18,30.24
+0.6V_DDR_VTT on IN4 (solid shape): 114.26,30.85 114.26,30.64 114.28,30.61 114.29,30.6 114.37,30.45 114.52,30.36 114.53,30.36 114.57,30.33 115.79,30.33 115.87,30.28 115.96,30.27 115.98,30.27 116.31,29.94 116.31,29.25 116.09,29.03 114.3,29.03 111.94,31.38 111.94,32.07 112.17,32.3 112.81,32.3
+1.2V on TOP (solid shape): outline of 255 points within 350.55,53.94 363.63,66.64
+1.2V on BOTTOM (solid shape): 320.81,55.08 320.81,54.85 319.79,53.84 318.73,53.84 318.62,53.94 318.62,54.24 318.7,54.32 318.93,54.32 319.77,55.16 320.73,55.16
+1.2V on BOTTOM (solid shape): 338.04,45.29 339.01,45.29 339.07,45.23 339.07,44.59 339,44.52 338.11,44.52 336.86,45.76 336.86,45.96 337.37,45.96
+1.2V on BOTTOM (solid shape): 344.61,46.8 344.61,46.6 344.46,46.45 343.72,46.45 342.86,45.58 342.2,45.58 342.58,45.96 342.58,46.55 343.57,47.54 343.87,47.54
+1.2V on BOTTOM (solid shape): 331.48,61 331.48,59.58 330.99,59.1 330.08,59.1 329.9,58.92 329.8,58.92 329.72,58.99 329.72,59.91 329.88,60.06 330.31,60.06 330.41,60.16 330.41,60.59 330.97,61.15 331.32,61.15
+1.2V on BOTTOM (solid shape): 329.09,54.5 329.09,53.68 329.55,53.23 329.9,53.23 330.03,53.1 330.03,51.96 329.85,51.78 329.14,51.78 329.04,51.88 329.04,52.85 328.91,52.97 328.91,54.5 328.94,54.52 329.06,54.52
+1.2V on BOTTOM (solid shape): 346.39,33.82 346.39,30.37 346.26,30.24 345.19,30.24 344.94,30.49 344.94,32.07 344.1,32.91 344.1,33.72 343.01,34.82 343.01,34.87 342.96,35.06 342.81,35.24 342.81,35.26 342.81,35.49 342.82,35.53 342.86,35.54 343.67,35.54 343.67,35.74 342.86,35.74 342.82,35.76 342.81,35.79 342.81,35.85 342.88,35.93 344.28,35.93
+1.2V on BOTTOM (solid shape): 203,10.91 204.73,10.91 205.83,9.81 205.83,9.34 206.11,9.07 206.66,9.07 207.63,8.11 207.63,6.64 207.93,6.34 207.93,3.34 207.92,3.31 207.89,3.29 207.62,3.02 207.75,2.65 207.78,2.58 207.75,2.5 207.32,2.07 205.9,2.07 205.54,2.43 205.54,3.08 205.55,3.12 205.86,4.71 205.55,6.3 205.54,6.31 205.54,6.49 205.39,6.65 205.38,6.66 204.66,7.66 203.68,8.42 203.67,8.43 202.93,8.75 202.15,8.93 202.14,8.93 202.01,9.06 202.01,11.14 202.06,11.18 202.52,11.18 202.52,11.19 202.55,11.22 202.7,11.22
+1.2V on IN1 (solid shape): outline of 156 points within 330.03,60.96 343.24,63.49
+1.2V on VCC (solid shape): outline of 10763 points within 196.72,0.51 355.33,29.35
+1.2V on IN2 (solid shape): 346.31,29.96 346.31,28.46 345.88,28.03 344.79,28.03 344.58,28.23 344.58,28.46 344.88,28.75 344.88,30.01 344.98,30.11 346.16,30.11
+1.2V on IN2 (solid shape): outline of 332 points within 342.68,60.54 351.06,66.64
+1.2V on IN2 (solid shape): outline of 1042 points within 324.9,41.84 351.35,63.51
+1.2V on IN3 (solid shape): outline of 425 points within 312.91,60.09 331.02,69.13
+1.2V on IN3 (solid shape): outline of 976 points within 338.49,32.4 362.87,55.46
+1.2V on IN4 (solid shape): outline of 276 points within 338.79,27.98 346.28,33.77
+1.2V_8409 on TOP (solid shape): outline of 188 points within 353.09,54.19 362.24,63.46
+1.2VSUS on TOP (solid shape): outline of 1051 points within 140.88,39.46 156.37,48.99
+1.2VSUS on TOP (solid shape): outline of 16856 points within 98.2,26.51 181.13,109.15
+1.2VSUS on BOTTOM (solid shape): 151.42,103.72 151.42,103.48 151.15,103.22 151.14,103.21 151.01,103.15 150.95,103.02 150.95,103 150.91,102.96 150.87,102.96 150.86,102.96 150.77,102.99 150.66,102.98 150.64,102.99 150.62,103 150.15,103.47 150.15,103.72 150.27,103.85 151.29,103.85
+1.2VSUS on BOTTOM (solid shape): 154.97,104.36 154.97,103.72 154.59,103.34 153.7,103.34 153.45,103.09 153.07,103.09 152.94,103.21 152.94,103.41 152.95,103.43 152.97,103.44 153.04,103.5 153.08,103.59 153.08,103.61 153.45,103.98 154.08,103.98 154.41,104.3 154.42,104.3 154.53,104.36 154.62,104.46 154.63,104.47 154.65,104.48 154.85,104.48
+1.2VSUS on BOTTOM (solid shape): 166.4,103.72 166.4,103.38 166.24,103.22 166.22,103.21 166.1,103.14 166.04,103.01 166.03,102.99 166.01,102.96 165.96,102.96 165.95,102.96 165.83,102.99 165.71,102.97 165.7,102.97 165.67,102.97 165.6,103.05 165.59,103.06 165.52,103.16 165.4,103.21 165.38,103.22 165.26,103.34 165.26,103.72 165.39,103.85 166.28,103.85
+1.2VSUS on BOTTOM (solid shape): 169.83,103.85 169.83,103.47 169.7,103.34 168.94,103.34 168.82,103.22 168.8,103.21 168.79,103.22 168.63,103.16 168.55,103.01 168.55,102.99 168.52,102.96 168.48,102.96 168.47,102.96 168.35,102.99 168.23,102.97 168.2,102.97 168.17,102.99 168.11,103.05 168.08,103.11 168.05,103.15 168.05,103.41 168.06,103.43 168.07,103.45 168.13,103.5 168.16,103.57 168.16,103.58 168.56,103.98 169.7,103.98
+1.2VSUS on BOTTOM (solid shape): 155.39,30.95 155.43,30.94 155.44,30.9 155.44,30.46 155.44,30.43 155.44,29.85 153.9,28.31 153.89,28.3 153.66,28.04 153.7,27.69 153.7,27.67 153.7,27.64 153.45,27.38 153.25,27.38 153.25,27.39 153.06,27.39 153.05,27.4 145.81,27.4 145.75,27.46 145.75,28.28 146.08,28.62 146.08,29.81 147.03,30.76 147.03,30.9 147.04,30.94 147.08,30.95
+1.2VSUS on BOTTOM (solid shape): 143.75,30.9 143.75,30.88 143.69,30.7 143.74,30.52 143.75,30.51 143.75,30.47 143.74,30.46 143.8,30.4 143.8,30.34 143.84,30.29 143.87,30.25 143.89,30.22 144.55,29.56 144.55,27.5 144.46,27.41 144.44,27.4 144.42,27.39 141.84,27.39 141.8,27.43 141.8,28.49 141.3,28.99 140.79,29.5 140.79,30.36 140.8,30.38 140.82,30.4 140.89,30.46 140.94,30.54 140.97,30.65 140.97,30.76 140.97,30.79 140.99,30.81 141.28,31.1 143.54,31.1
+1.2VSUS on BOTTOM (solid shape): 161.45,103.72 161.45,102.96 161.32,102.83 161.08,102.83 161.06,102.84 161.04,102.85 160.79,102.97 160.54,102.85 160.52,102.84 160.5,102.83 160.18,102.83 160.05,102.96 160.05,103.09 160.36,103.4 160.39,103.41 160.54,103.46 160.62,103.58 160.62,103.6 160.64,103.61 160.66,103.62 160.69,103.62 160.93,103.63 161.1,103.82 161.12,103.84 161.15,103.85 161.32,103.85
+1.2VSUS on BOTTOM (solid shape): 160.06,30.94 160.98,30.94 161.14,30.77 161.14,30.52 161.35,30.32 169.45,30.32 169.46,30.33 169.48,30.34 169.51,30.34 169.82,30.4 169.96,30.69 169.96,30.71 169.98,30.73 170.08,30.84 170.08,30.95 170.09,30.95 170.47,30.95 170.72,30.7 170.72,29.68 170.09,29.05 164.5,29.05 164.24,28.79 164.24,27.62 164.03,27.41 158.79,27.41 158.55,27.65 158.55,29.64 159.31,30.39 159.42,30.52 159.46,30.69 159.46,30.71 159.48,30.73 159.58,30.84 159.58,30.86 159.67,30.95 160.05,30.95
+1.2VSUS on BOTTOM (solid shape): 173.46,108.24 173.7,108.22 173.82,108.02 173.87,107.89 173.99,107.84 174.09,107.84 174.15,107.79 174.4,107.79 174.66,107.53 174.66,107.2 174.63,107.16 174.62,107.11 174.4,106.9 174.28,106.9 173.9,107.28 173.87,107.28 173.84,107.29 173.82,107.32 173.5,107.55 173.19,107.32 173.17,107.29 173.14,107.28 173.01,107.28 172.91,107.37 172.88,107.43 172.88,107.66 173.06,107.84 173.16,107.84 173.3,107.99 173.31,108.03 173.32,108.07 173.33,108.11
+1.2VSUS on BOTTOM (solid shape): 200.93,13.93 200.96,13.92 201.01,13.87 201.01,13.85 201.08,13.67 201.23,13.55 201.28,13.49 201.28,13.42 201.27,13.25 201.33,13.09 201.76,12.66 201.76,9.54 201.71,9.49 199.32,9.49 199.24,9.57 199.24,9.83 199.26,9.87 199.3,9.89 199.82,9.89 199.82,10.23 199.3,10.23 199.26,10.25 199.24,10.28 199.24,10.48 199.3,10.53 199.82,10.53 199.85,10.56 199.96,10.56 200.07,10.67 200.07,13.35 200.26,13.54 200.27,13.54 200.46,13.64 200.57,13.82 200.61,13.88 200.68,13.9 200.79,13.9 200.9,13.93
+1.2VSUS on BOTTOM (solid shape): 158.61,107.71 158.63,107.67 158.66,107.64 158.66,107.44 158.62,107.4 158.6,107.35 158.38,107.13 158.37,107.13 158.27,107.07 158.22,106.97 158.21,106.96 158.15,106.9 158.12,106.89 158.1,106.89 157.84,106.87 157.67,106.68 157.67,106.66 157.64,106.64 157.42,106.64 157.39,106.66 157.39,106.68 157.34,106.76 157.28,106.83 157.26,106.85 157.26,106.87 157.26,106.92 157.26,106.94 157.28,106.96 157.35,107.05 157.4,107.15 157.4,107.17 157.54,107.31 157.56,107.31 157.7,107.38 157.77,107.52 157.77,107.54 157.81,107.57 157.84,107.58 157.85,107.57 158.11,107.57 158.3,107.75 158.3,107.77 158.33,107.79 158.53,107.79
+1.2VSUS on BOTTOM (solid shape): 174.83,103.94 174.95,103.94 175.2,103.68 175.21,103.67 175.23,103.56 175.29,103.47 175.29,103.45 175.29,103.18 175.29,103.16 175.25,103.11 175.23,103.06 175.17,103 175.15,102.99 175.12,102.98 174.93,102.97 174.78,102.86 174.77,102.84 174.74,102.83 174.28,102.83 174,103.11 173.97,103.15 173.9,103.21 173.75,103.21 173.65,103.15 173.59,103.04 173.58,103.03 173.52,102.97 173.5,102.97 173.48,102.97 173.37,102.99 173.26,102.97 173.24,102.97 173.21,102.97 173.14,103.05 173.14,103.06 173.05,103.18 172.9,103.22 172.88,103.22 172.86,103.23 172.75,103.34 172.75,103.85 172.88,103.98 174.79,103.98
+1.2VSUS on BOTTOM (solid shape): 152.65,108.17 152.68,108.16 152.7,108.13 152.82,107.97 153.01,107.94 153.04,107.94 153.07,107.91 153.96,107.91 154.08,107.79 154.08,107.44 154.05,107.4 154.02,107.35 153.96,107.28 153.78,107.28 153.75,107.29 153.73,107.32 153.42,107.55 153.1,107.32 153.09,107.3 153.07,107.28 152.93,107.14 152.91,107.13 152.81,107.09 152.74,106.99 152.68,106.94 152.61,106.94 152.5,106.95 152.38,106.93 152.37,106.92 152.35,106.93 152.28,106.97 152.25,107.02 152.22,107.06 152.22,107.38 152.29,107.57 152.2,107.74 152.18,107.75 152.18,107.78 152.18,107.94 152.18,107.96 152.2,107.98 152.26,108.05 152.3,108.13 152.32,108.16 152.35,108.17
+1.2VSUS on BOTTOM (solid shape): outline of 303 points within 107.19,27.34 177.56,81.72
+1.2VSUS on BOTTOM (solid shape): outline of 927 points within 140.88,39.46 156.37,49.11
+1.2VSUS on IN2 (solid shape): outline of 36154 points within 107.79,32.32 183.71,108.17
+1.2VSUS on IN3 (solid shape): 156.71,33.53 156.76,33.62 156.86,33.62 156.93,33.6 157.01,33.59 157.1,33.53 157.08,33.42 155.14,31.48 155.14,29.99 155.12,29.95 155.09,29.94 151.18,29.94 151.14,29.95 151.12,29.99 151.12,31.06 152.45,32.39 155.62,32.39 156.71,33.48
+1.2VSUS on IN3 (solid shape): outline of 22288 points within 105.55,29.94 180.88,67.65
+1.2VSUS on GND2 (solid shape): outline of 1249 points within 147.03,11.47 204.98,30.95
+1.2VSUS_S on TOP (solid shape): 103.16,53.56 103.16,51.4 102.7,50.94 102.7,46.24 102.55,46.09 101.71,46.09 101.71,45.25 100.87,44.41 97.95,44.41 97.75,44.61 97.7,44.67 97.64,44.73 96.68,45.68 96.68,53.3 97.31,53.94 102.78,53.94
+1.2VSUS_S on IN4 (solid shape): outline of 117 points within 94.27,52.67 98.71,63.84
+1.5V on TOP (solid shape): 93.89,51.65 93.89,49.18 93.6,48.89 92.74,48.89 90.77,50.86 90.77,51.74 90.99,51.95 93.58,51.95
+1.5V on TOP (solid shape): 87.2,56.27 87.2,54.71 87.15,54.65 86.44,54.65 86.44,54.65 85.48,54.65 84.95,55.18 84.95,56.41 85.21,56.67 86.81,56.67
+1.5V on TOP (solid shape): 59.49,64.9 59.49,63.87 58.71,63.08 58.71,62.75 58.58,62.63 57.86,62.63 57.77,62.73 57.77,64 58.1,64.33 58.1,65.17 58.27,65.34 59.05,65.34
+1.5V on TOP (solid shape): 94.37,47.77 94.37,46.39 95.35,45.4 95.35,45.34 95.42,45.34 96.41,44.34 96.41,43.82 96.43,43.8 96.43,43.04 96.19,42.8 96.16,42.79 96.14,42.79 96.11,42.8 94.69,44.23 94.61,44.23 94.54,44.31 93.6,44.31 92.93,44.97 92.93,45 93.77,45 93.77,44.94 93.79,44.89 93.8,44.84 93.83,44.79 93.86,44.75 93.9,44.71 93.95,44.68 93.99,44.66 94.05,44.64 94.1,44.63 94.15,44.63 94.21,44.63 94.26,44.65 94.31,44.67 94.35,44.7 94.4,44.73 94.43,44.77 94.46,44.82 94.48,44.87 94.5,44.92 94.51,44.97 94.51,45.03 94.5,45.08 94.48,45.13 94.46,45.18 94.43,45.22 94.4,45.26 94.35,45.3 94.31,45.33 94.26,45.35 94.21,45.36 94.15,45.37 94.1,45.37 94.05,45.36 93.99,45.34 93.95,45.31 93.9,45.28 93.86,45.24 93.83,45.2 93.8,45.15 93.79,45.1 93.77,45.05 93.77,45 92.93,45 92.93,47.88 92.97,47.92 94.22,47.92
+1.5V on IN1 (solid shape): outline of 411 points within 58.2,60.29 70.11,65.62
+1.5V on IN4 (solid shape): 71.67,62.42 71.67,61.39 71.54,61.25 68.98,61.25 68.71,61.52 68.71,62.46 69.02,62.77 71.32,62.77
+1.5V on IN4 (solid shape): 86.19,56.19 86.19,55.47 85.9,55.19 83.38,55.19 83.13,55.43 83.13,56.27 83.22,56.36 86.02,56.36
+1.05V_DEEP_SUS on TOP (solid shape): outline of 143 points within 282.54,66 287.81,71.03
+1.05V_DEEP_SUS on TOP (solid shape): outline of 146 points within 247.28,62.57 254.38,69.31
+1.05V_DEEP_SUS on BOTTOM (solid shape): 256.98,47.18 256.98,47 256.6,46.62 256.47,46.62 256.39,46.7 256.34,46.75 256.1,46.75 255.87,46.52 255.87,46.49 255.84,46.42 255.82,46.35 255.82,46.33 254.84,45.35 253.48,45.35 253.4,45.43 253.4,46.83 253.67,47.1 253.69,47.11 253.71,47.11 254.05,47.21 254.15,47.55 254.15,47.56 254.16,47.59 255.18,48.6 255.56,48.6
+1.05V_DEEP_SUS on BOTTOM (solid shape): 252.89,67.91 252.89,67.27 252.93,67.23 252.93,67.23 252.99,67.15 253.06,67.09 253.07,67.09 253.14,67.02 254.92,67.02 255.05,66.89 255.05,66.64 254.13,65.72 254.03,65.69 253.96,65.76 253.88,65.88 253.75,65.94 253.68,65.94 253.61,65.92 253.6,65.91 253.44,65.91 253.42,65.92 253.4,65.93 253.38,65.95 252.92,65.96 252.83,65.52 252.83,65.42 252.74,65.37 252.51,65.37 251.37,66.51 251.37,67.15 252.38,68.16 252.64,68.16
+1.05V_DEEP_SUS on BOTTOM (solid shape): 233.8,76.05 233.8,75.89 233.79,75.85 233.78,75.81 233.65,75.68 233.33,75.68 233.2,75.56 233.12,75.5 233.09,75.48 232.88,75.26 232.83,75.2 232.81,75.12 232.57,74.88 232.11,74.88 231.74,74.9 231.54,74.59 231.54,74.57 231.73,74.25 232.1,74.26 232.11,74.26 232.15,74.26 232.19,74.25 232.42,74.03 232.46,73.95 232.43,73.87 232.06,73.5 231.97,73.41 230.41,71.85 230.41,71.21 230.79,70.83 230.79,70.19 229.9,69.31 229.52,69.31 228.76,70.07 228.76,71.85 229.06,72.15 229.06,72.79 229.66,73.4 229.66,73.53 229.7,73.58 229.75,73.61 229.8,73.64 229.82,73.65 229.84,73.65 230.18,73.74 230.28,74.09 230.28,74.1 230.28,74.13 230.94,74.78 230.94,75.55 231.58,76.19 233.66,76.19
+1.05V_DEEP_SUS on BOTTOM (solid shape): 249.56,65.78 249.56,65.76 249.56,65.74 249.63,65.48 249.86,65.34 249.88,65.33 250.09,65.12 250.1,65.1 250.2,64.9 250.39,64.8 250.41,64.8 250.62,64.59 250.63,64.57 250.74,64.34 250.97,64.24 250.99,64.24 251,64.23 251.75,64.23 251.81,64.16 251.82,64.14 251.82,64.11 251.82,64.02 251.84,63.94 251.84,63.93 251.84,63.77 251.84,63.75 251.82,63.74 251.72,63.56 251.73,63.36 251.74,63.35 251.73,63.32 251.55,63.14 251.48,63.11 251.41,63.14 251.2,63.22 251.01,63.11 251,63.1 250.98,63.08 250.6,63.08 250.12,63.56 250.09,63.6 250.06,63.63 248.57,65.11 248.57,65.46 248.6,65.49 248.61,65.5 248.76,65.58 248.83,65.73 248.83,65.75 248.95,65.88 249.46,65.88
+1.05V_DEEP_SUS on BOTTOM (solid shape): 249.98,69.65 250,69.61 250.02,69.59 250.07,69.57 250.11,69.55 250.12,69.52 250.12,68.92 250.14,68.9 250.14,68.87 250.13,68.85 250.12,68.79 250.15,68.73 250.19,68.69 250.21,68.67 250.29,68.65 250.36,68.67 250.63,68.67 250.76,68.8 250.76,69.05 250.88,69.18 251.52,69.18 251.64,69.05 251.64,68.16 251.62,68.14 251.6,68.13 251.57,68.13 251.4,68.1 251.28,67.96 251.25,67.93 251.23,67.88 251.22,67.81 251.22,67.81 251.13,67.68 250.97,67.62 250.94,67.61 250.9,67.59 250.87,67.56 250.87,67.56 250.79,67.51 250.74,67.43 250.72,67.4 250.69,67.37 250.68,67.33 250.68,67.32 250.56,67.12 250.33,67.1 250.31,67.11 250.23,67.12 250.17,67.06 250.15,67.03 250.12,67.02 249.84,67.02 249.81,67.04 249.8,67.07 249.79,67.09 249.18,67.7 249.18,67.84 249.18,67.92 249.18,68.18 249.17,68.22 249.15,68.25 249.12,68.28 249.1,68.32 249.1,68.53 249.12,68.56 249.15,68.6 249.17,68.63 249.18,68.67 249.18,68.93 249.22,69.08 249.31,69.13 249.71,69.54 249.78,69.65 249.83,69.69 249.93,69.69
+1.05V_DEEP_SUS on VCC (solid shape): outline of 16153 points within 228.76,45.56 287.81,80.74
+1.05V_DEEP_SUS_S on TOP (solid shape): 295.31,67.02 295.31,62.45 294.8,61.94 288.97,61.94 288.95,61.96 288.68,62.08 288.41,61.96 288.4,61.96 288.36,61.94 288.2,61.94 286.67,63.46 285.4,63.46 285.15,63.72 285.15,65.11 284.77,65.5 284.77,65.86 286.3,67.4 286.42,67.4 286.62,67.2 287.1,67.2 287.79,66.51 288.14,66.51 288.14,66.51 288.75,66.51 288.75,66.51 290.94,66.51 291.85,67.43 294.9,67.43
+1.05V_DEEP_SUS_S on BOTTOM (solid shape): 291.62,66.38 291.62,64.86 291.5,64.73 290.41,64.73 290.12,65.03 289.68,65.03 289.47,65.24 289.47,66.38 289.59,66.51 291.5,66.51
+1.05V_LAN on TOP (solid shape): 23.49,128.94 23.83,128.94 23.91,128.91 23.93,128.82 24.29,128.37 24.65,128.82 24.67,128.91 24.75,128.94 25.1,128.94 25.31,128.74 25.31,127.34 25.18,127.22 23.65,127.22 23.02,126.58 23.02,125.82 22.62,125.42 22.6,125.42 22.46,125.36 22.4,125.22 22.4,125.2 22,124.8 21.37,124.8 21.11,125.06 21.11,126.5 21.15,126.58 21.22,126.61 21.6,126.85 21.46,127.27 21.42,127.35 21.45,127.43 22.97,128.95 23.48,128.95
+1.05V_LAN on BOTTOM (solid shape): 20.86,122.77 20.86,121.38 20.73,121.25 17.81,121.25 17.43,121.63 17.43,122.77 17.69,123.03 20.61,123.03
+1.05V_LAN on BOTTOM (solid shape): 24.19,121.5 24.23,121.49 24.24,121.45 24.24,120.45 24.44,120.45 24.44,121.45 24.45,121.49 24.49,121.5 24.59,121.5 24.63,121.49 24.64,121.45 24.64,121.14 24.6,121.04 24.58,120.94 24.58,120.16 24.67,120.08 24.67,119.85 24.68,119.84 24.68,117.58 24.67,117.57 23.24,117.57 23.21,117.58 23.19,117.62 23.19,119.53 23.64,119.98 23.78,119.98 24.04,120.23 24.04,120.45 24.04,120.45 24.04,121.45 24.05,121.49 24.09,121.5
+1.05V_LAN on IN3 (solid shape): outline of 369 points within 17.43,118.71 28.48,129.63
+1.5V_S on TOP (solid shape): 104.43,38.19 104.43,36.54 104.68,36.29 104.73,36.29 104.73,36.28 105.07,36.28 105.19,36.16 105.19,35.52 104.93,35.27 104.93,30.06 104.81,29.94 102.9,29.94 102.78,30.06 102.78,34.38 102.14,35.02 102.14,38.32 102.27,38.44 104.17,38.44
+1.8V on TOP (solid shape): 286.8,42.29 286.8,36.03 286.42,35.65 285.54,35.65 285.5,35.67 285.49,35.7 285.49,36.49 285.28,36.49 285.28,35.7 285.27,35.66 285.23,35.65 285.17,35.65 285.15,35.65 285.13,35.67 285.09,35.71 285.09,36.49 285.07,36.49 285.03,36.51 285.02,36.54 285.02,36.61 285.02,36.63 285.03,36.65 285.1,36.71 285.11,36.72 285.29,36.83 285.38,37.02 285.39,37.03 285.4,37.05 285.4,39.21 284.64,39.97 284.64,42.64 284.91,42.91 286.18,42.91
+1.8V_AMP on TOP (solid shape): 224.85,158.08 224.85,157.32 224.72,157.19 224.43,157.19 224.3,157.32 224.3,157.69 224.1,157.9 223.77,157.9 223.26,157.39 222.87,157.39 222.76,157.49 222.76,158.18 223.2,158.61 224.31,158.61
+1.8V_AMP on TOP (solid shape): 197.16,158.79 197.18,158.78 197.19,158.77 197.34,158.62 197.69,158.62 197.8,158.51 198.47,158.51 198.51,158.5 198.53,158.46 199.54,158.46 199.56,158.47 199.59,158.47 199.62,158.46 199.69,158.39 199.69,158.32 199.57,158.2 199.54,158.21 198.53,158.21 198.53,158.2 198.48,158.2 198.21,157.93 198.21,157.78 198.17,157.7 198.09,157.68 197.75,157.57 197.67,157.22 197.87,156.98 198.19,156.99 198.26,156.99 198.32,156.95 198.46,156.81 198.65,156.77 198.85,156.83 199,156.99 199,156.99 199.55,156.99 199.66,156.88 199.66,155.83 199.33,155.5 199.01,155.5 198.66,155.16 198.55,155.16 198.46,155.2 198.45,155.29 198.46,155.34 198.46,155.51 198.37,155.66 198.35,155.73 198.37,155.79 198.1,156.42 197.83,155.79 197.86,155.73 197.83,155.66 197.75,155.51 197.74,155.34 197.75,155.29 197.74,155.2 197.66,155.16 196.9,155.16 196.78,155.28 196.78,157.71 196.65,157.84 196.65,158.68 196.76,158.79
+1.8V_AMP on BOTTOM (solid shape): 199.46,156.99 199.59,156.86 199.59,155.68 199.58,155.67 199.55,155.55 199.58,155.44 199.59,155.43 199.59,155.28 199.56,155.21 199.55,155.16 199.55,155.14 199.41,154.99 198.91,154.99 198.85,155.05 198.85,155.25 198.93,155.33 199.07,155.33 199.15,155.39 199.2,155.46 199.2,155.48 199.21,155.55 199.2,155.63 199.2,155.64 199.2,155.84 199.02,156.02 199.02,156.81 199.21,157 199.46,157
+1.8V_CPAVDD18 on TOP (solid shape): 336.4,8.38 336.44,8.36 336.46,8.33 336.46,8.23 336.44,8.2 336.4,8.18 335.53,8.18 335.53,8.14 335.52,8.11 335.49,8.1 335.39,8.1 334.75,7.46 334.71,7.44 334.67,7.41 334.53,7.33 334.44,7.2 334.44,7.19 333.74,6.48 333.74,3.29 333.58,3.14 333.03,3.14 332.82,3.34 332.82,4.2 332.83,4.2 332.83,4.93 332.82,4.93 332.82,6.82 333,7 333.43,7 333.85,7.42 333.87,7.44 333.89,7.44 334,7.45 334.11,7.48 334.16,7.51 334.2,7.55 334.25,7.59 334.29,7.65 335.02,8.38
+1.8V_DEEP_SUS on TOP (solid shape): 284.13,43.27 284.13,39.84 283.5,39.21 283.5,37.36 283.49,37.34 283.48,37.33 283.38,37.07 283.48,36.82 283.5,36.81 283.5,36.79 283.71,36.58 283.72,36.55 283.72,36.52 283.72,36.51 283.68,36.49 283.68,35.71 283.64,35.67 283.62,35.65 283.6,35.65 283.54,35.65 283.5,35.66 283.49,35.7 283.49,36.49 283.28,36.49 283.28,35.7 283.27,35.66 283.23,35.65 282.61,35.65 282.1,36.16 282.1,39.59 281.21,40.48 281.21,43.4 281.34,43.52 283.88,43.52
+1.8V_DEEP_SUS on TOP (solid shape): 270.09,77.86 270.26,77.67 270.52,77.67 270.54,77.67 270.56,77.67 270.57,77.66 270.85,77.38 270.85,77.38 270.97,77.26 271.12,77.22 271.17,77.19 271.22,77.13 271.28,77.07 271.48,76.92 271.73,76.96 271.82,77.02 271.88,77.1 271.9,77.12 271.93,77.12 272.09,77.12 272.33,76.87 272.35,76.84 272.33,76.8 272.3,76.77 272.25,76.75 272.21,76.73 272.15,76.68 272.1,76.62 272.08,76.6 272.06,76.6 269.68,76.6 269.47,76.8 268.75,76.8 268.26,76.31 267.6,76.31 266.48,77.43 266.48,77.56 266.67,77.76 266.87,77.76 267.53,77.09 268.07,77.09 268.86,77.89 270.04,77.89
+1.8V_DEEP_SUS on BOTTOM (solid shape): 271.96,77.14 272.04,77.11 272.25,76.9 272.28,76.81 272.23,76.74 272.09,76.31 272.51,76.17 272.68,76.18 272.82,76.25 272.83,76.26 272.88,76.27 273.08,76.07 273.08,75.78 272.7,75.4 272.19,75.4 271.81,75.01 271.53,75.01 271.3,75.24 271.3,75.47 271.68,75.85 271.75,76 271.68,76.15 271.65,76.18 271.65,76.93 271.81,77.01 271.88,77.09
+1.8V_DEEP_SUS on IN3 (solid shape): outline of 1892 points within 247.43,43.15 284.03,71.07
+1.8V_SM on BOTTOM (solid shape): 281.26,20.56 281.26,20 281.72,19.55 281.72,17.3 281.59,17.17 279.91,17.17 279.38,17.71 279.38,17.9 280.62,17.9 280.62,17.9 281.27,17.9 281.27,19.55 281,19.55 281,17.9 280.62,17.9 280.62,19.57 280.35,19.57 280.35,17.9 279.38,17.9 279.38,18.25 279.31,18.33 279.31,20.31 279.66,20.66 281.16,20.66
+1.8VPCU on TOP (solid shape): 194.46,84.39 194.5,84.37 194.51,84.34 194.51,83.55 194.71,83.55 194.71,84.34 194.73,84.37 194.76,84.39 194.85,84.39 194.91,84.33 194.91,83.56 194.31,82.96 192.34,82.96 192.18,83.12 192.18,83.73 192.31,83.86 192.9,83.86 193.43,84.39
+1.8VPCU on TOP (solid shape): 196.37,157.7 196.37,156.68 196.09,156.4 195.04,156.4 195.03,156.41 194.88,156.44 194.72,156.41 194.71,156.4 194.65,156.4 194.32,156.07 193.81,156.07 193.71,156.17 193.71,156.92 193.91,157.13 193.93,157.13 194.18,157.24 194.28,157.49 194.28,157.51 194.6,157.82 196.25,157.82
+1.8VPCU on TOP (solid shape): 282.97,34.51 283,34.5 283.02,34.49 283.03,34.46 283.67,34.46 283.72,34.4 283.71,34.36 283.68,34.34 283.68,33.54 283.73,33.53 283.74,33.52 283.74,33.3 283.7,33.26 283.66,33.23 283.62,33.19 283.59,33.15 283.57,33.1 283.55,33.05 283.54,32.99 283.54,32.94 283.54,32.88 283.27,32.6 281.21,32.6 280.96,32.86 280.96,33.54 283.49,33.54 283.49,34.34 283.28,34.34 283.28,33.54 280.96,33.54 280.96,34.25 281.21,34.51
+1.8VPCU on TOP (solid shape): 198.06,84.51 198.13,84.48 198.16,84.41 198.17,84.35 198.19,84.29 198.26,84.17 198.38,84.08 198.39,84.08 198.41,84.05 198.41,83.71 198.4,83.68 198.39,83.66 198.37,83.64 198.34,83.63 198.09,83.58 197.94,83.38 197.92,83.31 197.91,83.24 197.91,82.4 197.64,82.13 196.5,82.13 196.29,82.34 196.29,83.46 196.28,83.47 196.28,83.5 196.29,83.53 196.31,83.55 196.31,84.33 196.37,84.39 196.46,84.39 196.5,84.37 196.51,84.34 196.51,83.55 196.71,83.55 196.71,84.34 196.73,84.37 196.76,84.39 197.14,84.39 197.26,84.51
+1.8VPCU on TOP (solid shape): outline of 96 points within 102.88,13.32 106.84,25.77
+1.8VPCU on TOP (solid shape): outline of 195 points within 285.05,26.51 291.24,34.51
+1.8VPCU on BOTTOM (solid shape): outline of 179 points within 181.52,10.25 184.68,33.75
+1.8VPCU on VCC (solid shape): outline of 381 points within 182.4,32.32 186.52,82.77
+1.8VPCU on IN2 (solid shape): 108.87,14.1 108.87,12.97 108.69,12.79 106.08,12.79 105.65,13.23 105.65,14.16 105.89,14.41 108.56,14.41
+1.8VPCU on IN2 (solid shape): outline of 3363 points within 181.9,2.12 287.43,34.51
+1.8VPCU on IN3 (solid shape): outline of 174 points within 182.75,79.68 193.89,86.09
+1.8VPCU on IN3 (solid shape): outline of 544 points within 187.69,148.12 194.85,157.19
+1.8VPCU on IN4 (solid shape): 197.9,83.91 197.9,82.74 197.77,82.61 195.44,82.61 195.41,82.63 195.41,82.64 195.19,82.83 194.9,82.77 194.82,82.75 194.76,82.8 194.4,82.94 194.15,82.65 194.15,82.63 194.12,82.61 193.54,82.61 193.51,82.62 193.5,82.63 193.26,82.78 192.99,82.7 192.92,82.67 192.85,82.7 192.82,82.74 192.82,83.91 193.2,84.29 197.52,84.29
+1.8VPCU_S on TOP (solid shape): 292.34,29.76 292.53,29.55 292.81,29.54 292.85,29.5 293.58,29.5 295.94,27.14 298.2,27.14 299.37,25.97 299.37,24.6 299.12,24.35 291.55,24.35 291.52,24.36 291.5,24.4 291.5,25.03 291.29,25.03 291.26,25.05 291.24,25.09 291.24,26.41 291.25,26.41 291.25,29.69 291.32,29.76
+1.8VPCU_S on BOTTOM (solid shape): 295.56,25.82 295.56,24.35 295.43,24.22 292.01,24.22 291.88,24.35 291.88,25.9 292.11,26.13 295.26,26.13
+2.5VSUS on TOP (solid shape): outline of 393 points within 174.78,21.68 184.7,49.59
+2.5VSUS on BOTTOM (solid shape): 181.13,41.37 181.34,41.37 181.57,41.14 183.02,41.14 183.19,40.96 183.19,40.12 183.03,39.95 183,39.94 182.94,39.96 182.89,39.98 182.84,39.99 182.79,40 182.74,39.99 182.69,39.98 182.64,39.97 182.6,39.94 182.55,39.91 182.54,39.89 182.2,39.89 181.9,39.59 180.88,39.59 180.25,38.95 179.86,38.95 179.48,39.33 179.48,39.45 179.98,39.45 179.98,41.21 179.73,41.21 179.73,39.45 179.48,39.45 179.48,41.11 179.99,41.62 180.88,41.62
+2.5VSUS on BOTTOM (solid shape): 171.42,22.95 171.5,22.91 171.51,22.82 171.86,22.33 172.21,22.82 172.23,22.91 172.31,22.95 176.05,22.95 176.18,22.82 176.18,21.68 175.93,21.43 170.42,21.43 170.26,21.58 170.26,22.65 170.57,22.95
+2.5VSUS on BOTTOM (solid shape): 189.85,36.87 189.85,32.68 189.78,32.62 189.78,29.82 189.52,29.55 188.02,29.55 187.71,29.86 187.71,31.35 187.75,31.56 187.65,31.76 187.63,31.83 187.75,32.15 187.63,32.46 187.75,32.78 187.63,33.1 187.65,33.17 187.7,33.61 187.28,33.77 187.19,33.79 187.15,33.87 187.15,36.9 187.31,37.05 189.67,37.05
+2.5VSUS on BOTTOM (solid shape): outline of 157 points within 179.48,55.72 187.87,66.56
+2.5VSUS on IN1 (solid shape): 184.18,48.86 184.18,43.02 186.75,40.45 186.75,38.12 187.02,37.86 187.02,37.73 187.08,37.67 187.09,37.64 187.09,37.63 187.17,37.32 187.48,37.23 187.51,37.23 187.53,37.22 187.92,36.83 187.92,34.11 187.54,33.74 187.52,33.73 187.49,33.73 187.34,33.74 187.19,33.68 186.75,33.68 186.73,33.69 186.72,33.7 184.83,35.58 184.83,37.88 183.83,38.89 183.83,39.06 183.04,39.85 183,39.89 182.53,40.36 182.53,41.19 182.58,41.27 182.67,41.28 183.12,41.59 182.67,41.9 182.58,41.92 182.53,42 182.53,48 182.49,48.04 182.49,48.73 182.67,48.91 182.7,48.92 182.71,48.92 182.83,48.91 182.94,48.95 183.04,49.03 183.1,49.13 183.1,49.14 183.13,49.16 183.88,49.16
+2.5VSUS on IN3 (solid shape): outline of 103 points within 181.54,47.55 184.29,59.36
+2.5VSUS_S on BOTTOM (solid shape): outline of 110 points within 190.07,26.74 194.66,33.62
+3V on TOP (solid shape): 319.03,43.37 319.03,41.72 318.93,41.62 318.07,41.62 317.94,41.75 317.94,43.75 318.19,44.01 318.4,44.01
+3V on TOP (solid shape): 288.65,14.57 288.65,14.11 288.83,13.93 288.83,11.14 288.7,11.01 287.56,11.01 287.31,11.27 287.31,14.7 287.43,14.82 288.4,14.82
+3V on TOP (solid shape): 263.56,80.74 263.56,80.48 263.05,79.97 262.67,79.97 261.53,81.12 261.02,81.12 260.42,80.52 260.35,80.51 260.28,80.48 260.13,80.48 259.11,81.5 259.11,81.75 260.26,82.89 260.26,82.91 260.62,83.28 261.02,83.28
+3V on TOP (solid shape): 353.97,120.11 354.6,119.79 355,119.21 355,118.58 354.87,118.45 353.73,118.45 353.6,118.58 353.6,119.27 353.14,119.72 353.14,120.03 353.22,120.11
+3V on TOP (solid shape): 263.17,57.23 263.25,57.26 263.32,57.22 263.35,57.19 263.44,57.1 263.44,56.7 263.67,56.47 263.67,55.11 263.58,55.02 263.5,55.02 263.33,55.19 263.33,55.68 262.99,56.02 262.5,56.02 262.34,56.18 262.34,56.41
+3V on TOP (solid shape): 260.36,86.7 260.36,85.03 259.75,84.42 259.49,84.42 259.37,84.55 259.37,84.8 260,85.43 260,86.07 259.37,86.7 259.01,86.7 258.91,86.72 258.81,86.7 258.1,86.7 257.97,86.83 257.97,87.41 258.06,87.5 258.12,87.62 258.35,87.85 259.21,87.85
+3V on TOP (solid shape): 47.25,59.22 47.25,57.24 47.02,57.02 45,57.02 44.79,57.23 44.79,57.83 44.81,57.85 44.81,58.43 45.01,58.63 45.02,58.64 45.12,58.69 45.18,58.79 45.18,58.8 45.19,58.82 45.2,58.84 45.2,59.15 45.19,59.15 45.19,59.32 45.27,59.4 47.07,59.4
+3V on TOP (solid shape): 67.81,48.82 67.81,46.63 67.77,46.52 67.76,46.39 67.76,46.37 67.75,46.35 67.55,46.14 67.55,45.76 67.37,45.58 66.66,45.58 66.55,45.68 66.55,46.27 66.4,46.42 65.82,46.42 65.64,46.6 65.64,47.21 65.79,47.36 66.81,47.36 66.94,47.49 66.94,47.87 66.95,47.97 66.94,48.07 66.94,48.35 66.66,48.63 66.25,48.63 66.16,48.67 66.15,48.77 66.16,48.8 66.16,48.84 66.16,49.14 66.16,49.17 66.18,49.25 66.26,49.29 67.34,49.29
+3V on TOP (solid shape): 273.73,70.95 274.91,70.95 274.99,70.92 275.02,70.84 275.23,70.53 275.59,70.65 275.67,70.69 275.75,70.66 278.16,68.25 278.16,67.48 278.1,67.38 277.99,67.41 277.16,68.23 277.16,68.68 277.15,68.71 277.15,68.8 276,69.94 275.9,69.94 275.89,69.95 275.35,69.95 275.29,70.03 275.08,70.24 274.99,70.32 274.44,70.32 274.41,70.35 274.41,70.37 274.39,70.43 274.35,70.49 274.14,70.7 273.99,70.76 273.83,70.7 273.71,70.58 273.34,70.58 272.83,71.08 272.83,71.34 272.94,71.45 273.23,71.45

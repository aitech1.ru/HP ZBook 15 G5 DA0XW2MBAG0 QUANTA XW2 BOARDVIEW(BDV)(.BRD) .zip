# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A6: length 94.7
  TOP w0.102: JDIM1003.127 145.1,33.33 144.41,34.03 143.75,34.03 143.67,34.1 143.67,34.38 143.95,34.66 143.95,34.81 143.83,34.93 143.52,34.93 143.42,35.04 143.42,35.32 143.52,35.42 143.67,35.42 143.8,35.54 143.8,35.73 143.67,35.85 143.24,35.85 143.06,35.68 143.06,34.86 143.31,34.61 143.31,34.41 142.99,34.08 142.71,34.08 v1(142.63,34.16)
  IN1 w0.076: v1(156.16,104.62) 156.16,104.29 155.27,103.4 155.27,93.57 155.23,93.53
  IN1 w0.152: v1(142.63,34.16) 144.12,35.65 144.12,40.53 143.63,41.01 143.63,47.47 143.31,47.79 143.31,49.84 143.98,50.5 144.53,50.5 144.83,50.8 144.83,52.59 144.46,52.96 144.46,72.45 144.96,72.96 144.96,73.32 144.46,73.83 144.46,74.13 144.61,74.28 144.81,74.28 144.96,74.43 144.96,74.66 144.81,74.82 144.61,74.82 144.46,74.97 144.46,75.43 155.02,86 155.02,93.33 155.23,93.53
  BOTTOM w0.076: U9001.AN7 155.83,104.3 v1(156.16,104.62)
  BOTTOM w0.102: v1(142.63,34.16) 143.29,34.82 143.29,37.42 145.1,39.24 JDIM1002.127
M_B_A7: length 89.8
  TOP w0.102: JDIM1003.122 143.85,39.39 143.52,39.05 143.52,38.81 143.85,38.47 143.85,38.1 143.96,38 144.1,38 144.2,37.9 144.2,37.59 144.13,37.52 143.96,37.52 143.85,37.41 143.85,37.13 143.96,37.03 144.1,37.03 144.2,36.93 144.2,36.65 144.1,36.55 143.96,36.55 143.85,36.45 143.85,36.17 143.75,36.06 143.14,36.06 143.03,36.16 143.03,36.3 v1(142.63,36.7)
  IN1 w0.076: 154.72,93.78 154.91,93.98 154.91,103.56 155.51,104.15 155.51,104.8 155.78,105.07 155.78,106.19 v1(156.16,106.57)
  IN1 w0.152: v1(142.63,36.7) 143.13,37.2 143.13,40.12 142.32,40.92 142.32,50.49 142.85,51.02 142.85,54.37 142.54,54.68 142.54,55.34 142.85,55.65 142.85,57.26 143.47,57.88 143.47,75.84 154.49,86.87 154.49,93.56 154.72,93.78
  BOTTOM w0.076: v1(156.16,106.57) 155.83,106.25 U9001.AN10
  BOTTOM w0.102: v1(142.63,36.7) 142.23,36.29 142.23,33.99 142.59,33.63 143.21,33.63 143.85,32.98 JDIM1002.122
M_B_A8: length 92.1
  TOP w0.102: JDIM1003.125 144.6,33.32 144.18,33.75 143.67,33.75 143.47,33.95 143.24,33.95 143.03,33.75 142.47,33.75 142.22,34 142.22,34.94 141.79,35.37 141.79,35.63 142.02,35.85 142.21,35.85 v1(142.63,35.43)
  IN1 w0.076: 154.97,93.66 155.09,93.78 155.09,103.48 155.72,104.11 155.72,104.77 156.16,105.21 v1(156.16,105.27)
  IN1 w0.152: 154.97,93.66 154.77,93.45 154.77,86.44 143.96,75.64 143.96,57.5 143.81,57.34 143.64,57.34 143.49,57.19 143.49,56.96 143.64,56.81 143.78,56.81 143.96,56.63 143.96,56.43 143.81,56.28 143.64,56.28 143.49,56.12 143.49,55.9 143.64,55.74 143.81,55.74 143.96,55.59 143.96,55.26 143.81,55.11 143.64,55.11 143.49,54.96 143.49,54.73 143.64,54.57 143.81,54.57 143.96,54.42 143.96,51.19 142.82,50.04 142.82,47.59 143.14,47.27 143.14,41.7 142.82,41.38 142.82,41.13 143.62,40.32 143.62,36.99 143.29,36.66 143.29,36.39 143.6,36.08 143.6,35.83 143.04,35.27 142.79,35.27 v1(142.63,35.43)
  BOTTOM w0.076: U9001.AN8 155.83,104.95 v1(156.16,105.27)
  BOTTOM w0.102: v1(142.63,35.43) 143.06,35.86 143.06,37.81 144.6,39.36 JDIM1002.125
M_B_A9: length 92.6
  TOP w0.102: JDIM1003.121 143.6,33.03 143.76,33.18 144.13,33.18 144.23,33.28 144.23,33.39 144.08,33.54 143.68,33.54 143.47,33.33 143.29,33.33 143.1,33.52 142.87,33.52 142.73,33.38 142.55,33.38 141.87,34.07 141.87,34.23 142.02,34.38 142.02,34.79 141.92,34.89 141.77,34.89 141.64,34.76 141.64,34.54 141.57,34.46 141.36,34.46 141.26,34.57 141.26,35.02 v1(141.41,35.17)
  IN1 w0.076: v1(154.33,107.22) 154.79,106.76 154.79,106.38 154.86,106.31 154.86,105.14 155.02,104.99 155.02,104.17 154.56,103.71 154.56,94.42 154.32,94.18
  IN1 w0.152: v1(141.41,35.17) 142.14,35.9 142.14,39.7 141.33,40.51 141.33,55.64 141.81,56.12 141.81,61.25 142.48,61.92 142.48,76.25 153.98,87.76 153.98,93.84 154.32,94.18
  BOTTOM w0.076: U9001.AR11 154.01,106.9 v1(154.33,107.22)
  BOTTOM w0.102: JDIM1002.121 143.6,39.51 143.18,39.08 143.17,39.08 141.82,37.73 141.82,35.58 v1(141.41,35.17)
M_B_A10: length 93
  TOP w0.102: v1(152.03,37.34) 151.58,37.34 151.14,36.9 150.86,36.9 150.43,37.33 150.43,37.64 150.53,37.74 150.81,37.74 150.91,37.84 150.91,38.12 150.81,38.22 150.53,38.22 150.43,38.32 150.43,38.7 150.81,39.08 151.6,39.08 151.85,39.33 JDIM1003.146
  IN1 w0.076: v1(159.82,104.62) 159.93,104.5 159.93,100.89 160.08,100.74 160.08,89.18 160.25,89.01
  IN1 w0.152: v1(152.03,37.34) 152.03,45.25 154.32,47.55 154.32,50.28 154.47,50.43 154.72,50.43 154.85,50.57 154.85,54.68 154.75,54.78 154.52,54.78 154.37,54.93 154.37,55.52 153.89,55.99 153.89,64.4 153.72,64.58 153.72,64.84 153.89,65.02 153.89,65.17 154.01,65.28 154.34,65.28 154.44,65.38 154.44,65.67 154.34,65.78 154.01,65.78 153.91,65.88 153.91,66.18 154.01,66.28 154.33,66.28 154.44,66.38 154.44,66.69 154.34,66.79 154.01,66.79 153.91,66.89 153.91,67.22 154.01,67.32 154.34,67.32 154.44,67.43 154.44,67.77 154.34,67.88 154.01,67.88 153.91,67.98 153.91,68.31 154.01,68.41 154.29,68.41 154.44,68.56 154.44,68.79 154.29,68.94 154.04,68.94 153.89,69.09 153.89,69.32 154.04,69.48 154.29,69.48 154.44,69.63 154.44,69.86 154.29,70.01 154.04,70.01 153.89,70.16 153.89,70.39 154.04,70.54 154.29,70.54 154.44,70.7 154.44,70.92 154.29,71.08 154.04,71.08 153.89,71.23 153.89,71.46 154.04,71.61 154.29,71.61 154.44,71.76 154.44,71.99 154.29,72.14 154.04,72.14 153.89,72.3 153.89,72.52 154.04,72.68 154.29,72.68 154.44,72.83 154.44,73.06 154.29,73.21 154.04,73.21 153.89,73.36 153.89,73.62 154.02,73.74 154.29,73.74 154.44,73.9 154.44,74.12 154.29,74.28 154.02,74.28 153.89,74.4 153.89,74.74 153.99,74.84 154.34,74.84 154.44,74.94 154.44,75.29 161.32,82.17 161.32,87.94 160.25,89.01
  BOTTOM w0.076: v1(159.82,104.62) 159.49,104.3 U9001.AH7
  BOTTOM w0.102: v1(152.03,37.34) 151.62,36.94 151.62,35.83 151.92,35.53 151.92,33.36 151.85,33.3 JDIM1002.146
M_B_A11: length 94.4
  TOP w0.102: JDIM1003.120 143.35,39.21 143.23,39.08 142.53,39.08 142.4,38.95 142.4,38.67 142.5,38.57 143.44,38.57 143.65,38.36 143.65,36.55 143.54,36.44 143.29,36.44 143.16,36.57 143.16,37.81 143,37.97 v1(142.63,37.97)
  IN1 w0.076: v1(156.16,107.22) 155.71,106.77 155.71,106.45 155.63,106.36 155.63,105.14 155.29,104.81 155.29,104.19 154.73,103.63 154.73,94.21 154.52,93.99
  IN1 w0.152: v1(142.63,37.97) 142.63,39.91 141.83,40.72 141.83,50.7 142.3,51.17 142.3,54.21 142.04,54.47 142.04,55.59 142.3,55.85 142.3,57.79 142.45,57.94 142.82,57.94 142.97,58.1 142.97,58.33 142.82,58.48 142.45,58.48 142.3,58.63 142.3,58.86 142.45,59.01 142.82,59.01 142.97,59.16 142.97,59.39 142.82,59.54 142.45,59.54 142.3,59.7 142.3,59.93 142.45,60.08 142.82,60.08 142.97,60.23 142.97,60.46 142.82,60.61 142.45,60.61 142.3,60.76 142.3,60.99 142.45,61.14 142.82,61.14 142.97,61.3 142.97,76.05 154.24,87.31 154.24,93.71 154.52,93.99
  BOTTOM w0.076: U9001.AN11 155.83,106.9 v1(156.16,107.22)
  BOTTOM w0.102: v1(142.63,37.97) 142.23,37.56 142.23,36.62 142.02,36.41 142.02,33.91 142.51,33.42 142.88,33.42 143.35,32.95 JDIM1002.120
M_B_A12: length 88.2
  TOP w0.102: v1(141.11,36.37) 140.79,36.05 140.79,35.76 141.01,35.55 141.01,34.41 141.17,34.25 141.38,34.25 141.51,34.12 141.51,33.91 141.67,33.75 141.88,33.75 142.01,33.62 142.01,33.41 142.24,33.18 142.99,33.18 143.1,33.07 JDIM1003.119
  IN1 w0.076: 154.08,94.3 154.38,94.6 154.38,103.83 154.86,104.32 154.86,104.89 154.71,105.05 154.71,106.19 v1(154.33,106.57)
  IN1 w0.152: v1(141.11,36.37) 141.64,36.9 141.64,39.5 140.84,40.31 140.84,55.85 141.31,56.32 141.31,61.45 141.98,62.12 141.98,76.46 153.73,88.21 153.73,93.95 154.08,94.3
  BOTTOM w0.076: v1(154.33,106.57) 154.01,106.25 U9001.AR10
  BOTTOM w0.102: JDIM1002.119 143.1,39.31 141.55,37.75 141.55,36.81 v1(141.11,36.37)
M_B_A13: length 93.8
  TOP w0.102: JDIM1003.158 154.85,38.33 154.71,38.18 154.71,36 154.93,35.78 155.26,35.78 v1(155.54,36.06)
  IN1 w0.076: v1(161.65,105.92) 162.03,105.54 162.03,104.32 162.02,104.32 162.02,100.79 162.36,100.45 162.36,100.21
  IN1 w0.152: 162.36,100.21 162.36,91.6 165.32,88.64 165.32,80.51 159.26,74.45 159.26,59.72 159.51,59.47 160.37,59.47 160.53,59.31 160.53,59.09 160.37,58.93 159.41,58.93 159.26,58.78 159.26,58.55 159.41,58.4 160.37,58.4 160.53,58.25 160.53,58.02 160.37,57.87 159.41,57.87 159.26,57.71 159.26,57.49 159.41,57.33 160.37,57.33 160.53,57.18 160.53,56.95 160.37,56.8 159.41,56.8 159.26,56.65 159.26,56.42 159.41,56.27 160.03,56.27 160.58,55.72 160.58,49.72 158.66,47.8 158.66,46.57 158.86,46.37 158.86,45.1 156.05,42.29 156.05,36.57 v1(155.54,36.06)
  BOTTOM w0.076: U9001.AF9 161.32,105.6 v1(161.65,105.92)
  BOTTOM w0.102: JDIM1002.158 154.85,33.75 155.07,33.96 155.07,35.59 v1(155.54,36.06)
M_B_A14: length 88.6
  TOP w0.102: JDIM1003.151 153.1,33.93 153.21,34.03 153.55,34.03 153.65,34.13 153.65,34.41 153.55,34.51 153.21,34.51 153.1,34.61 153.1,35.78 153.08,35.8 v1(153.08,36.59)
  IN1 w0.076: 160.67,100.77 160.67,100.92 160.39,101.19 160.39,104.23 160.54,104.37 160.54,104.91 160.35,105.1 160.35,106.69 v1(159.82,107.22)
  IN1 w0.152: v1(153.08,36.59) 153.58,37.09 153.58,44.65 155.85,46.93 155.85,48.5 156.61,49.26 156.61,49.66 156.82,49.87 157.17,49.87 157.39,50.08 157.39,54.77 155.96,56.19 155.96,73.33 156.14,73.51 156.47,73.51 156.62,73.66 156.62,73.89 156.47,74.04 156.12,74.04 155.96,74.19 155.96,74.42 156.12,74.57 156.42,74.57 156.62,74.78 156.62,75.32 162.85,81.54 162.85,88.13 160.67,90.31 160.67,100.77
  BOTTOM w0.076: v1(159.82,107.22) 159.49,106.9 U9001.AH11
  BOTTOM w0.102: v1(153.08,36.59) 152.64,37.04 152.64,38.39 153.1,38.86 JDIM1002.151
M_B_A15: length 92.3
  TOP w0.102: JDIM1003.156 154.35,35.82 v1(153.68,35.15)
  IN1 w0.076: 161.59,103.92 161.59,104.16 161.26,104.49 161.26,104.81 161.49,105.04 161.49,105.12 v1(161.65,105.28)
  IN1 w0.152: 161.59,103.92 161.59,100.48 161.91,100.17 161.91,90.91 164.29,88.53 164.29,80.94 158.07,74.72 158.07,67.75 157.41,67.09 157.41,64.19 157.56,64.04 157.75,64.04 157.9,63.89 157.9,63.66 157.75,63.51 157.56,63.51 157.41,63.35 157.41,63.13 157.56,62.97 157.75,62.97 157.9,62.82 157.9,62.59 157.75,62.44 157.56,62.44 157.41,62.29 157.41,62.06 157.56,61.91 157.75,61.91 157.9,61.75 157.9,61.53 157.75,61.37 157.56,61.37 157.41,61.22 157.41,60.99 157.56,60.84 157.75,60.84 157.9,60.69 157.9,60.46 157.75,60.31 157.56,60.31 157.41,60.15 157.41,59.93 157.56,59.77 157.75,59.77 157.9,59.62 157.9,59.39 157.75,59.24 157.56,59.24 157.41,59.09 157.41,58.86 157.56,58.71 157.75,58.71 157.9,58.55 157.9,58.33 157.41,57.84 157.41,56.79 159.42,54.79 159.42,54.27 159.27,54.12 159.27,49.87 157.3,47.9 157.3,45.88 157.16,45.73 156.71,45.73 156.55,45.58 156.55,45.25 156.67,45.14 156.92,45.14 157.05,45 157.05,44.75 155.02,42.72 155.02,36.49 v1(153.68,35.15)
  BOTTOM w0.076: v1(161.65,105.28) 161.31,104.95 U9001.AF8
  BOTTOM w0.102: JDIM1002.156 154.35,33.09 154.21,33.24 153.91,33.24 153.78,33.36 153.78,33.6 153.9,33.72 154.15,33.72 154.29,33.86 154.29,34.07 154.16,34.2 153.83,34.2 153.68,34.35 v1(153.68,35.15)
M_B_A16: length 94
  TOP w0.102: v1(153.08,37.84) 153.35,37.84 153.58,37.61 153.58,36.22 153.69,36.11 153.98,36.11 154.08,36.21 154.08,38.19 153.96,38.32 153.58,38.32 153.35,38.54 JDIM1003.152
  IN1 w0.076: v1(159.82,106.57) 160.2,106.19 160.2,105.03 160.37,104.86 160.37,104.42 160.24,104.29 160.24,101.07 160.46,100.85 160.46,89.95 160.69,89.72
  IN1 w0.152: v1(153.08,37.84) 153.08,44.85 155.36,47.13 155.36,48.71 156.12,49.47 156.12,49.91 156.75,50.54 156.75,51.09 156.37,51.48 156.37,53.65 156.22,53.81 156.03,53.81 155.88,53.96 155.88,54.19 156.03,54.34 156.22,54.34 156.42,54.54 156.42,54.95 155.23,56.14 155.23,56.32 155.47,56.56 155.47,56.81 155.31,56.96 155.05,56.96 154.92,57.09 154.92,57.37 155.05,57.49 155.31,57.49 155.47,57.65 155.47,57.87 155.31,58.03 155.05,58.03 154.92,58.15 154.92,58.43 155.05,58.56 155.31,58.56 155.47,58.71 155.47,58.94 155.31,59.09 155.05,59.09 154.92,59.22 154.92,59.5 155.05,59.63 155.31,59.63 155.47,59.78 155.47,60.01 155.31,60.16 155.05,60.16 154.92,60.29 154.92,60.54 155.07,60.69 155.31,60.69 155.47,60.85 155.47,61.08 155.31,61.23 155.07,61.23 154.92,61.38 154.92,61.61 155.07,61.76 155.31,61.76 155.47,61.91 155.47,62.14 155.31,62.29 155.07,62.29 154.92,62.45 154.92,62.68 155.07,62.83 155.31,62.83 155.47,62.98 155.47,74.86 162.35,81.75 162.35,88.06 160.69,89.72
  BOTTOM w0.076: v1(159.82,106.57) 159.49,106.25 U9001.AH10
  BOTTOM w0.102: JDIM1002.152 153.35,33.17 153.28,33.25 153.28,35.86 153.49,36.07 153.49,37.43 v1(153.08,37.84)
M_B_BG#0: length 86.9
  TOP w0.102: v1(140.12,36.78) 140.36,36.78 140.59,36.54 140.59,35.68 140.8,35.47 140.8,34.33 142.1,33.03 JDIM1003.115
  IN1 w0.076: 153.06,98.71 153.06,99.37 153.7,100.01 153.7,104.06 153.95,104.31 153.95,105.54 v1(154.33,105.92)
  IN1 w0.114: v1(140.12,36.78) 140.12,38.94 139.37,39.7 139.37,43.26 138.58,44.05 138.58,59.15 139.62,60.19 139.62,61.83 140.51,62.73 140.51,77.07 153.06,89.61 153.06,98.71
  BOTTOM w0.076: U9001.AR9 154.01,105.6 v1(154.33,105.92)
  BOTTOM w0.102: v1(140.12,36.78) 140.12,37.49 142.1,39.47 JDIM1002.115
M_B_BG#1: length 92
  TOP w0.102: JDIM1003.113 141.61,33.24 141.38,33.47 141.26,33.47 141,33.21 140.85,33.21 140.73,33.33 140.73,33.47 140.95,33.7 140.95,33.82 140.64,34.13 140.48,34.13 140.38,34.03 140.38,33.64 140.31,33.57 140.09,33.57 140.01,33.64 140.01,34.36 140.09,34.43 140.52,34.43 140.6,34.51 140.6,35.37 140.5,35.48 v1(140.19,35.48)
  IN1 w0.114: v1(154.33,104.62) 154.33,104.4 153.93,104 153.93,99.86 153.26,99.18 153.26,89.22 140.93,76.89 140.93,62.55 140.04,61.66 140.04,58.46 140.26,58.23 140.26,57.76 140.12,57.62 139.21,57.62 139.1,57.51 139.1,57.24 139.21,57.12 140.15,57.12 140.26,57.01 140.26,56.76 139,55.49 139,48.36 139.79,47.57 139.79,39.87 140.59,39.07 140.59,35.88 v1(140.19,35.48)
  BOTTOM w0.076: U9001.AR7 154.01,104.3 v1(154.33,104.62)
  BOTTOM w0.102: JDIM1002.113 141.61,39.31 139.72,37.42 139.72,35.94 v1(140.19,35.48)
M_B_BS#0: length 89.4
  TOP w0.102: v1(152.03,36.07) 152.43,36.48 152.43,37.66 151.82,38.27 151.82,38.55 151.97,38.7 152.66,38.7 152.85,38.89 JDIM1003.150
  IN1 w0.076: v1(159.82,105.27) 159.82,105.2 160.22,104.8 160.22,104.48 160.09,104.35 160.09,100.99 160.26,100.82 160.26,89.64 160.43,89.47
  IN1 w0.114: 160.43,89.47 161.84,88.06 161.84,81.96 154.95,75.08 154.95,64.91 154.84,64.8 154.52,64.8 154.41,64.68 154.41,64.42 154.52,64.3 154.84,64.3 154.95,64.19 154.95,63.97 154.82,63.84 154.54,63.84 154.41,63.7 154.41,63.59 154.67,63.33 154.67,63.15 154.41,62.89 154.41,56.23 154.88,55.76 154.88,55.37 155.11,55.15 155.49,55.15 155.7,54.94 155.7,54.73 155.37,54.4 155.37,53.32 155.48,53.2 155.74,53.2 155.85,53.09 155.85,52.82 155.74,52.71 155.48,52.71 155.37,52.59 155.37,52.33 155.48,52.21 155.74,52.21 155.85,52.1 155.85,51.26 156.14,50.98 156.14,50.66 155.48,50 155.02,50 154.92,49.9 154.92,49.68 155.02,49.58 155.15,49.58 155.25,49.48 155.25,49.32 154.85,48.92 154.85,47.34 152.54,45.04 152.54,36.28 152.34,36.07 v1(152.03,36.07)
  BOTTOM w0.076: v1(159.82,105.27) 159.49,104.95 U9001.AH8
  BOTTOM w0.102: JDIM1002.150 152.85,33.27 152.15,33.98 152.15,35.95 v1(152.03,36.07)
M_B_BS#1: length 95.8
  TOP w0.102: v1(151.51,34.99) 151.51,36.21 151.34,36.38 150.98,36.38 150.78,36.18 150.78,34.13 151.04,33.87 151.34,33.87 151.6,33.61 JDIM1003.145
  IN1 w0.076: v1(159.82,105.92) 159.44,105.54 159.44,104.48 159.78,104.14 159.78,100.79 159.93,100.64 159.93,88.83 160.05,88.7
  IN1 w0.114: v1(151.51,34.99) 151.57,34.99 151.82,34.74 151.98,34.74 152.14,34.9 152.14,35.33 151.9,35.57 151.25,35.57 151.14,35.69 151.14,35.83 151.51,36.2 151.51,45.47 153.81,47.76 153.81,50.69 153.96,50.84 154.13,50.84 154.34,51.04 154.34,54.24 154.16,54.41 153.96,54.41 153.81,54.56 153.81,55.35 153.38,55.78 153.38,56.1 153.2,56.28 152.97,56.28 152.86,56.38 152.86,56.68 152.97,56.78 153.27,56.78 153.37,56.89 153.37,57.24 153.27,57.34 152.91,57.34 152.81,57.44 152.81,57.77 152.91,57.88 153.24,57.88 153.38,58.01 153.38,61.19 153.24,61.33 152.95,61.33 152.83,61.45 152.83,61.71 152.95,61.83 153.26,61.83 153.38,61.94 153.38,62.21 153.26,62.32 152.95,62.32 152.83,62.44 152.83,62.7 152.95,62.82 153.26,62.82 153.38,62.93 153.38,63.2 153.26,63.31 152.95,63.31 152.83,63.43 152.83,63.69 152.95,63.81 153.26,63.81 153.38,63.92 153.38,64.19 153.26,64.3 152.95,64.3 152.83,64.42 152.83,64.68 153.38,65.23 153.38,74.96 160.81,82.39 160.81,87.95 160.05,88.7
  BOTTOM w0.076: U9001.AH9 159.49,105.6 v1(159.82,105.92)
  BOTTOM w0.102: v1(151.51,34.99) 151.51,35.65 151.42,35.74 151.42,38.83 151.6,39.01 JDIM1002.145
M_B_CB0: length 97
  TOP w0.102: v1(136.9,35.88) 137.31,36.29 138.06,36.29 138.19,36.41 138.19,36.67 138.06,36.79 137.5,36.79 137.37,36.92 137.37,37.48 137.57,37.68 137.57,38.23 138.55,39.21 139.09,39.21 139.35,39.47 JDIM1003.104
  IN1 w0.076: v1(151.59,107.22) 151.97,106.84 151.97,106.4 152.12,106.25 152.12,105.11 152.28,104.96 152.28,103.99 152.02,103.73 152.02,96.93 151.39,96.3 151.39,91.98 151.16,91.75
  IN1 w0.102: v1(136.9,35.88) 137.57,35.22 137.82,35.22 138,35.4 138,35.67 137.29,36.38 137.29,37.76 136.53,38.52 136.53,41.33 135.16,42.7 135.16,61.39 137.64,63.87 137.64,64.14 137.29,64.49 137.29,64.69 137.4,64.79 137.57,64.79 137.67,64.9 137.67,65.1 137.57,65.2 137.4,65.2 137.29,65.3 137.29,65.5 137.4,65.61 137.57,65.61 137.67,65.71 137.67,65.91 137.57,66.01 137.4,66.01 137.29,66.11 137.29,66.29 137.67,66.67 137.67,78.26 151.16,91.75
  BOTTOM w0.076: U9001.AW11 151.26,106.9 v1(151.59,107.22)
  BOTTOM w0.102: v1(136.9,35.88) 136.5,35.48 136.5,34.42 137.05,33.87 137.91,33.87 138.48,33.3 139.16,33.3 139.35,33.11 JDIM1002.104
M_B_CB1: length 96.6
  TOP w0.102: JDIM1003.88 135.35,39.35 134.02,38.01 133.33,38.01 133.02,37.71 133.02,36 v1(133.42,35.6)
  IN1 w0.076: v1(150.67,107.22) 150.41,107.48 150.27,107.48 150.14,107.35 150.14,105.09 149.99,104.94 149.99,104.45 149.23,103.69 149.23,94.52 149.13,94.42
  IN1 w0.102: v1(133.42,35.6) 133.19,35.6 132.72,36.07 132.72,39.02 130.02,41.73 130.02,53.37 130.13,53.48 130.28,53.48 130.37,53.57 130.37,53.76 130.23,53.9 130.23,54.09 130.37,54.23 130.37,56.39 130.59,56.61 130.82,56.61 130.92,56.71 130.92,56.92 130.82,57.02 130.47,57.02 130.37,57.12 130.37,57.32 130.47,57.42 130.82,57.42 130.92,57.53 130.92,57.73 130.82,57.83 130.47,57.83 130.37,57.93 130.37,58.14 130.47,58.24 130.82,58.24 130.92,58.34 130.92,62.39 133.03,64.51 133.03,78.93 145.75,91.65 146.36,91.65 149.13,94.42
  BOTTOM w0.076: U9001.AY11 150.35,106.9 v1(150.67,107.22)
  BOTTOM w0.102: JDIM1002.88 135.35,33.11 135.18,33.29 134.47,33.29 133.89,33.87 133.89,34.76 134.04,34.91 134.04,35.36 133.8,35.6 v1(133.42,35.6)
M_B_CB2: length 95.9
  TOP w0.102: v1(133.43,37.51) 135.03,35.91 135.03,34.02 136.1,32.95 JDIM1003.91
  IN1 w0.076: v1(150.67,105.27) 150.67,105.19 150.3,104.81 150.3,104.3 149.53,103.54 149.53,94.06 149.44,93.97
  IN1 w0.102: 149.44,93.97 146.46,90.99 146.03,90.99 133.86,78.83 133.86,78.5 133.97,78.4 134.14,78.4 134.25,78.3 134.25,78.09 134.14,77.99 133.86,77.99 133.76,77.89 133.76,77.64 133.86,77.54 134,77.54 134.1,77.44 134.1,77.24 134,77.14 133.86,77.14 133.76,77.03 133.76,76.83 133.86,76.73 134,76.73 134.1,76.63 134.1,76.42 134,76.32 133.86,76.32 133.76,76.22 133.76,76.02 133.86,75.92 134,75.92 134.1,75.81 134.1,75.61 134,75.51 133.86,75.51 133.76,75.41 133.76,75.21 133.86,75.1 134,75.1 134.1,75 134.1,74.8 134,74.7 133.86,74.7 133.76,74.6 133.76,74.39 133.86,74.29 134,74.29 134.1,74.19 134.1,73.99 134,73.88 133.86,73.88 133.76,73.78 133.76,73.58 133.86,73.48 134,73.48 134.1,73.38 134.1,73.17 134,73.07 133.86,73.07 133.76,72.97 133.76,72.77 133.86,72.67 134,72.67 134.1,72.56 134.1,72.36 134,72.26 133.86,72.26 133.76,72.16 133.76,71.95 133.86,71.85 134,71.85 134.1,71.75 134.1,71.55 134,71.45 133.86,71.45 133.76,71.34 133.76,71.14 133.86,71.04 134,71.04 134.1,70.94 134.1,70.73 134,70.63 133.86,70.63 133.76,70.53 133.76,70.33 133.86,70.23 134,70.23 134.1,70.13 134.1,69.92 134,69.82 133.86,69.82 133.69,69.65 133.69,64.24 131.58,62.12 131.58,50.89 131.45,50.76 131.2,50.76 131.03,50.59 131.03,50.26 131.17,50.11 131.17,49 131.07,48.9 130.84,48.9 130.74,48.8 130.74,48.59 130.84,48.49 131.07,48.49 131.17,48.39 131.17,48.19 131.07,48.09 130.78,48.09 130.68,47.98 130.68,47.78 130.78,47.68 131.07,47.68 131.17,47.58 131.17,41.51 133.43,39.25 v1(133.43,37.51)
  BOTTOM w0.076: U9001.AY8 150.35,104.95 v1(150.67,105.27)
  BOTTOM w0.102: v1(133.43,37.51) 133.89,37.05 134.15,37.05 134.3,37.2 134.3,37.94 135.31,38.95 135.78,38.95 136.1,39.28 JDIM1002.91
M_B_CB3: length 98.6
  TOP w0.102: v1(136.9,34.61) 137.21,34.61 137.37,34.77 137.37,35.93 137.52,36.08 138.01,36.08 138.19,35.9 138.19,35.61 138.08,35.51 137.88,35.51 137.78,35.41 137.78,35.16 137.9,35.03 138.08,35.03 138.19,34.93 138.19,34.64 138.77,34.05 138.77,33.8 138.65,33.68 138.65,33.54 138.85,33.34 138.99,33.34 139.09,33.43 139.28,33.43 139.61,33.11 JDIM1003.105
  IN1 w0.076: 151.55,103.74 151.97,104.17 151.97,104.83 151.59,105.22 v1(151.59,105.27)
  IN1 w0.102: 151.55,103.74 151.49,103.68 151.49,99.32 150.42,98.25 150.42,91.94 136.63,78.16 136.63,63.8 134.5,61.66 134.5,61.43 134.37,61.3 134.14,61.3 133.99,61.16 133.99,57.77 134.12,57.65 134.35,57.65 134.5,57.49 134.5,54.74 134.34,54.57 134.14,54.57 133.99,54.42 133.99,51.32 134.5,50.81 134.5,49.94 134.4,49.84 134.09,49.84 133.99,49.73 133.99,49.53 134.09,49.43 134.4,49.43 134.5,49.33 134.5,49.12 134.4,49.02 134.09,49.02 133.99,48.92 133.99,48.72 134.09,48.62 134.4,48.62 134.5,48.51 134.5,48.31 134.4,48.21 134.09,48.21 133.99,48.11 133.99,47.91 134.09,47.8 134.4,47.8 134.5,47.7 134.5,47.5 134.4,47.4 134.27,47.4 133.99,47.12 133.99,42.06 135.87,40.19 135.87,38.25 136.43,37.69 136.43,35.09 v1(136.9,34.61)
  BOTTOM w0.076: v1(151.59,105.27) 151.26,104.95 U9001.AW8
  BOTTOM w0.102: JDIM1002.105 139.61,39.46 137.45,37.3 137.45,35.15 v1(136.9,34.61)
M_B_CB4: length 96.7
  TOP w0.102: JDIM1003.87 135.1,32.98 135.37,33.25 135.37,33.39 135.15,33.62 134.91,33.62 134.8,33.72 134.8,34 134.68,34.13 134.68,34.38 134.83,34.53 134.83,34.84 134.68,34.99 134.68,35.24 134.83,35.4 134.83,35.68 134.47,36.03 134.14,36.03 134.08,36.1 134.08,36.53 133.97,36.64 133.79,36.64 133.66,36.51 133.66,36.47 v1(133.43,36.24)
  IN1 w0.076: 149.26,94.17 149.38,94.29 149.38,103.61 150.14,104.38 150.14,104.87 150.3,105.02 150.3,106.21 150.66,106.57 v1(150.67,106.57)
  IN1 w0.102: v1(133.43,36.24) 133.05,36.62 133.05,39.16 130.35,41.86 130.35,48.87 130.7,49.22 130.7,49.43 130.6,49.53 130.45,49.53 130.35,49.63 130.35,49.83 130.45,49.93 130.6,49.93 130.7,50.04 130.7,50.24 130.6,50.34 130.45,50.34 130.35,50.44 130.35,50.65 130.45,50.75 130.6,50.75 130.7,50.85 130.7,51.05 130.6,51.15 130.45,51.15 130.35,51.26 130.35,51.46 130.45,51.56 130.6,51.56 130.7,51.66 130.7,51.86 130.6,51.97 130.45,51.97 130.35,52.07 130.35,52.27 130.45,52.37 130.6,52.37 130.7,52.47 130.7,52.68 130.6,52.78 130.45,52.78 130.35,52.88 130.35,53.08 130.45,53.19 130.6,53.19 130.7,53.29 130.7,54.03 130.97,54.3 131.15,54.3 131.25,54.41 131.25,54.61 131.15,54.71 130.8,54.71 130.7,54.81 130.7,55.02 130.8,55.12 131.15,55.12 131.25,55.22 131.25,55.42 131.12,55.55 130.8,55.55 130.72,55.63 130.72,55.88 131.25,56.4 131.25,62.26 133.36,64.37 133.36,78.79 145.89,91.32 146.41,91.32 149.26,94.17
  BOTTOM w0.076: v1(150.67,106.57) 150.35,106.25 U9001.AY10
  BOTTOM w0.102: v1(133.43,36.24) 133.02,36.65 133.02,37.71 134.02,38.7 134.32,38.7 135.1,39.48 JDIM1002.87
M_B_CB5: length 99
  TOP w0.102: v1(136.9,37.15) 136.4,37.15 136.2,37.35 136.2,37.63 136.38,37.81 137.19,37.81 137.32,37.94 137.32,38.19 137.19,38.32 136.15,38.32 136.05,38.42 136.05,38.7 136.18,38.83 137.83,38.83 138.35,39.35 JDIM1003.100
  IN1 w0.076: v1(151.59,106.57) 151.97,106.19 151.97,105.05 152.12,104.9 152.12,104.05 151.67,103.6 151.67,99.12 151.24,98.68 151.24,93.44 151.14,93.34
  IN1 w0.102: 151.14,93.34 150.98,93.18 150.98,92.04 137.32,78.38 137.32,77.5 136.96,77.15 136.96,76.94 137.07,76.84 137.22,76.84 137.32,76.74 137.32,76.54 137.22,76.43 137.07,76.43 136.96,76.33 136.96,76.13 137.07,76.03 137.19,76.03 137.29,75.93 137.29,75.72 137.19,75.62 137.07,75.62 136.96,75.52 136.96,75.32 137.07,75.21 137.19,75.21 137.29,75.11 137.29,74.91 137.19,74.81 137.07,74.81 136.96,74.71 136.96,74.5 137.07,74.4 137.19,74.4 137.29,74.3 137.29,74.1 137.19,74 137.07,74 136.96,73.89 136.96,73.69 137.07,73.59 137.19,73.59 137.29,73.49 137.29,73.28 137.19,73.18 137.07,73.18 136.96,73.08 136.96,72.88 137.07,72.78 137.19,72.78 137.29,72.67 137.29,72.47 137.19,72.37 137.07,72.37 136.96,72.27 136.96,72.07 137.07,71.96 137.19,71.96 137.29,71.86 137.29,71.66 137.19,71.56 137.07,71.56 136.96,71.46 136.96,71.25 137.07,71.15 137.19,71.15 137.29,71.05 137.29,70.85 137.19,70.74 137.07,70.74 136.96,70.64 136.96,70.44 137.07,70.34 137.19,70.34 137.29,70.24 137.29,70.03 137.19,69.93 137.07,69.93 136.96,69.83 136.96,69.63 137.07,69.53 137.19,69.53 137.29,69.42 137.29,69.22 137.19,69.12 137.07,69.12 136.96,69.02 136.96,68.81 137.07,68.71 137.19,68.71 137.29,68.61 137.29,68.41 137.19,68.31 137.07,68.31 136.96,68.2 136.96,68 137.07,67.9 137.19,67.9 137.29,67.8 137.29,67.59 137.19,67.49 137.07,67.49 136.96,67.39 136.96,67.19 137.07,67.09 137.19,67.09 137.27,67.01 137.27,66.76 136.96,66.45 136.96,63.66 134.83,61.53 134.83,44.97 134.73,44.86 134.58,44.86 134.47,44.76 134.47,44.56 134.58,44.46 134.75,44.46 134.83,44.38 134.83,44.13 134.75,44.05 134.58,44.05 134.47,43.95 134.47,43.75 134.58,43.65 134.73,43.65 134.83,43.54 134.83,42.56 136.2,41.19 136.2,38.38 136.9,37.68 v1(136.9,37.15)
  BOTTOM w0.076: v1(151.59,106.57) 151.26,106.25 U9001.AW10
  BOTTOM w0.102: JDIM1002.100 138.35,32.98 137.85,33.49 137.14,33.49 136.3,34.34 136.3,36.54 v1(136.9,37.15)
M_B_CB6: length 96
  TOP w0.102: JDIM1003.92 136.35,39.4 135.24,38.28 135.24,34.51 v1(135.65,34.11)
  IN1 w0.076: 149.51,93.66 149.68,93.83 149.68,103.43 150.67,104.42 v1(150.67,104.62)
  IN1 w0.102: v1(135.65,34.11) 135.19,33.64 134.56,33.64 134.15,34.05 134.15,35.02 133.81,35.36 133.81,39.33 131.5,41.64 131.5,47.94 131.6,48.04 131.81,48.04 131.91,48.14 131.91,48.42 131.81,48.52 131.58,48.52 131.5,48.6 131.5,48.82 131.6,48.93 131.81,48.93 131.91,49.03 131.91,49.23 131.81,49.33 131.58,49.33 131.5,49.41 131.5,49.64 131.6,49.74 131.81,49.74 131.91,49.84 131.91,61.98 134.02,64.1 134.02,69.38 134.58,69.93 134.58,79.07 146.14,90.64 146.49,90.64 149.51,93.66
  BOTTOM w0.076: v1(150.67,104.62) 150.35,104.3 U9001.AY7
  BOTTOM w0.102: JDIM1002.92 136.35,33.44 136.19,33.61 134.74,33.61 134.53,33.82 134.53,34.56 134.68,34.71 134.9,34.71 135.03,34.58 135.03,34.31 135.24,34.11 v1(135.65,34.11)
M_B_CB7: length 97.2
  TOP w0.102: v1(135.65,37.28) 136.5,36.43 136.5,34.44 136.74,34.2 137.94,34.2 138.3,33.84 138.3,33.41 138.6,33.11 138.6,32.13 JDIM1003.101
  IN1 w0.102: v1(151.59,104.64) 151.59,104.14 151.26,103.81 151.26,99.41 150.22,98.37 150.22,92.21 136.3,78.29 136.3,69.22 135.82,68.74 135.82,68.53 135.92,68.43 136.2,68.43 136.3,68.33 136.3,68.13 136.2,68.02 135.92,68.02 135.82,67.92 135.82,67.72 135.92,67.62 136.2,67.62 136.3,67.52 136.3,67.31 136.2,67.21 135.92,67.21 135.82,67.11 135.82,66.91 135.92,66.81 136.2,66.81 136.3,66.7 136.3,66.5 136.2,66.4 135.92,66.4 135.82,66.3 135.82,66.09 135.92,65.99 136.2,65.99 136.3,65.89 136.3,65.69 136.2,65.59 135.92,65.59 135.82,65.48 135.82,65.28 135.92,65.18 136.2,65.18 136.3,65.08 136.3,64.87 136.2,64.77 135.92,64.77 135.82,64.67 135.82,64.47 135.92,64.37 136.1,64.37 136.3,64.16 136.3,63.93 133.66,61.29 133.66,57.3 133.76,57.2 134.07,57.2 134.17,57.1 134.17,56.9 134.07,56.8 133.76,56.8 133.66,56.69 133.66,56.49 133.76,56.39 134.07,56.39 134.17,56.29 134.17,56.08 134.07,55.98 133.76,55.98 133.66,55.88 133.66,55.68 133.76,55.58 134.07,55.58 134.17,55.48 134.17,55.27 134.07,55.17 133.76,55.17 133.66,55.07 133.66,50.8 133.76,50.7 134.07,50.7 134.17,50.6 134.17,50.4 134.07,50.3 133.76,50.3 133.66,50.2 133.66,47.2 133.53,47.07 133.43,47.07 133.33,46.97 133.33,46.74 133.43,46.64 133.56,46.64 133.66,46.54 133.66,46.31 133.56,46.21 133.43,46.21 133.33,46.11 133.33,45.88 133.43,45.78 133.56,45.78 133.66,45.67 133.66,41.93 135.54,40.05 135.54,38.11 135.65,38 v1(135.65,37.28)
  BOTTOM w0.076: v1(151.59,104.64) 151.25,104.3 U9001.AW7
  BOTTOM w0.102: v1(135.65,37.28) 136.01,36.92 136.18,36.92 136.3,37.05 136.3,37.43 136.16,37.57 136.16,37.86 136.49,38.19 137.07,38.19 137.7,38.83 138.21,38.83 138.61,39.23 JDIM1002.101
M_B_CKE0: length 83.8
  IN1 w0.076: v1(153.42,105.27) 153.19,105.04 153.19,104.96 153.03,104.79 153.03,104.09 152.53,103.6 152.53,96.63 151.89,95.98 151.89,90.24 151.71,90.06
  IN1 w0.114: v1(139.29,36.66) 138.87,37.08 138.87,38.42 138.11,39.18 138.11,41.99 136.74,43.36 136.74,60.74 139.26,63.25 139.26,77.61 151.71,90.06
  BOTTOM w0.076: U9001.AT8 153.09,104.95 v1(153.42,105.27)
  BOTTOM w0.102: v1(139.29,36.66) 138.91,36.29 138.34,36.29 138,36.62 138,37.23 139.35,38.58 139.74,38.58 140.61,39.44 JDIM1002.109
M_B_CKE1: length 84
  IN1 w0.076: 151.54,90.49 151.73,90.68 151.73,96.11 152.38,96.75 152.38,103.66 152.87,104.16 152.87,104.92 153.03,105.08 153.03,106.08 153.04,106.2 v1(153.42,106.57)
  IN1 w0.114: 151.54,90.49 138.84,77.78 138.84,63.42 136.32,60.91 136.32,43.18 137.69,41.81 137.69,39 138.45,38.25 138.45,36.87 v1(139.29,36.03)
  BOTTOM w0.076: U9001.AT10 153.09,106.25 v1(153.42,106.57)
  BOTTOM w0.102: v1(139.29,36.03) 139.78,35.53 139.78,34.08 140.85,33 JDIM1002.110
M_B_CKE2: length 88.1
  TOP w0.102: v1(139.29,37.93) 139.09,37.93 138.88,37.72 138.88,35.2 139.1,34.99 139.47,34.99 139.77,34.68 139.77,33.45 139.86,33.36 140.35,33.36 140.61,33.11 JDIM1003.109
  IN1 w0.076: 152.18,91.37 152.04,91.51 152.04,95.76 152.68,96.4 152.68,103.53 153.42,104.27 v1(153.42,104.62)
  IN1 w0.114: 152.18,91.37 152.43,91.12 152.43,90.19 139.67,77.43 139.67,63.08 138.78,62.18 138.78,60.58 138.62,60.42 138.46,60.42 138.12,60.76 137.92,60.76 137.77,60.62 137.77,60.41 138.11,60.07 138.11,59.92 137.59,59.39 137.59,57.84 137.43,57.69 137.32,57.69 137.16,57.53 137.16,57.32 137.27,57.2 137.53,57.2 137.66,57.07 137.66,56.89 137.53,56.76 137.27,56.76 137.19,56.67 137.19,56.4 137.27,56.31 137.53,56.31 137.66,56.18 137.66,56 137.53,55.87 137.27,55.87 137.16,55.76 137.16,55.54 137.27,55.42 137.53,55.42 137.64,55.32 137.64,55.09 137.53,54.98 137.27,54.98 137.16,54.87 137.16,54.59 137.26,54.49 137.51,54.49 137.66,54.34 137.66,50.38 137.51,50.22 137.31,50.22 137.16,50.07 137.16,49.86 137.27,49.75 137.55,49.75 137.66,49.64 137.66,49.42 137.55,49.31 137.27,49.31 137.16,49.19 137.16,48.98 137.27,48.86 137.55,48.86 137.66,48.75 137.66,48.53 137.55,48.42 137.27,48.42 137.16,48.3 137.16,48 137.27,47.89 137.45,47.89 137.59,47.75 137.59,43.86 138.53,42.92 138.53,39.35 139.29,38.59 v1(139.29,37.93)
  BOTTOM w0.076: U9001.AT7 153.09,104.3 v1(153.42,104.62)
M_B_CKE3: length 89.3
  TOP w0.102: v1(139.29,34.51) 138.59,35.2 138.59,37.81 139.12,38.34 139.68,38.34 140.85,39.51 JDIM1003.110
  IN1 w0.076: v1(153.42,107.22) 152.97,106.77 152.97,106.47 152.88,106.39 152.88,105.21 152.72,105.05 152.72,104.22 152.18,103.67 152.18,96.83 151.56,96.21 151.56,91.09 151.37,90.91
  IN1 w0.114: 151.37,90.91 138.42,77.96 138.42,63.6 135.9,61.08 135.9,43.01 137.27,41.64 137.27,38.83 138.03,38.07 138.03,36.69 138.75,35.97 138.75,35.05 v1(139.29,34.51)
  BOTTOM w0.076: U9001.AT11 153.09,106.9 v1(153.42,107.22)
M_B_CLKN0: length 80.2
  IN1 w0.076: v1(156.16,105.92) 156.4,105.92 156.54,105.78 156.54,104.42 157.04,103.92 157.4,103.92 157.87,103.45 157.87,102.34 157.24,101.72 157.17,101.65 157.17,101.13 157.16,101.11 157.16,83.93 148.41,75.19 148.41,55.45 149.08,54.79 149.08,48.2 147.5,46.62 147.5,37.56 147.44,37.5 147.31,37.5 v1(147.1,37.71)
  BOTTOM w0.076: U9001.AN9 155.83,105.6 v1(156.16,105.92)
  BOTTOM w0.102: v1(147.1,37.71) 146.67,37.28 146.57,37.28 146.51,37.34 146.51,38.34 147.05,38.88 147.31,38.88 147.64,39.21 148.02,39.21 148.1,39.3 JDIM1002.139
M_B_CLKN1: length 81.8
  IN1 w0.076: v1(147.1,35.17) 147.28,35.36 147.51,35.36 147.71,35.55 147.71,36.54 148.34,37.18 148.34,46.27 150.3,48.23 150.3,54.9 149.52,55.67 149.52,75.11 157.99,83.58 157.99,93.78 157.87,93.91 157.87,101.09 157.84,101.12 157.84,101.58 158.4,102.14 158.4,103.61 157.56,104.46 157.56,104.67 157.43,104.8 157.43,104.83 157.07,105.19 v1(157.07,105.27)
  BOTTOM w0.076: U9001.AM8 156.75,104.95 v1(157.07,105.27)
  BOTTOM w0.102: JDIM1002.140 148.35,33.06 148.18,33.24 148.02,33.24 147.39,33.87 147.19,33.87 146.54,34.52 146.54,35.44 146.63,35.53 146.74,35.53 v1(147.1,35.17)
M_B_CLKN2: length 87.6
  TOP w0.102: JDIM1003.139 148.1,33 147.81,33.3 147.81,33.47 148.22,33.88 148.58,33.88 148.95,34.25 148.95,35.3 148.71,35.53 148.41,35.53 v1(148.16,35.78)
  IN1 w0.076: v1(157.07,106.57) 157.07,106.69 157.21,106.83 157.4,106.83 157.45,106.77 157.45,105.06 157.74,104.77 157.74,104.54 158.63,103.65 158.63,101.98 158.15,101.5 158.15,101.02 158.13,101 158.13,94.28 158.45,93.96 158.45,83.37 149.98,74.9 149.98,74.09 150.17,73.9 150.39,73.9 150.46,73.83 150.46,73.4 150.39,73.32 150.17,73.32 149.98,73.13 149.98,72.54 150.17,72.35 150.39,72.35 150.46,72.28 150.46,71.85 150.39,71.77 150.17,71.77 149.98,71.58 149.98,70.99 150.17,70.81 150.39,70.81 150.46,70.73 150.46,70.3 150.39,70.22 150.17,70.22 149.98,70.03 149.98,69.44 150.17,69.26 150.39,69.26 150.46,69.18 150.46,68.75 150.39,68.67 150.17,68.67 149.98,68.48 149.98,67.89 150.17,67.71 150.39,67.71 150.46,67.63 150.46,67.2 150.39,67.12 150.14,67.12 149.98,66.96 149.98,66.32 150.14,66.16 150.39,66.16 150.46,66.08 150.46,65.65 149.98,65.17 149.98,55.86 151.17,54.67 151.17,48.46 148.8,46.08 148.8,35.71 148.65,35.55 148.39,35.55 v1(148.16,35.78)
  BOTTOM w0.076: U9001.AM10 156.75,106.25 v1(157.07,106.57)
M_B_CLKN3: length 90.4
  TOP w0.102: v1(149.45,36.93) 149.45,36.87 149.16,36.58 148.99,36.58 148.52,37.06 148.52,38.08 148.06,38.55 148.06,39.16 148.35,39.46 JDIM1003.140
  IN1 w0.076: v1(158.9,107.22) 158.54,106.86 158.54,106.62 158.37,106.45 158.37,104.4 159.08,103.69 159.08,100.38 159.13,100.33 159.13,100.08 159.11,100.07 159.11,83.09 151.11,75.09 151.11,74.45 151.3,74.26 151.61,74.26 151.68,74.19 151.68,73.75 151.61,73.68 151.3,73.68 151.11,73.49 151.11,72.9 151.3,72.71 151.61,72.71 151.68,72.64 151.68,72.2 151.61,72.13 151.3,72.13 151.11,71.94 151.11,71.35 151.3,71.16 151.61,71.16 151.68,71.09 151.68,70.66 151.61,70.58 151.3,70.58 151.11,70.39 151.11,69.8 151.3,69.61 151.61,69.61 151.68,69.54 151.68,69.11 151.61,69.03 151.3,69.03 151.11,68.84 151.11,68.25 151.3,68.06 151.61,68.06 151.68,67.99 151.68,67.56 151.61,67.48 151.3,67.48 151.11,67.29 151.11,66.7 151.3,66.52 151.61,66.52 151.68,66.44 151.68,66.01 151.61,65.93 151.3,65.93 151.11,65.74 151.11,64.74 151.04,64.66 150.82,64.66 150.63,64.47 150.63,63.88 150.82,63.7 151.04,63.7 151.11,63.62 151.11,63.19 151.04,63.11 150.82,63.11 150.63,62.92 150.63,62.33 150.82,62.15 151.04,62.15 151.11,62.07 151.11,61.64 151.04,61.56 150.82,61.56 150.63,61.37 150.63,60.78 150.82,60.6 151.04,60.6 151.11,60.52 151.11,60.09 151.04,60.01 150.82,60.01 150.63,59.82 150.63,59.23 150.82,59.05 151.04,59.05 151.11,58.97 151.11,58.54 151.04,58.46 150.82,58.46 150.63,58.28 150.63,57.69 150.82,57.5 151.04,57.5 151.11,57.42 151.11,57.06 150.72,56.66 150.72,56.04 151.82,54.94 151.82,48.19 149.45,45.81 149.45,39.38 149.73,39.1 149.73,38.85 149.45,38.57 149.45,38.09 149.82,37.72 149.82,36.93 149.67,36.79 149.59,36.79 v1(149.45,36.93)
  BOTTOM w0.076: U9001.AJ11 158.58,106.9 v1(158.9,107.22)
M_B_CLKP0: length 80.2
  IN1 w0.076: v1(147.1,37.08) 147.33,37.31 147.52,37.31 147.69,37.48 147.69,46.54 149.27,48.12 149.27,54.86 148.6,55.53 148.6,75.11 157.35,83.85 157.35,101.13 157.32,101.15 157.32,101.58 157.35,101.61 158.02,102.28 158.02,103.51 157.46,104.07 157.11,104.07 156.7,104.48 156.7,105.55 v1(157.07,105.92)
  BOTTOM w0.076: v1(157.07,105.92) 156.75,105.6 U9001.AM9
  BOTTOM w0.102: v1(147.1,37.08) 146.48,37.08 146.31,37.25 146.31,38.43 146.97,39.08 147.23,39.08 147.6,39.46 JDIM1002.137
M_B_CLKP1: length 81.9
  IN1 w0.076: v1(147.1,35.81) 147.35,35.55 147.43,35.55 147.52,35.63 147.52,36.62 148.15,37.26 148.15,46.35 150.11,48.31 150.11,54.82 149.33,55.59 149.33,75.19 157.8,83.66 157.8,93.71 157.68,93.83 157.68,101.11 157.69,101.12 157.69,101.65 158.25,102.2 158.25,103.55 157.41,104.39 157.41,104.61 157.31,104.7 157.12,104.7 v1(157.07,104.65)
  BOTTOM w0.076: U9001.AM7 156.62,104.08 156.75,103.94 157,103.94 157.07,104.01 v1(157.07,104.65)
  BOTTOM w0.102: JDIM1002.138 147.85,33.12 147.3,33.67 147.1,33.67 146.34,34.44 146.34,35.52 146.55,35.74 147.03,35.74 v1(147.1,35.81)
M_B_CLKP2: length 87.6
  TOP w0.102: v1(148.16,35.15) 148.35,35.33 148.63,35.33 148.75,35.21 148.75,34.33 148.5,34.08 148.13,34.08 147.6,33.55 JDIM1003.137
  IN1 w0.076: v1(148.16,35.15) 148.38,35.36 148.73,35.36 148.99,35.63 148.99,46 151.37,48.38 151.37,54.75 150.17,55.94 150.17,65.09 150.65,65.57 150.65,66.16 150.47,66.35 150.22,66.35 150.17,66.4 150.17,66.88 150.22,66.93 150.47,66.93 150.65,67.12 150.65,67.71 150.47,67.9 150.25,67.9 150.17,67.97 150.17,68.4 150.25,68.48 150.47,68.48 150.65,68.67 150.65,69.26 150.47,69.45 150.25,69.45 150.17,69.52 150.17,69.95 150.25,70.03 150.47,70.03 150.65,70.22 150.65,70.81 150.47,71 150.25,71 150.17,71.07 150.17,71.5 150.25,71.58 150.47,71.58 150.65,71.77 150.65,72.36 150.47,72.54 150.25,72.54 150.17,72.62 150.17,73.05 150.25,73.13 150.47,73.13 150.65,73.32 150.65,73.91 150.47,74.09 150.25,74.09 150.17,74.17 150.17,74.82 158.64,83.29 158.64,94.04 158.32,94.36 158.32,101 158.31,101.02 158.31,101.44 158.78,101.91 158.78,103.72 157.89,104.61 157.89,104.83 157.6,105.12 157.6,106.83 157.46,106.98 157.32,106.98 v1(157.07,107.22)
  BOTTOM w0.076: U9001.AM11 156.75,106.9 v1(157.07,107.22)
M_B_CLKP3: length 90.4
  TOP w0.102: JDIM1003.138 147.85,38.46 148.32,38 148.32,36.97 148.91,36.38 149.36,36.38 v1(149.45,36.29)
  IN1 w0.076: v1(158.9,106.57) 158.71,106.57 158.52,106.39 158.52,104.46 159.23,103.75 159.23,100.44 159.28,100.39 159.28,100.13 159.3,100.12 159.3,83.01 151.3,75.01 151.3,74.53 151.38,74.45 151.69,74.45 151.87,74.27 151.87,73.68 151.69,73.49 151.38,73.49 151.3,73.41 151.3,72.98 151.38,72.9 151.69,72.9 151.87,72.72 151.87,72.13 151.69,71.94 151.38,71.94 151.3,71.86 151.3,71.43 151.38,71.35 151.69,71.35 151.87,71.17 151.87,70.58 151.69,70.39 151.38,70.39 151.3,70.31 151.3,69.88 151.38,69.8 151.69,69.8 151.87,69.62 151.87,69.03 151.69,68.84 151.38,68.84 151.3,68.76 151.3,68.33 151.38,68.26 151.69,68.26 151.87,68.07 151.87,67.48 151.69,67.29 151.38,67.29 151.3,67.21 151.3,66.78 151.38,66.71 151.69,66.71 151.87,66.52 151.87,65.93 151.69,65.74 151.38,65.74 151.3,65.66 151.3,64.66 151.11,64.47 150.9,64.47 150.82,64.39 150.82,63.96 150.9,63.89 151.11,63.89 151.3,63.7 151.3,63.11 151.11,62.92 150.9,62.92 150.82,62.84 150.82,62.41 150.9,62.34 151.11,62.34 151.3,62.15 151.3,61.56 151.11,61.37 150.9,61.37 150.82,61.3 150.82,60.86 150.9,60.79 151.11,60.79 151.3,60.6 151.3,60.01 151.11,59.82 150.9,59.82 150.82,59.75 150.82,59.31 150.9,59.24 151.11,59.24 151.3,59.05 151.3,58.46 151.11,58.27 150.9,58.27 150.82,58.2 150.82,57.76 150.9,57.69 151.11,57.69 151.3,57.5 151.3,56.98 150.91,56.58 150.91,56.12 152.01,55.02 152.01,48.11 149.64,45.73 149.64,39.46 149.92,39.18 149.92,38.78 149.64,38.5 149.64,38.16 150.01,37.8 150.01,36.85 v1(149.45,36.29)
  BOTTOM w0.076: U9001.AJ10 158.45,106.51 158.51,106.57 v1(158.9,106.57)
M_B_CS#0: length 85.1
  IN1 w0.076: v1(161.65,107.22) 161.2,106.77 161.2,106.46 161.11,106.38 161.11,105.1 160.96,104.95 160.96,104.36 161.19,104.14 161.19,100.51 160.86,100.19 160.86,90.56 160.94,90.48
  IN1 w0.114: v1(152.62,35.46) 152.62,35.77 152.86,36.01 153.22,36.01 154.09,36.88 154.09,44.43 156.37,46.71 156.37,48.29 158.33,50.26 158.33,54.55 156.48,56.41 156.48,72.79 157.14,73.45 157.14,75.11 163.36,81.33 163.36,88.06 160.94,90.48
  BOTTOM w0.076: v1(161.65,107.22) 161.32,106.9 U9001.AF11
  BOTTOM w0.102: JDIM1002.149 152.6,39.04 152.43,38.86 152.43,36.35 152.62,36.16 v1(152.62,35.46)
M_B_CS#1: length 83.6
  IN1 w0.076: v1(162.56,104.64) 162.56,104.12 162.41,103.96 162.41,101.09 162.8,100.7 162.8,96.08 163.02,95.85 163.02,95.46
  IN1 w0.114: v1(157,36.67) 157,41 160.32,44.33 160.32,48.14 161.87,49.69 161.87,57.08 161.51,57.44 161.51,64.1 161.38,64.23 160.69,64.23 160.48,64.43 160.48,65.04 160.81,65.37 160.81,67.75 160.59,67.97 160.3,67.97 160.19,68.09 160.19,68.35 160.3,68.47 160.7,68.47 160.81,68.58 160.81,68.85 160.7,68.96 160.3,68.96 160.19,69.08 160.19,69.34 160.3,69.46 160.7,69.46 160.81,69.57 160.81,69.84 160.7,69.95 160.3,69.95 160.19,70.07 160.19,70.33 160.3,70.45 160.59,70.45 160.81,70.68 160.81,71.82 160.19,72.44 160.19,74.06 166.26,80.13 166.26,88.85 163.02,92.08 163.02,95.46
  BOTTOM w0.076: v1(162.56,104.64) 162.22,104.3 U9001.AE7
  BOTTOM w0.102: v1(157,36.67) 157,37.05 154.6,39.45 JDIM1002.157
M_B_CS#2: length 87.7
  TOP w0.102: v1(152.62,34.19) 152.62,33.77 152.6,33.75 JDIM1003.149
  IN1 w0.076: v1(161.65,106.57) 161.26,106.19 161.26,105.02 161.11,104.87 161.11,104.43 161.36,104.17 161.36,104.07
  IN1 w0.114: v1(152.62,34.19) 153.07,34.64 153.07,35.26 154.51,36.7 154.51,43.35 155.89,44.73 155.89,45.64 156.79,46.54 156.79,48.12 158.75,50.08 158.75,54.72 156.9,56.58 156.9,67.73 157.01,67.85 157.44,67.85 157.56,67.96 157.56,68.23 157.44,68.34 156.98,68.34 156.9,68.43 156.9,68.75 156.98,68.84 157.44,68.84 157.56,68.95 157.56,69.22 157.44,69.33 157.01,69.33 156.9,69.45 156.9,69.71 157.01,69.83 157.44,69.83 157.56,69.94 157.56,70.21 157.44,70.32 157.01,70.32 156.9,70.44 156.9,70.7 157.01,70.82 157.44,70.82 157.56,70.93 157.56,71.2 157.44,71.31 157.01,71.31 156.9,71.43 156.9,71.69 157.01,71.81 157.44,71.81 157.56,71.92 157.56,72.19 157.44,72.3 157.06,72.3 156.97,72.39 156.97,72.68 157.56,73.27 157.56,74.93 163.78,81.15 163.78,88.41 161.63,90.56 161.63,100.12 161.36,100.39 161.36,104.07
  BOTTOM w0.076: U9001.AF10 161.32,106.25 v1(161.65,106.57)
M_B_CS#3: length 91.9
  TOP w0.102: v1(155.54,33.86) 155.4,33.86 154.6,33.07 JDIM1003.157
  IN1 w0.076: 163.74,95.62 163.74,95.98 163.2,96.51 163.2,100.95 162.71,101.44 162.71,103.84 162.92,104.05 162.92,104.25 163.09,104.42 163.09,104.88 162.94,105.04 162.94,106.08 162.56,106.46 v1(162.56,106.57)
  IN1 w0.114: v1(155.54,33.86) 156.69,35.01 157.2,35.01 157.84,35.65 157.84,39.78 161.6,43.55 161.6,48.24 163.15,49.79 163.15,54.01 162.73,54.43 162.73,56.86 163.15,57.28 163.15,61.09 162.59,61.65 162.59,66.22 162.21,66.6 161.84,66.6 161.73,66.71 161.73,66.98 161.84,67.1 162.26,67.1 162.37,67.21 162.37,67.48 162.26,67.59 161.84,67.59 161.73,67.71 161.73,67.97 161.84,68.09 162.26,68.09 162.37,68.2 162.37,68.47 162.26,68.58 161.84,68.58 161.73,68.7 161.73,68.96 161.84,69.08 162.26,69.08 162.37,69.19 162.37,69.46 162.26,69.57 161.84,69.57 161.73,69.69 161.73,69.95 161.84,70.07 162.26,70.07 162.37,70.18 162.37,70.45 162.26,70.56 161.84,70.56 161.73,70.68 161.73,70.94 161.84,71.06 162.26,71.06 162.37,71.17 162.37,71.44 162.26,71.55 161.84,71.55 161.73,71.67 161.73,71.93 161.84,72.05 162.26,72.05 162.37,72.16 162.37,72.43 162.26,72.54 161.84,72.54 161.73,72.66 161.73,72.92 161.84,73.04 162.26,73.04 162.37,73.15 162.37,73.42 162.26,73.53 161.84,73.53 161.73,73.65 161.73,73.92 161.84,74.03 162.26,74.03 162.37,74.14 162.37,75.06 167.09,79.78 167.09,88.9 163.74,92.26 163.74,95.62
  BOTTOM w0.076: v1(162.56,106.57) 162.23,106.25 U9001.AE10
M_B_DQ0: length 101
  TOP w0.102: JDIM1003.3 114.1,33 113.47,33.64 113.47,35.07 113.67,35.27 113.67,35.67 113.81,35.8 113.81,36.36 v1(114.19,36.74)
  IN1 w0.102: v1(114.19,36.74) 114.19,36.82 110.83,40.18 110.83,48.46 108.81,50.47 108.81,54.88 110.5,56.57 110.5,62.08 115.69,67.27 115.69,67.49 115.37,67.8 115.37,68.08 115.45,68.16 115.64,68.16 115.71,68.23 115.71,68.51 115.64,68.59 115.48,68.59 115.37,68.69 115.37,68.92 115.48,69.02 115.61,69.02 115.71,69.12 115.71,69.35 115.61,69.45 115.48,69.45 115.37,69.55 115.37,69.78 115.48,69.88 115.61,69.88 115.71,69.98 115.71,70.21 115.61,70.31 115.45,70.31 115.37,70.39 115.37,70.67 115.45,70.75 115.61,70.75 115.71,70.85 115.71,71.08 115.61,71.18 115.45,71.18 115.37,71.25 115.37,71.53 115.45,71.61 115.61,71.61 115.71,71.71 115.71,71.94 115.61,72.04 115.48,72.04 115.37,72.14 115.37,72.37 115.48,72.47 115.61,72.47 115.71,72.57 115.71,80.02 116.41,80.72 116.41,84.48 119.2,87.26 119.35,87.26 119.41,87.2 119.56,87.2 119.72,87.36 119.72,87.5 119.65,87.57 119.65,87.71 119.81,87.87 119.96,87.87 120.02,87.81 120.17,87.81 120.33,87.97 120.33,88.11 120.26,88.18 120.26,88.32 120.42,88.48 120.57,88.48 120.63,88.42 120.78,88.42 120.94,88.58 120.94,88.72 120.87,88.79 120.87,88.93 121.16,89.22 121.16,95.11 128.17,102.12 130.13,102.12 134.83,106.83 v1(137.28,106.83)
  BOTTOM w0.076: U9001.BT11 137.29,106.84 v1(137.28,106.83)
  BOTTOM w0.102: v1(114.19,36.74) 114.19,37.32 113.7,37.81 113.7,38.32 114.1,38.73 JDIM1002.3
M_B_DQ1: length 102.8
  TOP w0.102: v1(114.21,34.84) 114.66,35.29 114.66,37.78 114.35,38.09 JDIM1003.4
  IN1 w0.102: v1(114.21,34.84) 114.59,35.22 114.59,36.88 111.16,40.32 111.16,48.6 109.14,50.61 109.14,54.75 110.83,56.43 110.83,61.94 113.6,64.71 114.18,64.71 114.34,64.87 114.34,65.02 114.19,65.16 114.19,65.31 114.36,65.47 114.5,65.47 114.65,65.32 114.79,65.32 115.03,65.56 115.03,65.89 115.4,66.26 115.73,66.26 116.04,66.57 116.04,79.88 116.75,80.59 116.75,84.34 119.17,86.76 119.59,86.76 121.49,88.66 121.49,94.97 128.36,101.84 130.31,101.84 134.84,106.38 v1(135.51,106.38)
  BOTTOM w0.076: U9001.BR11 139.42,106.71 139.07,106.36 137.59,106.36 137.06,105.83 136.06,105.83 135.97,105.92
  BOTTOM w0.102: v1(114.21,34.84) 113.99,35.07 113.24,35.07 113.06,34.89 113.06,34.38 114.35,33.09 JDIM1002.4
  BOTTOM w0.165: 135.97,105.92 v1(135.51,106.38)
M_B_DQ2: length 102.1
  TOP w0.102: v1(117.09,34.57) 117.51,34.99 117.51,35.69 117.63,35.82 117.86,35.82 117.99,35.69 117.99,34.38 117.86,34.25 117.38,34.25 117.25,34.13 117.25,33.95 117.38,33.82 118.75,33.82 118.88,33.69 118.88,33.44 118.6,33.16 JDIM1003.21
  IN1 w0.102: v1(138.08,105.98) 137.75,105.98 137.32,105.55 136.68,105.55 136.12,104.99 135.48,104.99 131.1,100.6 129.31,100.6 123.04,94.33 123.04,88.02 118.29,83.27 118.29,79.83 117.59,79.13 117.59,65.93 112.66,61 112.66,56.07 110.69,54.1 110.69,51.25 112.71,49.24 112.71,40.96 116.36,37.31 116.36,35.3 v1(117.09,34.57)
  BOTTOM w0.076: U9001.BT9 138.15,106.05 v1(138.08,105.98)
  BOTTOM w0.102: JDIM1002.21 118.6,39.42 117.89,38.7 117.89,35.37 v1(117.09,34.57)
M_B_DQ3: length 101.8
  TOP w0.102: v1(117.09,37.11) 116.3,37.11 115.7,37.71 115.7,38.01 115.88,38.19 116.14,38.19 116.71,37.62 116.93,37.62 117.08,37.77 117.08,37.93 116.76,38.26 116.76,38.58 117.35,39.18 JDIM1003.16
  IN1 w0.102: v1(117.09,37.11) 117.09,37.51 113.37,41.24 113.37,49.58 111.35,51.6 111.35,53.83 111.59,54.06 111.73,54.06 112.05,53.74 112.23,53.74 112.36,53.87 112.36,54.05 112.04,54.37 112.04,54.51 112.2,54.68 112.34,54.68 112.71,54.3 112.89,54.3 113.02,54.43 113.02,54.61 112.65,54.98 112.65,55.13 113.32,55.79 113.32,60.72 118.25,65.66 118.25,76.51 118.95,77.21 118.95,77.56 118.88,77.64 118.35,77.64 118.25,77.74 118.25,77.97 118.35,78.07 118.85,78.07 118.95,78.17 118.95,78.4 118.85,78.5 118.35,78.5 118.25,78.61 118.25,78.83 118.35,78.94 118.75,78.94 118.95,79.14 118.95,83 123.7,87.74 123.7,94.05 129.69,100.04 132.1,100.04 135.95,103.89 v1(135.95,104.35)
  BOTTOM w0.076: 135.97,104.35 137.04,104.35 137.14,104.45 137.77,104.45 138.64,105.33 138.89,105.33 138.95,105.26 U9001.BR8
  BOTTOM w0.102: v1(117.09,37.11) 116.68,36.71 116.68,33.93 117.35,33.26 JDIM1002.16
  BOTTOM w0.165: 135.97,104.35 v1(135.95,104.35)
M_B_DQ4: length 102.7
  TOP w0.102: JDIM1003.8 115.35,35.34 v1(115.8,34.89)
  IN1 w0.102: v1(136.16,106.39) 135.72,105.95 134.85,105.95 130.46,101.56 128.55,101.56 121.82,94.83 121.82,88.53 119.73,86.43 119.3,86.43 117.08,84.2 117.08,80.45 116.37,79.75 116.37,66.44 114.16,64.22 113.58,64.22 111.16,61.8 111.16,60.16 111.41,59.91 111.41,59.53 111.16,59.27 111.16,56.29 109.47,54.61 109.47,50.75 111.49,48.73 111.49,40.46 114.92,37.02 114.92,35.07 115.1,34.89 v1(115.8,34.89)
  BOTTOM w0.076: v1(136.16,106.39) 136.53,106.02 137.03,106.02 137.55,106.54 138.86,106.54 139.1,106.77 139.1,106.9 139.3,107.1 139.8,107.1 U9001.BP11
  BOTTOM w0.102: v1(115.8,34.89) 115.35,35.35 115.14,35.35 114.84,35.04 114.84,34.25 115.35,33.74 JDIM1002.8
M_B_DQ5: length 104
  TOP w0.102: v1(114.21,35.47) 113.67,34.93 113.67,33.72 114,33.39 114.48,33.39 114.66,33.57 114.66,34.21 114.79,34.34 114.98,34.34 115.1,34.21 JDIM1003.7
  IN1 w0.102: v1(114.21,35.47) 113.81,35.88 113.81,36.74 110.5,40.05 110.5,48.32 108.48,50.34 108.48,55.02 110.17,56.7 110.17,62.21 115.04,67.09 115.04,72.51 115.38,72.85 115.38,80.16 116.08,80.86 116.08,84.61 120.83,89.36 120.83,95.24 127.99,102.4 129.95,102.4 134.83,107.27 v1(137.73,107.27)
  BOTTOM w0.076: v1(137.73,107.27) 140.28,107.27 U9001.BN11
  BOTTOM w0.102: v1(114.21,35.47) 114.64,35.9 114.64,38.63 115.1,39.09 JDIM1002.7
M_B_DQ6: length 101.4
  TOP w0.102: v1(117.09,35.84) 116.89,35.84 116.68,35.64 116.68,33.88 116.99,33.58 118.2,33.58 118.29,33.48 118.29,33.31 118.2,33.21 117.76,33.21 117.6,33.06 JDIM1003.17
  IN1 w0.102: v1(117.09,35.84) 116.91,35.84 116.69,36.06 116.69,37.44 113.04,41.1 113.04,49.45 111.02,51.46 111.02,53.97 112.99,55.93 112.99,60.86 117.92,65.79 117.92,78.99 118.62,79.69 118.62,83.14 123.37,87.88 123.37,94.19 129.5,100.32 131.27,100.32 131.56,100.61 131.76,100.61 131.91,100.46 132.04,100.46 132.23,100.65 132.23,100.78 132.05,100.96 132.05,101.08 132.26,101.28 132.38,101.28 132.56,101.1 132.69,101.1 132.88,101.29 132.88,101.42 132.7,101.6 132.7,101.72 132.88,101.9 133.05,101.9 133.21,101.75 133.33,101.75 133.53,101.94 133.53,102.07 133.35,102.25 133.35,102.37 133.55,102.57 133.7,102.57 133.87,102.4 133.97,102.4 134.17,102.6 134.17,102.72 133.99,102.9 133.99,103.02 134.2,103.22 134.32,103.22 134.49,103.05 134.62,103.05 134.81,103.25 134.81,103.37 134.64,103.54 134.64,103.71 135.66,104.73 v1(136.48,104.73)
  BOTTOM w0.076: v1(136.48,104.73) 137.7,104.73 138.52,105.55 139.57,105.55 139.86,105.26 U9001.BP8
  BOTTOM w0.102: JDIM1002.17 117.6,36.36 v1(117.09,35.84)
M_B_DQ7: length 102.7
  TOP w0.102: v1(118.68,34.38) 118.26,34.8 118.26,35.79 117.87,36.18 117.87,38.47 118.35,38.95 JDIM1003.20
  IN1 w0.102: v1(118.68,34.38) 117.49,35.58 117.49,37.58 113.7,41.37 113.7,47.59 113.98,47.87 113.98,49.44 113.05,50.37 113.05,50.88 113.81,51.63 113.81,53.84 113.43,54.21 113.43,55.44 113.64,55.65 113.65,55.65 113.65,60.58 118.58,65.52 118.58,72.91 118.68,73.02 118.84,73.02 118.94,73.12 118.94,73.35 118.84,73.45 118.68,73.45 118.58,73.55 118.58,73.78 118.68,73.88 118.84,73.88 118.94,73.98 118.94,74.21 118.84,74.31 118.68,74.31 118.58,74.41 118.58,74.64 118.68,74.74 118.84,74.74 118.94,74.84 118.94,75.07 118.84,75.17 118.68,75.17 118.58,75.28 118.58,75.5 118.68,75.61 118.84,75.61 118.94,75.71 118.94,75.94 118.84,76.04 118.68,76.04 118.58,76.14 118.58,76.37 118.68,76.47 118.96,76.47 119.29,76.8 119.29,82.86 124.03,87.61 124.03,93.92 129.87,99.76 132.29,99.76 137.7,105.17 v1(137.7,105.38)
  BOTTOM w0.076: v1(137.7,105.38) 138.04,105.38 138.42,105.76 139.62,105.76 139.82,105.55 140.42,105.55 U9001.BN8
  BOTTOM w0.102: JDIM1002.20 118.35,33.11 118.46,33.22 118.9,33.22 119.02,33.35 119.02,33.63 118.91,33.75 117.58,33.75 117.46,33.87 117.46,34.1 117.61,34.25 118.55,34.25 v1(118.68,34.38)

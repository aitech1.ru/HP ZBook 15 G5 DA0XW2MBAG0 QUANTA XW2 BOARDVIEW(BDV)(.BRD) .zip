# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NB679A_BST: length 2.4
  TOP w0.508: v1(196.47,40.12) PR13000.1 v4(197.87,39.08)
NB679A_EN: length 3.5
  BOTTOM w0.254: PU13000.11 200.05,40.84 200.25,41.04 200.25,41.55 PC13014.2 PR13006.2
NB679A_LP#: length 5.2
  TOP w0.254: PR13002.1 PR13005.2 202.28,42.2 v1(202.34,42.13)
  BOTTOM w0.254: v1(202.34,42.13) 202.34,41.85 201.99,41.49 201.33,41.49 v1(200.82,40.98) 200.82,40.6 200.55,40.34 PU13000.12
NB679A_PG: length 2.5
  BOTTOM w0.254: PU13000.3 200.55,36.3 200.98,35.87 PR13007.2 201.17,35.63 201.35,35.8 v1(201.35,36.44)
NB679A_SW: length 4.1
  TOP w0.508: v1(192.79,36.79) PC13006.2 192.8,38.14 v4(194.34,38.14) 194.93,37.56 PR13003.2
NB679A_VCC: length 1.9
  BOTTOM w0.254: PU13000.9 199.05,40.44 198.91,40.59 PC13007.1
NB679A_VOUT: length 18.5
  TOP w0.254: v1(190.58,42.61) 190.58,40.53 191.5,39.62 191.5,35.57 192.31,34.76 198.15,34.76 198.89,35.5 v1(199.55,35.5)
  BOTTOM w0.203: PR13004.1 190.43,42.45 v1(190.58,42.61)
  BOTTOM w0.254: PU13000.5 199.55,35.5 v1(199.55,35.5)
NB680A_AGND: length 2.4
  BOTTOM w0.254: PU13001.10 218.59,41.23 PC13021.2
  BOTTOM w0.508: PC13021.2 PR13008.2
NB680A_BST: length 1.8
  BOTTOM w0.508: 219.69,42.43 v1(220.19,41.94) 220.38,41.75 PR13009.1
NB680A_EN: length 3.6
  BOTTOM w0.254: PU13001.11 218.1,41.7 217.71,41.32 PC13029.2 PR13014.1 216.69,41.57 v1(216.8,41.67)
NB680A_LP#: length 4.9
  BOTTOM w0.203: v1(214.66,41.67) PR13010.1
  BOTTOM w0.254: PR13010.1 PR13013.2 215.68,41.25 216.59,42.17 217,42.17 217.17,42 217.46,42 217.59,42.14 PU13001.12
NB680A_PG: length 2.2
  BOTTOM w0.254: PU13001.3 217.59,45.67 217.38,45.89 v1(216.8,45.89) 216.8,46.25 PR13015.2
NB680A_SW: length 1.6
  TOP w0.508: PR13011.2 219.04,43.94 v1(219.82,44.72)
  vias: v1(220.5,45.05)
NB680A_VCC: length 1.5
  BOTTOM w0.254: PU13001.9 219.1,41.89 219.5,41.48 PC13021.1
NB680A_VOUT: length 14.1
  IN4 w0.254: v1(218.85,46.7) 219.01,46.85 220.81,46.85 221.46,47.5 221.46,49.94 223.17,51.65 v1(223.17,55.08)
  BOTTOM w0.254: PU13001.5 218.59,46.44 v1(218.85,46.7) ; v1(223.17,55.08) 222.92,54.83 PR13012.1
NB681_3.3_1.8: length 3.8
  TOP w0.114: PR16000.2 290.69,16.77 v1(290.48,16.98)
  TOP w0.254: PR16000.2 291.01,16.14 291.26,15.9 PC16000.1 292.17,15.9 292.64,16.37 PU16000.10
NB681_3.3_2.5: length 4.6
  BOTTOM w0.114: v1(205.26,33.11) 205.65,32.73 205.65,31.93 PC15000.2
  BOTTOM w0.254: PU15000.10 205.91,30.62 205.9,30.63
  BOTTOM w0.381: 205.9,30.63 205.9,31.01 206.14,31.26 PC15000.2 205.15,31.43 PR15000.2
NB681BST_1.8: length 1.2
  TOP w0.114: v1(292.21,16.7) 292.81,17.3 PR16004.2
NB681BST_2.5:
  vias: v1(204.88,29.81)
NB681BST_S_1.8: length 1.1
  TOP w0.114: 291.57,19.1 290.57,19.1 v1(290.48,19.01)
NB681BST_S_2.5: length 2.5
  BOTTOM w0.508: v1(202.34,31.79) PC15006.1 202.8,30.93 203.01,31.14 PR15003.1
NB681EN_1.8: length 3.9
  TOP w0.114: PR16013.2 v1(299.63,14.88)
  TOP w0.254: PC16012.2 297.72,14.88 296.73,15.87 PU16000.5
  TOP w0.381: PC16012.2 PR16013.2
NB681EN_2.5: length 5
  BOTTOM w0.254: PR15002.2 v1(206.8,23.36) PC15007.2 206.02,25.1 PR15004.2 206.02,25.96 206.41,26.35 PU15000.5
NB681FB_1.8: length 16
  TOP w0.254: PU16000.12 292.78,15.37 291.98,14.57 289.21,14.57 v1(289.08,14.44) ; PR16006.1 v1(290.48,24.73)
  IN4 w0.254: v1(290.48,24.73) 290.48,20.64 289.85,20 289.85,15.2 v1(289.08,14.44)
NB681FB_2.5: length 18
  TOP w0.254: v1(206.94,30.72) 206.92,30.72 203.88,33.76 201.67,33.76 201.03,34.39 192.58,34.39 192.18,34 v1(192.18,34.03)
  BOTTOM w0.254: v1(206.94,30.72) 206.91,30.69 PU15000.12 ; v1(192.18,34.03) 192.08,33.92 PR15006.1
NB681PG_1.8: length 2.4
  TOP w0.254: PR16014.2 292.01,13.98 292.08,14.06 v1(292.64,14.06) 292.64,14.65 292.87,14.87 PU16000.13
NB681PG_2.5: length 2.1
  BOTTOM w0.254: PR15012.2 208.21,31.14 v1(208.21,30.57) 208.02,30.38 207.61,30.38 207.41,30.18 PU15000.13
NB681SW_1.8: length 2.1
  TOP w0.114: 291.57,20.3 290.59,20.3 v1(290.48,20.41)
  BOTTOM w0.508: PR16005.2 v1(294.18,17.89)
NB681SW_2.5: length 0.9
  TOP w0.508: PR15005.2 203.12,29.08 v1(202.98,29.22)
  vias: v1(202.34,28.28)
NB685BST:
  vias: v1(101.45,62.4)
NB685EN1: length 7
  TOP w0.178: PU14000.16 99.76,64.84 99.98,65.06 99.98,67.55 v1(100.36,67.93) 100.74,68.32 100.74,69.31 PC14017.2
  TOP w0.254: PR14007.2 PC14017.2
NB685EN2: length 5.4
  TOP w0.178: PU14000.15 99.77,64.34 99.93,64.51 99.93,64.6 100.44,65.11 v1(100.44,66.64) 100.44,66.98 PC14018.2
  TOP w0.254: PR14009.2 PC14018.2
NB685FB1: length 27.1
  TOP w0.254: PR14011.2 PC14019.2 v1(103.03,65.75) 104.5,65.75 105.62,64.63 105.62,60.09 104.88,59.35 104.88,46.01 104.43,45.56 102.85,45.56 102.72,45.69 PR14006.1
NB685PG: length 4.3
  TOP w0.114: v1(102.9,64.45) 102.67,64.23 101.51,64.23 101.24,63.96 PR14010.2
  TOP w0.254: PU14000.12 100.37,62.84 PR14010.2
NB685SW: length 1.5
  BOTTOM w0.508: PR14004.2 98.33,62.15 97.82,61.64 v4(97.82,61.18)
  vias: v1(99.73,60.92)
NB685VTTREF: length 4.7
  TOP w0.114: PR14005.2 95.28,61.3 95.54,61.05 v1(96.43,61.05)
  TOP w0.254: PU14000.7 96.06,62.84 95.54,62.32 95.28,62.32
  TOP w0.305: 95.28,62.32 PC14015.1 PR14005.2
NCTF_CPU_A3: length 6.9
  BOTTOM w0.079: 179.39,101.02 U9001.A3
  BOTTOM w0.114: TP9052.1 184.18,99.63 184.16,99.63 183.97,99.82 180.28,99.82 179.39,100.71 179.39,101.02
NCTF_CPU_B2: length 5.7
  BOTTOM w0.079: 178.76,101.02 U9001.B2
  BOTTOM w0.114: TP9051.1 183.24,99.15 180.12,99.15 178.76,100.51 178.76,101.02
NCTF_CPU_BP1: length 6.5
  BOTTOM w0.076: U9001.BP1 140.06,100.38 139.58,99.91 139.52,99.91 138.73,99.12 138.46,99.12 138.11,98.77 135.67,98.77 134.91,99.53 TP9053.1
NCTF_CPU_BR38: length 12.1
  IN1 w0.076: v1(129.19,129) 129.19,129.04 129.59,129.44 136.93,129.44 v1(138.93,127.44)
  BOTTOM w0.114: TP9054.1 v1(129.19,129)
  BOTTOM w0.254: U9001.BR38 v1(138.93,127.44)
NCTF_CPU_BT37: length 11.5
  IN1 w0.076: v1(138.34,126.85) 138.34,127.72 136.77,129.29 130.12,129.29 v1(129.83,129)
  BOTTOM w0.114: TP9055.1 v1(129.83,129)
  BOTTOM w0.254: v1(138.34,126.85) U9001.BT37
NCTF_CPU_C1: length 4.1
  BOTTOM w0.114: U9001.C1 178.13,98.89 177.71,98.47 TP9050.1
NCTF_PCH_A2: length 7.7
  BOTTOM w0.114: TP9056.1 229.24,68.95 230,68.95 231.35,67.6 235.04,67.6 U9002.A2
NCTF_PCH_A3: length 6.7
  BOTTOM w0.114: TP9057.1 230.05,68.5 231.18,67.37 235.52,67.37 U9002.A3
NCTF_PCH_A46: length 7.7
  BOTTOM w0.114: U9002.A46 250.6,52.16 250.6,51.11 250.6,51.11 250.6,50.69 251.16,50.14 251.83,50.14 252.3,49.66 252.3,47.13 TP9058.1
NCTF_PCH_A47: length 7.3
  BOTTOM w0.114: TP9059.1 252.76,49.53 251.89,50.4 251.27,50.4 250.83,50.85 250.83,51.88 251.08,52.13 251.27,52.13
NCTF_PCH_BF1: length 5.9
  BOTTOM w0.102: 250.12,86.43 250.12,85.97 250.53,85.56
  BOTTOM w0.114: U9002.BF1 250.53,84.37 250.53,85.56 ; 250.12,86.43 250.12,86.81 249.71,87.21 249.71,88.61 249.33,88.99 TP9060.1
NCTF_PCH_BF49: length 1.7
  TOP w0.114: v1(268.3,67.21) 267.94,67.21 TP9061.1
  BOTTOM w0.254: U9002.BF49 268.24,67.27 v1(268.3,67.21)
NCTF_PCH_BG2: length 6.8
  BOTTOM w0.114: U9002.BG2 251.37,83.98 250.76,84.6 250.76,85.92 250.35,86.32 250.35,86.91 249.97,87.29 249.97,88.77 249.92,88.81 249.92,89.58 TP9062.1
NCTF_TBT_A1: length 4
  BOTTOM w0.114: TP8006.1 349.66,122.75 350.22,122.19 U8001.A1
NCTF_TBT_A23: length 6.6
  BOTTOM w0.114: TP8005.1 340.72,125.36 340.72,122.89 340.49,122.66 340.49,121.39 340.1,121 U8001.A23
NCTF_TBT_AC1: length 4.5
  BOTTOM w0.102: U8001.AC1 350.22,108.91 350.28,108.85 350.28,108.51 350.27,108.51 350.27,107.94 349.99,107.66 349.92,107.66 349.68,107.42 349.68,106.9
  BOTTOM w0.114: TP8008.1 351.11,106.09 350.83,106.36 350.22,106.36 349.68,106.9
NCTF_TBT_AC23: length 3.2
  BOTTOM w0.102: 339.78,107.63 339.78,109.03 339.94,109.19 U8001.AC23
  BOTTOM w0.114: 339.78,107.63 340.27,107.15 TP8007.1
NFC_DWL_REQ: length 99.4
  TOP w0.114: R9509.1 260.55,6.02 v1(260.69,5.88)
  IN2 w0.089: v1(245.45,37.12) 245.87,37.53 246.43,37.53 247,38.11 247,38.59 248.58,40.17 248.58,41.5 249.97,42.89 250.69,42.89 252.23,44.43 252.23,46.78 254.23,48.78 254.23,51 254.83,51.6 256.39,51.6 264.74,59.94 264.74,64.48 265.77,65.51 265.77,65.95 266.39,66.58 266.39,67.56 265.27,68.69 264.98,68.69 260.47,73.21 v1(258.36,73.21)
  BOTTOM w0.114: v1(245.45,37.12) 246.25,36.32 248.25,36.32 250.51,34.06 250.51,33.43 253.21,30.73 253.21,28.1 255.18,26.14 255.18,24.57 257.17,22.57 257.17,18.54 258.4,17.31 258.4,15.94 260.74,13.6 263,13.6 263.56,13.04 263.56,11.43 264.47,10.51 264.47,7 264.12,6.64 261.58,6.64 v1(260.69,5.88) 259.93,6.77 CON9500.5 ; v1(258.36,73.21) 258.36,73.59 U9002.BB26
NFC_INT: length 96.3
  TOP w0.114: v1(260.35,65.23) 260.15,65.03 260.15,64.72 261.63,63.23 R9253.1 261.63,62.04 262.38,61.28 R9543.1
  IN2 w0.089: v1(260.35,65.23) 260.35,64.69 261.32,63.71 261.32,62.56 260.69,61.93 259.36,61.93 256.87,59.45 256.87,57.86 252.57,53.56 251.49,53.56 251.37,53.68 250.14,53.68 248.57,52.12 248.57,49.79 246.53,47.75 246.53,45.37 245.53,44.37 245.53,42.52 245.02,42 245.02,41.37 244.3,40.65 v1(244.3,39.79)
  BOTTOM w0.114: v1(260.35,65.23) 259.89,65.69 U9002.AN40 ; CON9500.11 256.93,6.75 257.46,6.21 257.46,5.55 257.92,5.09 261.31,5.09 262.64,6.42 264.22,6.42 264.7,6.9 264.7,10.61 263.81,11.5 263.81,13.12 263.1,13.83 260.84,13.83 258.65,16.02 258.65,17.5 257.42,18.73 257.42,22.64 255.4,24.66 255.4,26.23 253.47,28.16 253.47,30.79 250.85,33.41 250.74,33.53 250.74,34.15 248.3,36.6 246.69,36.6 244.36,38.92 244.36,39.73 v1(244.3,39.79)
NFC_MOD_DET: length 101.1
  IN2 w0.089: v3(246.21,32.12) 246.26,32.17 246.26,33.16 246.51,33.42 246.51,33.97 247.3,34.76 248.37,34.76 249.93,36.32 249.93,36.62 249.94,36.63 249.94,36.64 253.52,40.22 254.31,40.22 254.54,40.45 255.86,40.45 256.93,41.52 256.93,43.96 258.58,45.61 258.58,47.39 259.82,48.63 259.82,51.48 261.32,52.97 261.32,53.13 268.43,60.24 268.43,65.29 267.72,66 267.72,68.04 265.31,70.45 265.31,71.59 263.13,73.78 v3(263.13,74.51)
  BOTTOM w0.102: 264.61,74.86 264.55,74.81 263.39,74.81 263.13,74.54 v3(263.13,74.51) 263.13,74.49 262.64,74 262.45,74 261.77,73.33 261.77,73.01 261.53,72.77 261.48,72.77 261.4,72.68 U9002.BE32
  BOTTOM w0.114: v3(246.21,32.12) 246.89,32.12 250.73,28.28 250.73,27.8 251.62,26.91 251.62,26.23 253.09,24.75 v1(253.4,24.75) 254.64,24.75 256.9,22.49 256.9,18.43 257.98,17.35 R9383.1 257.98,16.03 260.97,13.04 262.19,13.04 262.57,12.66 262.92,12.66 263.3,12.28 263.3,11.34 264.24,10.4 264.24,7.09 264.03,6.88 262.26,6.88 261.93,7.21 CON9500.1 ; R9103.1 266.51,76.14 266.1,75.73 265.48,75.73 264.61,74.86
NFC_RST#: length 159.7
  TOP w0.114: v1(302.18,27.78) 302.55,28.14 302.55,29.35 305.72,32.53 305.72,35.14 306.61,36.03 306.61,39.62 311.13,44.15 311.13,47.25 311.99,48.11 311.99,52.33 312.74,53.08 312.74,56.37 311.94,57.16 v1(311.94,58.85) ; R9370.1 297.33,58.14 297.54,57.93 298.43,57.93 298.71,57.65 v1(300.26,57.65)
  IN1 w0.076: v1(302.18,27.78) 301.29,26.89 290.37,26.89 289.25,25.77 286.82,25.77 286.4,25.34 286.4,24.88 280.03,18.51 280.03,16.51 271.99,8.47 263.43,8.47 262.67,7.71 260.34,7.71 259.43,8.63 v1(259.43,8.65)
  IN2 w0.089: v3(268.06,80.27) 268.06,79.43 271.46,76.04 271.68,76.04 272.77,74.94 273.86,74.94 275.59,73.21 275.9,73.21 277.04,72.07 278.04,72.07 282.12,67.98 282.12,67.36 283.41,66.08 285.79,66.08 290.13,61.74 290.13,61.29 291.29,60.12 292.73,60.12 293.88,58.97 294.14,58.97 294.98,58.12 299.78,58.12 v1(300.26,57.65) 300.29,57.62 302.17,57.62 302.67,58.13 311.31,58.13 311.94,58.76 v1(311.94,58.85)
  BOTTOM w0.102: U9002.BE30 260.35,73.36 260.46,73.47 260.46,73.67 260.74,73.95 260.88,73.95 261.13,74.2 261.21,74.2 261.7,74.7 261.7,75.39 262.65,76.34 263.06,76.34 264.61,77.89
  BOTTOM w0.114: v3(268.06,80.27) 268.07,80.27 267.43,80.27 265.44,78.28 R9248.1 265.23,77.67 265,77.89 264.61,77.89 ; v1(259.43,8.65) CON9500.6
NFC_SML0_CLK: length 3.9
  BOTTOM w0.114: CON9500.8 258.43,8.57 R9506.1 258.98,9.28 258.64,9.62 258.64,10.25 259.16,10.77 v1(259.16,10.86)
NFC_SML0_DATA: length 1.5
  BOTTOM w0.114: CON9500.9 257.93,8.78 258.1,8.95 R9505.1
NFC_SWP: length 5.3
  BOTTOM w0.114: CON9500.13 255.93,6.95 255.55,6.57 252.05,6.57 TP9500.1
NGFF_RESET#_R: length 6.1
  BOTTOM w0.114: C4215.1 346.05,6.33 v1(346.51,6.8) ; R4211.1 348.96,5.92 348.63,6.26 348.22,6.26 348.15,6.32 R4225.1 346.99,6.32 v1(346.51,6.8) ; v1(346.51,6.8) 347.07,7.36 347.07,7.69 347.25,7.86 CON4201.67
NIC_SMCLK: length 421.3
  TOP w0.114: v1(258.4,88.74) 258.38,88.74 257.82,89.3 253.83,89.3 253.5,88.97 253.5,88 252.89,87.39 252.46,87.39 252.13,87.05 252.13,85.84 251.72,85.43 250.35,85.43 249.98,85.81 249.25,85.81 248.66,86.4 248.34,86.4 247.3,87.44 245.96,87.44 245.3,86.78 243.91,86.78 242.35,85.22 232.96,85.22 231.54,83.81 230.76,83.81 229.91,82.96 229.27,82.96 228.19,81.88 228.19,79.69 226.98,78.48 226.98,70.07 227.06,70 v1(227.06,69.33) ; R4023.1 29.65,124.93 v1(29.98,125.26) ; v1(227.01,34.11) 227.01,33.52 226.58,33.1 223.96,33.1 222.49,31.63 222.49,30.65 220.77,28.94 220.5,28.94 220.5,28.94 219.93,28.94 211.31,20.32 204.96,20.32 199.9,15.26 v1(199.9,14.98)
  IN1 w0.076: v1(199.9,14.98) 199,14.98 197.47,16.51 182.93,16.51 177.13,10.71 112.54,10.71 106.9,16.35 105.06,16.35 103.79,17.62 102.83,17.62 101.22,19.23 100.68,19.23 99.95,19.96 99.95,24.74 100.73,25.52 100.73,29.94 99.1,31.56 99.1,39.86 94.68,44.29 93.9,44.29 93.12,45.06 93.12,45.75 88.89,49.99 74.51,49.99 72.98,48.47 69.77,48.47 69.03,49.21 66.67,49.21 65.72,48.26 60.87,48.26 59.73,49.4 57.55,49.4 56.51,50.45 53.7,50.45 53.45,50.7 53.45,51.12 53.6,51.27 53.6,54.56 52.9,55.26 52.9,56.75 54.26,58.1 54.26,59.07 49.49,63.84 43.49,63.84 40.67,66.67 39.44,66.67 37.41,68.7 37.41,70.96 35.52,72.85 35.52,76.25 33.99,77.77 33.99,79.42 29.19,84.22 29.19,91.78 27.08,93.89 27.08,99.46 26.85,99.68 26.85,103.75 26.32,104.28 26.32,111.47 25.57,112.22 25.57,117.71 27.34,119.47 27.34,121.5 29.12,123.28 30.77,123.28 31.02,123.53 31.02,124.22 v1(29.98,125.26)
  IN2 w0.089: v1(227.01,34.11) 227.22,34.11 228.78,35.67 228.78,50.68 229.86,51.76 229.86,67.1 227.63,69.33 v1(227.06,69.33)
  BOTTOM w0.102: 263.91,83.25 263.91,82.67 263.68,82.44 263.68,82.11 263.81,81.98 263.81,81.42 262.58,80.19 ; U9002.BF25 259.49,75.52 259.79,75.82 259.79,76.09 260.26,76.56 260.26,76.59 260.28,76.62
  BOTTOM w0.114: 262.58,80.19 262.03,79.64 262.03,78.4 260.28,76.64 260.28,76.62 ; 263.91,83.25 263.91,83.38 263.68,83.61 263.68,84.8 263.94,85.05 263.94,85.48 263.08,86.34 263.08,86.68 262.19,87.57 262.19,87.9 261.6,88.48 261.25,88.48 260.93,88.79 260.89,88.79 260.46,89.23 260.41,89.23 260.38,89.26 259.73,89.26 259.39,88.91 258.58,88.91 v1(258.4,88.74) ; U4000.28 29.76,125.04 v1(29.98,125.26)
NIC_SMDAT: length 420.9
  TOP w0.114: v1(226.99,34.77) 227.53,34.23 227.53,33.62 226.78,32.87 224.05,32.87 222.71,31.53 222.71,30.55 220.87,28.71 220.4,28.71 220.02,28.71 211.41,20.09 205.06,20.09 200.34,15.37 200.34,14.67 v1(200.74,14.26) ; v1(227.53,68.89) 227.64,69 227.64,69.74 227.21,70.17 227.21,78.37 228.42,79.59 228.42,81.78 229.37,82.73 230.01,82.73 230.85,83.58 231.64,83.58 233.04,84.98 242.44,84.98 244.01,86.55 245.39,86.55 246.06,87.22 247.2,87.22 248.27,86.15 248.57,86.15 249.14,85.58 249.82,85.58 250.2,85.21 251.82,85.21 252.38,85.77 252.38,86.86 252.61,87.09 253.02,87.09 253.8,87.87 253.8,88.76 254.11,89.07 257.64,89.07 257.92,88.79 257.92,87.87 v1(257.77,87.72) ; R4024.1 29.83,123.92 v1(30,123.74)
  IN1 w0.076: v1(200.74,14.26) 200.59,14.42 199.26,14.42 197.31,16.36 182.99,16.36 177.19,10.56 112.48,10.56 106.84,16.19 105,16.19 103.73,17.46 102.77,17.46 101.16,19.07 100.62,19.07 99.8,19.9 99.8,24.8 100.58,25.58 100.58,29.88 98.95,31.5 98.95,39.79 94.66,44.08 93.89,44.08 92.97,45 92.97,45.69 88.84,49.82 74.56,49.82 73.05,48.31 69.7,48.31 69.6,48.41 66.3,48.41 65.8,47.92 60.75,47.92 60.3,48.38 58.27,48.38 56.36,50.29 53.64,50.29 53.3,50.64 53.3,51.18 53.45,51.34 53.45,54.5 52.75,55.2 52.75,56.87 54.08,58.21 54.08,59.02 49.41,63.69 43.43,63.69 40.61,66.51 39.38,66.51 37.23,68.66 37.23,70.92 35.36,72.79 35.36,76.19 33.8,77.75 33.8,79.38 29.01,84.16 29.01,91.73 26.93,93.82 26.93,99.39 26.7,99.62 26.7,103.52 26.07,104.15 26.07,111.34 25.31,112.1 25.31,120.23 28.81,123.74 v1(30,123.74)
  IN2 w0.089: v1(227.53,68.89) 227.68,68.89 229.68,66.89 229.68,51.83 228.6,50.76 228.6,35.75 227.63,34.77 v1(226.99,34.77)
  BOTTOM w0.102: 260.97,79.22 260.97,79.21 260.54,78.77 260.54,78.18 260.29,77.93 260.28,77.93 259.24,76.89 259.24,76.76 258.7,76.23 258.7,76.13 258.15,75.58 U9002.BE24
  BOTTOM w0.114: U4000.31 29.9,123.84 v1(30,123.74) ; 260.97,79.22 261.3,79.54 261.3,79.95 260.76,80.48 260.76,81.5 261.14,81.88 261.14,83.02 262.13,84.01 262.13,85.33 262.85,86.04 262.85,86.59 261.91,87.52 261.91,87.84 261.53,88.23 261.09,88.23 260.32,88.99 259.8,88.99 259.47,88.66 258.94,88.66 258,87.72 v1(257.77,87.72)
NMI_SMI_DBG#: length 109
  TOP w0.114: v1(280.52,23.15) 280.1,23.15 279.81,23.44 Q6001.1 ; v1(257.15,71.73) 256.72,72.16 R9223.2
  IN1 w0.076: v1(262.14,16.94) 263.13,15.95 272.96,15.95 280.16,23.15 v1(280.52,23.15)
  IN2 w0.089: v1(257.15,71.73) 257.55,71.33 258.22,71.33 259.11,72.23 260.13,72.23 262.03,70.32 262.41,70.32 263.43,69.31 263.43,68.95 264.07,68.32 264.07,66.92 264.7,66.28 264.7,65.79 263.56,64.65 263.56,64.1 262.99,63.54 262.99,63.22 252.2,52.43 252.2,50.59 251.63,50.01 250.93,50.01 248.79,47.86 248.79,46.48 248.06,45.76 248.06,43.94 245.73,41.6 245.73,40.17 244.91,39.35 v1(244.91,39.06)
  BOTTOM w0.114: v1(244.91,39.06) 244.91,38.7 246.79,36.83 248.39,36.83 250.97,34.25 250.97,33.62 253.7,30.89 253.7,28.26 255.63,26.33 255.63,24.76 257.65,22.74 257.65,18.82 258.88,17.59 258.88,16.12 260.43,14.57 261.65,14.57 262.24,15.16 JCN9000.5 262.24,16.84 v1(262.14,16.94) ; v1(257.15,71.73) 256.75,72.12 U9002.AU26
NPCE576H_AGND: length 14.2
  TOP w0.114: C6018.1 261.11,25.84 260.89,25.63 C6017.2 260.61,25.63 v1(259.7,24.84) 259.07,24.21 C6039.1 258.47,24.21 258.2,23.95 258.2,22.81 C6038.1
  BOTTOM w0.114: U6001.E1 265.21,26.19 263.8,26.19 263.47,25.86 C6008.1 C6009.1 260.98,25.86 C6011.1 260.13,26.64 259.78,26.3 259.78,26.03 259.02,25.27 R6027.2 259.29,24.84 v1(259.7,24.84)
NUM_LOCK_LED#: length 61.4
  TOP w0.114: Q9037.5 244.71,50.31 244.28,49.87 243.75,49.87 R17940.2 243.37,49.1 243.88,48.6 R18102.1 244.38,47.91 245.79,46.5 245.79,45.89 246.14,45.54 246.14,45.19 245.14,44.18 v1(245.14,42.93)
  IN1 w0.076: v3(269.54,25.32) 268.97,25.89 268.97,30 268.78,30.19 264.23,30.19 264.03,30.39 263.46,30.39 263.3,30.55 263.3,31.56 264.03,32.29 264.03,32.88 262.83,34.08 258.83,34.08 257.1,35.8 256.13,35.8 254.13,37.8 249.27,37.8 246.93,40.13 245.14,41.92 v1(245.14,42.93)
  IN2 w0.076: 269.87,24.22 269.87,24.99 v3(269.54,25.32)
  IN2 w0.089: v1(267.54,14.67) 267.54,18.05 268.13,18.64 268.13,20.98 269.15,22 269.15,23.2 269.87,23.93 269.87,24.22
  BOTTOM w0.114: v1(267.54,14.67) 267.24,14.97 JCN9000.15 ; U6001.D7 v3(269.54,25.32)
NUM_LOCK_LED#_R: length 18.4
  TOP w0.114: v1(240.42,50.28) 240.42,50.66 240.06,51.02 v1(238.41,51.02) 237.78,51.02 237.45,51.35 237.45,51.86 237.27,52.03 236.67,52.03 R17965.1 236.17,53.22 236.5,53.55 R6817.1 ; R18102.2 244.38,49.65 245.21,50.48 Q9037.6 245.21,51.34 245.65,51.78 245.65,52.8 v1(245.47,52.97) 245.28,53.17 C6829.2
  IN2 w0.089: v1(245.47,52.97) 244.13,52.97 242.04,50.89 241.03,50.89 v1(240.42,50.28)
NV_GPU_DET: length 7.2
  TOP w0.114: v1(264.24,61.29) 263.95,61.29 v1(262.85,60.19) 262.85,59.72 R2227.2
  BOTTOM w0.102: v1(264.24,61.29) 264.03,61.49 264.03,62.42 263.17,63.29 263.17,63.52 262.69,64 U9002.AP47
NVVDD: length 4.2
  TOP w0.381: v1(211.29,114.28) 210.79,113.78 C2074.1 210.68,113.76 v1(210.07,113.15)
  BOTTOM w0.254: 214.28,82.39 215.67,83.78 PR9023.2
  vias: v1(209.03,107.15) v1(209.15,117.02) v1(209.13,109.16) v1(210.09,115.12) v1(210.07,112.15) v1(210.17,117.01) v1(210.73,80.1) v1(211.06,111.15) v1(211.18,109.14) v1(211.24,112.18) v1(211.25,107.23) v1(212.1,115.08) v1(212.1,111.3) v1(212.17,117.04) v1(212.5,105.47) v1(212.5,104.71) v1(212.5,103.82) v1(212.5,102.95) v1(212.97,114.21) v1(213,111.2) v1(213.01,106.24) v1(213.09,116.12) v1(213.37,103.82) v1(213.37,102.93) v1(213.37,102.17) v1(213.37,101.28) v1(213.37,100.52) v1(213.34,99.73) v1(214.03,107.15) v1(214.2,117.35) v1(214.18,115) v1(214.18,111.22) v1(215.06,107.14) v1(215.37,115.23) v1(216.04,116.2) v1(216.07,114.22) v1(216.09,111.17) v1(216.09,107.19) v1(217.18,115.31) v1(217.21,113.33) v1(217.16,110.2) v1(217.15,107.21) v1(217.26,117.28) v1(218.97,113.21) v1(218.96,112.21) v1(218.96,111.2) v1(218.96,110.2) v1(218.96,109.2) v1(218.98,107.2) v1(219.06,117.27) v1(219.04,115.24) v4(192.18,74.51) v4(192.18,73.24) v4(192.56,73.88) v4(192.95,74.51) v4(192.95,73.24) v4(193.33,73.88) v4(193.71,74.51) v4(193.71,73.24) v4(194.09,73.88) v4(194.47,74.51) v4(194.47,73.24) v4(194.85,73.88) v4(195.23,74.51) v4(195.23,73.24) v4(195.61,73.88) v4(195.99,74.51) v4(195.99,73.24) v4(196.37,73.88) v4(196.76,74.51) v4(196.76,73.24) v4(197.14,73.88) v4(197.52,74.51) v4(197.52,73.24) v4(197.9,73.88) v4(198.28,74.51) v4(198.28,73.24) v4(198.66,73.88) v4(199.04,74.51) v4(199.04,73.24) v4(199.42,73.88) v4(199.8,74.51) v4(199.8,73.24) v4(200.18,73.88) v4(200.57,74.51) v4(200.57,73.24) v4(200.95,73.88) v4(201.33,74.51) v4(201.33,73.24) v4(201.71,73.88) v4(202.09,74.51) v4(202.09,73.24) v4(202.47,73.88) v4(202.85,74.51) v4(202.85,73.24) v4(203.23,73.88) v4(203.61,74.51) v4(203.61,73.24) v4(203.99,73.88) v4(204.38,74.51) v4(204.38,73.24) v4(204.76,73.88) v4(205.14,74.51) v4(205.14,73.24) v4(205.52,73.88) v4(205.9,74.51) v4(205.9,73.24) v4(206.28,73.88) v4(206.66,74.51) v4(206.66,73.24) v4(207.04,73.88) v4(207.42,74.51) v4(207.42,73.24) v4(207.8,73.88) v4(207.83,72.58) v4(208.19,73.24) v4(208.67,72.61) v4(208.82,73.75) v4(209.2,73.12) v4(209.58,73.75) v4(209.58,72.48) v4(209.96,73.12) v4(210.34,73.75) v4(210.34,72.48) v4(210.73,73.12) v4(211.11,73.75) v4(211.11,72.48) v4(211.36,94.8) v4(211.36,94.04) v4(211.36,93.28) v4(211.36,92.51) v4(211.49,73.12) v4(211.89,73.78) v4(211.87,72.48) v4(212,95.18) v4(212,94.42) v4(212,93.66) v4(212,92.9) v4(212.33,73.12) v4(212.66,73.78) v4(212.66,72.46) v4(213.09,73.12) v4(213.42,73.78) v4(213.57,72.51)
NVVDD_CORE1_EN: length 55.6
  TOP w0.114: R2129.2 C2229.2 221.7,83.09 221.7,81.95 R2128.1 221.56,81.68 221.56,79.5 221.72,79.34 223.78,79.34 226.63,76.49 226.63,68.37 v1(227.16,67.83) 227.54,67.45 227.54,65.29 v1(227.39,65.14)
  TOP w0.254: v1(214.92,52.26) 214.88,52.29 213.77,52.29 213.18,51.7 PD9005.1
  IN1 w0.076: v1(227.39,65.14) 227.26,65.01 227.26,62.09 228.66,60.7 228.66,55.41 225.33,52.09 222.67,52.09 220.7,50.12 216.31,50.12 214.92,51.51 v1(214.92,52.26)
  BOTTOM w0.254: v1(214.92,52.26) 214.29,52.88 PR9222.1
NVVDD_EN: length 2.8
  TOP w0.114: R2129.1 222.76,84.67 v1(223.29,84.15) 223.29,83.8 223.54,83.54 U2008.4
NVVDD_PWM_GPU: length 126.8
  IN1 w0.076: v1(226.37,31.46) 226.37,31.64 226.66,31.92 226.66,32.34 228.47,34.15 228.47,50.87 227.58,51.75 222.8,51.75 220.38,49.33 214.58,49.33 v1(213.9,50.02)
  IN2 w0.089: v1(226.37,31.46) 226.37,31.64 226.61,31.87 229.05,31.87 229.55,32.37 230.77,32.37 232.26,33.87 232.26,35.42 233,36.16 233.89,36.16 234.3,36.56 234.3,37.66 234.22,37.74 234.22,59.55 233.97,59.8 233.97,60.55 234.11,60.69 234.11,63.07 233.39,63.78 233.39,67.57 232.34,68.62 232.34,70.42 230.52,72.23 230.52,74.78 230,75.3 229.41,75.3 228.47,76.24 228.47,78.81 227.52,79.75 226.53,79.75 226.15,80.13 226.15,80.98 224.54,82.59 224.54,83.3 223.29,84.55 221.87,84.55 220.78,85.64 220.78,87.81 219.96,88.64 218.95,88.64 217.38,90.21 217.38,94.3 216.26,95.41 216.26,96.74 217.08,97.55 217.08,102.51 v1(217.5,102.93)
  BOTTOM w0.102: v1(217.5,102.93) 217.12,102.55 U2000.P6
  BOTTOM w0.254: PR9014.1 212.5,50.6 212.99,50.11 213.81,50.11 v1(213.9,50.02)
NVVDD_VIN: length 19.9
  IN3 w0.508: v4(194.98,55.94) 194.98,55.21 194.85,55.08 194.85,51.02 195.87,50 197.64,50 198.55,49.1 201.44,49.1 203.87,46.67 206.03,46.67 206.38,46.31 v1(206.38,45.91)
  BOTTOM w0.508: v1(206.38,45.91) 206.8,46.32 PR9001.1
  vias: v1(214.54,58.13) v4(191.8,61.26) v4(191.93,59.24) v4(191.93,58.48) v4(191.93,57.72) v4(192.56,61.26) v4(193.33,61.26) v4(193.83,56.61) v4(194.22,55.94) v4(194.6,56.61) v4(195.74,61.53) v4(195.74,55.94) v4(196.76,61.26) v4(197.52,61.26) v4(198.28,61.26) v4(199.04,61.26) v4(201.58,60.03) v4(203.49,61.53) v4(204.63,61.47) v4(205.39,61.47) v4(206.15,61.47) v4(210.09,61.47) v4(210.85,61.45) v4(211.61,61.45) v4(212.38,61.45) v4(213.14,61.45) v4(217.58,59.24) v4(217.58,58.48) v4(217.71,61.26) v4(218.47,61.26) v4(219.23,61.26) v4(221.9,61.53) v4(221.9,60.76) v4(222.79,57.75) v4(222.92,61.18) v4(223.55,57.75) v4(223.68,61.18) v4(224.31,57.75) v4(224.44,61.18) v4(225.2,61.18) v4(225.97,61.18)
NVVDDPG: length 114.7
  IN2 w0.089: v1(203.22,52.2) 203.22,51.14 202.47,50.38 201.2,50.38 199.93,49.11 198.41,49.11 198.03,49.49 196.88,49.49 196.5,49.11 192.18,49.11 191.68,49.62 191.68,50.76 190.68,51.75 190.68,69.13 188.88,70.93 188.88,76.67 191.24,79.03 192.69,79.03 192.97,79.31 192.97,79.69 193.2,79.92 193.57,79.92 194.65,81 197.32,81 199.36,83.03 199.36,85.11 198.7,85.77 198.25,85.77 197.57,86.45 197.57,88.23 v1(199.55,90.21)
  IN4 w0.076: v1(230.84,82.95) 230.79,82.89 225.97,82.89 225.48,82.41 220.22,82.41 218.95,83.68 206.33,83.68 205.09,84.93 v1(203.99,84.93) 202.72,86.2 202.72,87.09 200.71,89.1 199.44,89.1 199.17,89.37 199.17,89.83 v1(199.55,90.21)
  BOTTOM w0.114: D2008.1 199.02,89.76 199.47,90.21 v1(199.55,90.21) ; PU9503.2 v1(203.99,84.93) 205.15,84.93 PR9522.2 205.78,85.9 206.31,86.43 206.31,87.37 206.9,87.96 U2006.1 ; PU25002.1 230.78,82.88 v1(230.84,82.95)
  BOTTOM w0.254: PR9006.2 203.13,52.29 v1(203.22,52.2) 204.68,53.65 PU9001.16
NVVDDS_PSI: length 7.6
  BOTTOM w0.114: TP2012.1 216.69,94.42 216.69,95.61 217.46,96.37 217.46,97.55 216.69,98.31 216.69,100.51 U2000.P4
NVVDDS_VID: length 4.6
  TOP w0.114: v1(216.65,102.13) 216.65,102.39 216.24,102.8 216.24,103.11 216.57,103.44 216.57,104.2 216.29,104.48 216.29,104.89 215.91,105.27 TP2010.1
  BOTTOM w0.127: U2000.P5 217.05,101.7 216.65,102.1 v1(216.65,102.13)
OCP_CHG#: length 17
  TOP w0.114: v1(262.51,5.34) 264.09,3.77 PR12009.1
  BOTTOM w0.114: v1(262.51,5.34) 262.03,4.87 256.42,4.87 255.2,6.09 252.41,6.09 251.9,5.58 251.9,4.96 PR11020.1
OCP_IN_ADC: length 58.2
  TOP w0.114: R6231.1 258.76,29.6 259.13,29.23 260.52,29.23 v1(260.69,29.4) ; v1(300.49,30.06) 299.24,31.31 v1(299.24,31.33) 299.12,31.46 299.12,35.4 298.36,36.16 297.33,36.16 PC12009.1 296.58,36.91 296.58,37.82 PR12023.2
  IN4 w0.076: v1(260.69,29.4) 261.83,30.54 265.03,30.54 265.3,30.81 265.3,32.13 266.33,33.16 267.9,33.16 269.86,31.21 275.98,31.21 276.46,30.72 277.97,30.72 278.43,31.18 279.83,31.18 280.25,30.76 282.69,30.76 283.24,31.31 290.54,31.31 290.93,30.93 298.05,30.93 298.51,30.47 300.09,30.47 v1(300.49,30.06)
  BOTTOM w0.114: R6021.2 261.52,28.61 260.8,29.33 v1(260.69,29.4)
OCP_IN_ADC_R: length 6.7
  IN2 w0.089: v1(263.02,27.78) 262.9,27.65 v1(262.9,26.69)
  BOTTOM w0.114: C6008.2 262.85,26.64 v1(262.9,26.69) ; R6021.1 262.8,28.56 263.02,28.34 v1(263.02,27.78) 263.64,27.78 264.34,27.08 264.93,27.08 265.1,27.26 265.65,27.26 U6001.F2
OCP_OC#: length 175.3
  IN2 w0.089: v1(233.76,33.49) 233.99,33.72 234.32,33.72 235.45,34.85 235.45,37.52 236.02,38.09 236.02,38.09 236.18,38.24 236.18,57.79 236.81,58.43 236.81,60.62 236.23,61.2 236.23,63.65 236.45,63.86 236.45,64.23 236.68,64.46 237.25,64.46 237.88,65.09 237.88,65.9 237.19,66.59 236.58,66.59 236.2,66.97 236.2,70.38 235.56,71.02 235.56,73.58 234.5,74.64 233.54,74.64 232.42,75.76 231.83,75.76 230.66,76.93 230.66,80.63 228.84,82.46 228.84,83.99 228.1,84.72 228.1,85.99 228.82,86.71 230.87,86.71 231.18,87.02 232.91,87.02 233.56,86.37 234.93,86.37 235.91,87.35 246.5,87.35 249.3,90.15 250.79,90.15 251.03,90.39 253.83,90.39 253.97,90.25 258.99,90.25 260.03,89.22 v1(260.03,88.28)
  IN3 w0.089: v1(268.89,13.17) 268.89,14.18 267.87,15.2 262.16,15.2 261.44,14.48 256.15,14.48 255.68,14.95 255.68,15.33 257.84,17.49 258.99,17.49 259.98,18.48 259.98,20.99 258.06,22.91 258.06,24.01 256.91,25.15 255.24,25.15 254.92,24.82 253.25,24.82 252.64,25.43 252.64,26.15 v1(253,26.51)
  BOTTOM w0.102: U9002.BE15 255.04,78.69 255.42,79.08 255.42,79.44 255.91,79.94 255.91,79.95 256.67,80.71 256.67,80.86
  BOTTOM w0.114: v1(233.76,33.49) 236.03,33.49 237.21,32.32 241.21,32.32 243.52,34.63 245,34.63 245.49,34.14 246.82,34.14 247.34,34.65 247.87,34.65 248.25,34.27 248.25,32.67 249.46,31.46 249.46,30.6 251.45,28.61 251.45,28.09 253,26.54 v1(253,26.51) ; PR12011.2 269.79,8.98 PQ12004.3 268.76,10.38 269.27,10.89 269.27,12.79 v1(268.89,13.17) ; v1(260.03,88.28) 259.47,87.72 R9229.1 259.47,86.33 259.32,86.18 259.07,85.91 259.05,85.91 257.72,84.57 257.72,83.06 257.19,82.54 257.19,82.53 256.67,82.02 256.67,80.86
OCP_PWM_OUT: length 165.7
  TOP w0.114: v1(325.53,19.52) 326.3,20.28 326.3,26.11 327.21,27.03 327.21,27.95 326.33,28.83 325.77,28.83 324.33,30.28 324.33,39.03 323.48,39.88 323.48,45.96 v1(324.16,46.65) 325.23,47.72 325.23,48.71 323.94,50 323.94,51.36 324.51,51.93 324.51,59.16 325.02,59.67 325.02,63.69 325.93,64.61 325.93,65.97 326.35,66.38 327.44,66.38 327.82,66.77 327.82,67.86 328,68.04 328,69.38 v1(327.31,70.07) ; v1(266.88,7.05) 266.94,7 268.21,7 268.89,6.31 268.89,5.96 269.15,5.7 269.15,4.41 269.53,4.03 PQ12003.2
  IN2 w0.089: v1(266.88,7.05) 266.76,7.18 266.76,12.51 266.05,13.22 266.05,16.3 266.33,16.58 266.33,20.18 266.03,20.47 266.03,21.03 266.61,21.6 266.61,23.72 265.94,24.38 265.94,26.75 266.59,27.4 267.72,27.4 v3(268.24,27.92)
  IN3 w0.089: v1(266.88,7.05) 266.94,7 271,7 271.23,7.23 273.01,7.23 274.3,5.93 296.32,5.93 306.86,16.47 310.83,16.47 312.2,15.1 318.19,15.1 318.55,15.46 319.82,15.46 323.26,18.9 324.91,18.9 v1(325.53,19.52)
  BOTTOM w0.114: v1(266.88,7.05) 266.88,7.03 266.73,7.18 PQ12004.2 ; U6001.G6 v3(268.24,27.92) ; Q6300.2 325.14,79.97 324.77,79.59 324.77,78.45 325.03,78.2 325.03,75.37 325.41,74.99 325.41,70.97 326.05,70.32 327.06,70.32 v1(327.31,70.07)
ON_OFF#: length 368
  TOP w0.114: Q6007.1 257.22,51.51 RV6000.1 257.77,51.54 257.77,50.18 258.48,49.47 v1(258.48,48.35) ; v1(205.18,14.04) 206.34,15.2 210.54,15.2 221.08,25.74 227.35,25.74 233.88,32.27 235.8,32.27 238,31.36 239.01,31.16 240.05,31.16 241.06,31.36 241.48,31.54 242.39,31.54 243.32,32.46 245.38,32.46 245.52,32.6 v3(245.52,32.7)
  IN1 w0.076: v1(205.18,14.04) 205.18,14.42 200.71,18.89 182.03,18.89 178.62,15.47 111.91,15.47 104.88,22.49 103.87,22.49 101.49,24.87 101.49,30.26 99.87,31.88 99.87,40.2 94.18,45.89 93.85,45.89 89.1,50.64 71.15,50.64 70.77,50.26 62.85,50.26 62.64,50.04 62.15,50.04 61.85,50.34 61.44,50.34 61.09,50 59.09,50 56.3,52.79 56.3,55.28 54.44,57.14 54.44,59.14 53.15,60.43 53.13,60.43 49.56,64 43.59,64 40.76,66.83 39.51,66.83 37.56,68.79 37.56,71.05 35.69,72.91 35.69,76.33 34.2,77.83 34.2,79.57 29.39,84.37 29.39,91.85 27.27,93.97 27.27,99.48 27.01,99.75 27.01,103.98 26.58,104.41 26.58,111.72 25.84,112.46 25.84,117.7 27.51,119.37 27.51,121.3 29.24,123.03 30.73,123.03 31.17,123.47 31.17,127.6 33.15,129.58 33.15,134.43 35.34,136.62 35.34,141.33 v1(36.09,142.09)
  IN2 w0.089: v3(245.52,32.7) 245.52,32.86 245.45,32.93 245.45,33.82 248.9,37.27 249.31,37.27 250.64,38.61 250.64,39.05 250.99,39.4 251.93,39.4 253.4,40.87 254.11,40.87 254.28,41.05 255.68,41.05 256.36,41.73 256.36,44.72 257.24,45.6 257.24,47.11 v1(258.48,48.35)
  BOTTOM w0.114: CON6000.7 35.73,142.85 35.47,142.58 C6020.1 v1(36.09,142.09)
ON_OFF#1: length 7.8
  TOP w0.114: Q6006.3 255.23,52.38 R6170.2 255.56,50.89 255.92,50.52 Q6007.3 255.92,49.76 256.42,49.27 R6176.1 256.42,48.19 255.2,46.98 v1(255.07,46.98)
ON_OFF#1_Q: length 257.9
  TOP w0.114: v1(205.26,12.11) 207.22,14.06 210.69,14.06 221.68,25.06 227.72,25.06 232.59,29.94 249.49,29.94 251.65,27.78 252.64,27.78 253.7,28.84 v1(255.2,28.84) 255.5,29.15 256.34,29.15 256.34,29.15 257.22,29.15 R6080.1 ; Q6006.1 252.34,53.72 251.29,52.67 250.35,52.67 248.32,50.64 248.32,48.6 248.57,48.35 248.57,45.39 249.09,44.87 249.09,44.02 249.59,43.52 250.3,43.52 250.7,43.93 v1(250.7,44.21)
  IN1 w0.076: v1(205.26,12.11) 204.76,12.61 204.76,13.43 204.38,13.81 204.38,14.79 200.58,18.58 182.16,18.58 178.24,14.66 112.28,14.66 104.74,22.19 103.74,22.19 101.19,24.74 101.19,30.13 99.56,31.75 99.56,40.05 94.61,45 v1(94.14,45)
  BOTTOM w0.114: v1(250.7,44.21) 251.31,44.21 252.9,42.62 CON401.11 252.9,35.13 255.2,32.83 v1(255.2,28.84) ; v1(94.14,45) 94.14,47.09 89.07,52.17 88.16,52.17 87.41,52.92 87.41,53.42 86.39,54.44 84.21,54.44 83.21,55.43 82.3,55.43 81.84,55.89 81.37,56.36 81.37,59.48 81.46,59.57 81.46,61.56 81.23,61.79 CON400.41
OPC_AGND: length 59.5
  IN2 w0.254: v1(186.85,103.44) 188.04,104.63 188.04,122.6 190.04,124.59 190.04,127.28 188.96,128.36 188.96,131.94 187.32,133.58 187.32,137.06 185.09,139.29 182.55,139.29 181.54,140.3 181.54,150.97 v1(181.29,151.22)
  BOTTOM w0.254: PU17000.11 182.15,150.34 PC17000.2 181.9,150.62 181.29,151.23 v1(181.29,151.22) 180.91,151.59 PR17007.2 ; PR17020.1 PR17019.1 186.1,103.44 v1(186.85,103.44)
OPC_EN: length 3.7
  BOTTOM w0.254: PU17000.5 186.71,150.34 187.73,151.35 PC17006.1 188.24,151.36 189.02,152.14 PR17010.2
OPC_PG: length 3.2
  BOTTOM w0.254: PR17016.2 182.66,153.38 183.19,152.85 v1(183.19,152.36) 183.19,151.86 183.37,151.68 PU17000.13
OPC_SW: length 2.6
  TOP w0.114: v1(182.79,147.54) v4(183.55,147.54)
  TOP w0.508: PR17013.2 183.89,147.54 v4(183.55,147.54)
OPC_VIN:
  vias: v1(183.29,159.22)
OPC_VOUT: length 59.5
  IN2 w0.254: v1(181.29,151.98) 181.9,151.37 181.9,140.44 182.7,139.64 185.23,139.64 187.66,137.21 187.66,133.82 189.3,132.18 189.3,128.55 190.38,127.47 190.38,124.45 188.39,122.45 188.39,104.29 v1(186.85,102.76)
  BOTTOM w0.254: PR17018.1 186.18,102.76 v1(186.85,102.76) ; PU17000.12 182.65,150.84 PR17017.2 181.68,151.59 v1(181.29,151.98)
OUT08_PSR_OFF#: length 3.5
  TOP w0.114: U12003.4 50.69,62.05 50.53,61.89 50.53,61.71 v1(51.06,61.18) 51.08,61.16 R18005.2 R18002.2
OUT_HPD_PIN44: length 7.3
  TOP w0.114: U3007.44 61.99,63.33 61.78,63.54 60.42,63.54 59.75,64.21 59.75,64.96 58.96,65.75 v1(57.82,65.75) R3056.2
OUT_L_A:
  vias: v1(220.63,154.65) v1(221.62,155.31) v1(222.26,155.31)
OUT_L_B:
  vias: v1(220.12,154.9) v1(220.38,152.49) v1(220.38,151.86)
OUT_R_A:
  vias: v1(201.48,155.27) v1(201.48,154.63) v1(202.09,155.28)
OUT_R_B:
  vias: v1(201.73,152.62) v1(202.37,152.62) v1(203.11,152.62)
OVERT#: length 8.8
  BOTTOM w0.102: 218.57,97.19 218.57,97.44 218.78,97.65 U2000.M1
  BOTTOM w0.114: Q2015.1 219.1,90.9 218.6,91.4 218.6,92.14 R2086.2 218.19,92.78 218.57,93.16 218.57,97.19
OVP_DET: length 38.5
  TOP w0.114: PQ12012.3 232.95,15.08 233.77,14.26 PR12037.2 234.25,13.2 v1(233.71,12.66) 231.65,10.61 231.65,5.02 231.81,4.87 235.01,4.87 235.24,5.09 235.24,6.31 235.49,6.57 236.15,6.57 236.38,6.8 237.05,6.8 237.68,6.17 238.3,6.17 238.66,5.81 240.56,5.81 PR11037.2 241.07,5.15 241.25,4.96 241.35,4.87 241.89,4.87 242.9,3.85 250.73,3.85 252.94,6.06 PQ11003.2
OVP_TRIP_P1_P2.1: length 2.8
  BOTTOM w0.076: U8500.K5 343.18,92.83 343.18,92.43 343.57,92.04 343.57,91.02
  BOTTOM w0.114: TP8520.1 343.57,90.79 343.57,91.02
PA_USB2_RBIAS: length 2.2
  TOP w0.076: v3(341.59,116.52) 341.27,116.84 340.68,116.84 340.65,116.8
  TOP w0.114: R8011.2 340.27,116.42 340.65,116.8
  BOTTOM w0.114: U8001.H19 v3(341.59,116.52)
PAC1933_ADDR: length 4.7
  BOTTOM w0.114: PR9812.2 194.62,48.5 193.94,48.5 193.7,48.73 v1(193.33,48.73)
  BOTTOM w0.203: PU9802.6 196.83,49.82 196.11,49.1 PR9809.1 PR9812.2
PAC1933_ALERT: length 1.6
  BOTTOM w0.203: PU9802.1 199.21,53.14 199.3,53.05 PR9814.2
PANEL_BKEN_GFX: length 86.7
  TOP w0.114: U3009.3 246.99,37.57 246.71,37.84 246.71,38.11 246.46,38.36 244.55,38.36 243.85,37.67 243.85,33.97 242.11,32.22 241.34,32.22 240.86,32.02 239.98,31.85 239.08,31.85 238.2,32.02 235.57,33.11 235.2,33.11 v1(233.09,35.22)
  IN2 w0.089: v1(226.73,80.38) 227.4,80.38 228.82,78.95 228.82,76.39 229.55,75.66 230.21,75.66 230.88,74.99 230.88,72.38 232.7,70.56 232.7,68.77 234.55,66.91 234.55,65.05 233.88,64.39 233.88,64.07 234.11,63.84 234.46,63.84 234.96,63.34 234.96,61.3 235.82,60.44 235.82,59.3 234.58,58.05 234.58,37.89 234.65,37.81 234.65,35.52 234.09,34.97 233.34,34.97 v1(233.09,35.22)
  BOTTOM w0.114: v1(226.73,80.38) 225.97,81.14 225.97,81.97 226.52,82.52 226.52,86.24 227.5,87.22 R2150.1 R2235.2 228.92,88.17 229.14,87.95 230.66,87.95 230.96,87.66 U2010.4
PANEL_BKEN_GFX_R: length 41.7
  IN2 w0.089: v1(235.06,93.18) 235.06,93.4 233.62,94.83 225.49,94.83 225.29,94.63 223.62,94.63 221.44,96.81 221.44,98.85 220.96,99.33 220.96,101.87 219.44,103.39 218.98,103.39 218.78,103.19 218.78,102.76 218.33,102.31 v1(218.33,101.3)
  BOTTOM w0.114: R2235.1 229,88.95 229.09,88.86 229.09,88.32 229.2,88.21 229.54,88.21 229.66,88.33 U2010.1 229.66,89.48 229.9,89.73 230.16,89.73 230.31,89.58 U2010.2 230.31,88.31 230.44,88.18 231.15,88.18 231.4,88.43 231.4,89.12 232,89.71 235.57,89.71 235.67,89.81 235.67,90.48 R2125.2 234.98,91.17 v1(234.98,92.17) 234.98,93.1 v1(235.06,93.18)
  BOTTOM w0.127: U2000.M4 218.38,101.3 v1(218.33,101.3)
PANEL_BKEN_PCH: length 42.3
  TOP w0.114: R3050.2 248.34,40.1 v1(248.14,40.3) ; U3009.1 247.28,38.87 246.54,39.6 245.78,39.6 R9329.1 245.77,39.6 v1(244.95,40.41)
  IN2 w0.089: v1(262.89,65.69) 263.05,65.53 263.05,64.23 262.64,63.81 262.64,63.37 252.06,52.8 250.73,52.8 249.54,51.6 249.54,49.12 248.42,48 248.42,46.65 247.66,45.89 247.66,44.04 245.37,41.75 245.37,40.83 v1(244.95,40.41)
  BOTTOM w0.114: v1(248.14,40.3) 247.68,39.84 245.52,39.84 v1(244.95,40.41) ; 263.38,65.45 263.13,65.45 v1(262.89,65.69)
PB_USB2_RBIAS: length 3.6
  TOP w0.114: v3(341.59,117.17) 341.48,117.17 341.1,117.56 340.52,117.56 R8012.2 340.07,117.11 339.07,117.11 v1(338.87,117.31)
  BOTTOM w0.114: U8001.F19 v3(341.59,117.17)
PCH_2_CPU_TRIG: length 277
  IN2 w0.089: v1(171.2,25.77) 171.43,26 178.85,26 179.41,25.44 189.66,25.44 190.15,25.93 205.54,25.93 206.3,25.16 213.03,25.16 214.24,26.38 217.56,26.38 221.45,30.27 230.64,30.27 232.98,32.6 234.22,32.6 236.27,34.65 236.27,37.55 237.14,38.42 237.14,56.82 236.75,57.21 236.75,57.53 237.39,58.16 237.39,61.03 237.24,61.18 237.24,61.87 237.89,62.52 238.46,62.52 239.05,63.11 239.05,68.67 238.54,69.18 237.9,69.18 235.92,71.17 235.92,74.75 235.27,75.4 233.55,75.4 232.52,76.43 232.52,80.31 234.35,82.13 236.76,82.13 237.01,81.88 240.98,81.88 v1(241.54,81.32)
  IN4 w0.076: v1(171.2,25.77) 171.2,26.19 174.87,29.86 179.53,29.86 180.32,30.64 180.32,30.83 185.48,35.99 185.48,49.18 185.33,49.33 185.33,80.09 187.08,81.84 187.08,94.99 186.09,95.98 182.23,95.98 182,96.2 182,96.71 182.28,96.99 183.8,96.99 184.15,96.64 185.87,96.64 186.86,97.63 192.31,97.63 193.45,98.77 193.45,106.35 192.41,107.4 192.41,121.28 191.98,121.71 190.01,121.71 189.03,122.68 184.5,122.68 184.23,122.42 184.23,120.83 183.39,119.99 180.27,119.99 179.1,118.82 179.1,118.33 178.87,118.09 174.96,118.09 174.78,117.91 174.78,117.28 175.15,116.91 v1(175.82,116.91)
  BOTTOM w0.114: v1(241.54,81.32) 241.97,80.88 R9270.1
  BOTTOM w0.127: v1(175.82,116.91) 175.19,116.91 U9001.H23
PCH_2_CPU_TRIG_R: length 4.8
  BOTTOM w0.102: 244.92,78.66 245.87,77.72 245.87,77.61 U9002.AK3
  BOTTOM w0.114: R9270.2 242.73,80.23 243.35,80.23 244.92,78.66
PCH_+VCCAPLL_1P05A: length 6.5
  TOP w0.381: R17900.1 232.53,70.13 232.79,70.39 C12023.1 233.33,69.33 v1(233.35,69.31)
  BOTTOM w0.254: v1(233.35,69.31) 233.43,69.31 234.07,68.67 234.47,68.67 234.67,68.48 U9002.B1 235.6,68.48 U9002.B2 236.26,67.82 U9002.B3
PCH_DPST_PWM_R: length 3.2
  BOTTOM w0.114: R3022.1 54.9,50.13 55.02,50.26 R3014.2 R3021.2 55.52,48.85 55.28,48.6 v1(55.28,48.35)
PCH_DPST_PWM_R_R: length 4.3
  BOTTOM w0.114: R3022.2 53.25,50.5 53.25,51.15 C3036.1 53.62,52.21 v1(53.85,52.44) 54.43,53.02 CON3000.23
PCH_GPP_A22: length 10
  TOP w0.102: v1(264.07,74.64) 263.81,74.64 263.53,74.36 263.48,74.36 263.12,74 263.1,74
  TOP w0.114: R17887.1 265.52,74.67 R9351.2 v1(264.07,74.64) ; v3(259.19,70.13) 259.19,70.48 259.58,70.86 260.01,70.86 260.65,71.49 260.95,71.49 262.22,72.76 262.22,73.58 262.49,73.85 262.95,73.85 263.1,74
  BOTTOM w0.102: v3(259.19,70.13) 259.24,70.17 U9002.AW32
PCH_ISH_I2C0_SCL: length 8.5
  BOTTOM w0.089: 259.37,61.78 U9002.AG45 ; 260.03,60.44 260.03,60.64 259.74,60.93 259.74,60.98 259.37,61.36
  BOTTOM w0.102: 259.37,61.36 259.37,61.78 ; 260.25,59.52 259.87,59.89 259.87,60.11 260.03,60.26 260.03,60.44
  BOTTOM w0.114: R9349.2 260.31,55.18 260.31,55.82 260.53,56.05 260.53,56.44 260.31,56.66 260.31,57.55 261.02,58.26 261.02,58.75 260.25,59.52
PCH_ISH_I2C0_SDA: length 7
  BOTTOM w0.089: U9002.AH46 260.23,61.74 260.23,61.46 260.53,61.15 260.53,60.58 260.73,60.38
  BOTTOM w0.102: 260.79,57.62 261.27,58.11 261.27,58.79 260.79,59.28 260.79,60.33 260.73,60.38
  BOTTOM w0.114: 260.79,57.62 260.59,57.42 260.59,56.73 260.76,56.56 260.76,55.72 R9350.2
PCH_KBC_CLK: length 54.4
  TOP w0.114: Q9009.4 285.07,53.18 284.44,52.56 282.23,52.56 279.83,54.95 v1(279.83,56.56) 279.83,60.89 282.36,63.42 282.36,65.55 281.86,66.05 281.86,70.24 281.86,70.26 281.86,70.49 280.74,71.61 279.43,71.61 276.82,74.22 276.23,74.22 274.67,75.78 273.87,75.78 272.21,77.43 271.97,77.43 271.45,77.96 271.1,77.96 267.94,81.12 v3(267.19,81.12) 267.29,81.02 267.29,80.23 R9110.1
  BOTTOM w0.102: 261.15,76.22 260.61,75.67 260.61,75.49 260.04,74.92 260.04,74.7 U9002.BF27
  BOTTOM w0.114: 261.15,76.22 264.52,79.59 265.26,79.59 266.78,81.12 v3(267.19,81.12)
PCH_KBC_DATA: length 52.2
  TOP w0.114: Q9009.1 283.38,54.19 v1(282.99,54.57) 282.52,54.57 282.5,54.59 281.44,54.59 280.4,55.64 280.4,57.32 280.24,57.47 280.24,60.75 282.02,62.53 282.47,62.97 282.73,63.23 282.73,65.7 282.23,66.2 282.23,70.65 280.89,71.98 280.59,71.98 279.58,71.98 276.97,74.59 276.38,74.59 274.81,76.16 274.01,76.16 272.37,77.8 272.12,77.8 271.6,78.32 271.25,78.32 268.03,81.55 v3(266.8,81.55) 266.63,81.37 R9113.1
  BOTTOM w0.102: U9002.BE27 259.57,74.56 259.83,74.82 259.83,75 260.4,75.57 260.4,75.79 261.03,76.42
  BOTTOM w0.114: v3(266.8,81.55) 266.02,81.55 262.93,78.45 262.93,78.32 261.03,76.42
PCH_KBC_SMCLK: length 332.4
  TOP w0.114: PU11001.1 232.51,6.89 233.56,7.94 v1(233.56,9.97) ; Q2019.3 218.6,90.73 219.21,90.13 219.64,90.13 220,89.78 v1(220,89.24) ; Q9009.3 284.39,53.18 284.64,53.44 284.64,54.19 285.15,54.71 286.61,54.71 286.96,54.36 286.96,52.14 v1(287.19,51.91) ; v3(270.19,29.87) 270.19,31.77 271.32,32.9 273.22,32.9 R6039.2 ; v1(192.44,93.41) 192.51,93.49 193.79,93.49 194.03,93.74 194.03,95.54 197.22,98.72 197.22,100.93 198.15,101.86 198.72,101.86 199.42,102.56 199.42,102.96 v1(199.93,103.47)
  IN1 w0.076: v1(233.56,9.97) 233.08,9.49 224.72,9.49 223.91,10.3 217.43,10.3 216.08,11.65 207.32,11.65 206.18,12.79 206.18,14.82 205.19,15.81 204.63,15.81 200.37,20.08 192.44,20.08 192.02,19.66 181.98,19.66 179.13,16.8 173.95,16.8 v1(173.51,17.24)
  IN3 w0.076: 271.94,29.28 271.66,29.55 270.51,29.55 v3(270.19,29.87)
  IN3 w0.089: 271.94,29.28 272.85,28.36 273.93,28.36 273.94,28.37 274.26,28.37 274.37,28.25 275.21,28.25 275.62,28.67 277.15,28.67 278.24,27.57 284.44,27.57 285.16,28.29 287.57,28.29 v1(288.58,29.3)
  IN4 w0.076: v1(173.51,17.24) 174.15,17.87 174.87,17.87 175.29,18.3 175.29,21.33 176.69,22.72 176.69,24.86 176.44,25.11 176.44,25.74 178.26,27.57 184.65,27.57 188.37,31.29 188.37,44.46 188.64,44.73 188.64,45.93 189.14,46.43 189.14,50.33 187.94,51.53 187.94,61.27 187.4,61.81 187.4,69.29 187.92,69.81 187.92,77.8 189.69,79.57 189.69,86.57 191.93,88.8 191.93,92.91 v1(192.44,93.41) ; v1(220,89.24) 219.65,89.24 219.37,88.97 215.53,88.97 215.17,88.61 211.27,88.61 209.19,90.69 208,90.69 206.8,91.89 205.72,91.89 205.13,91.3 204.27,91.3 202.15,93.43 202.15,94.89 202.98,95.72 202.98,97.01 200.11,99.88 200.11,101.81 199.47,102.44 199.47,103.01 v1(199.93,103.47) ; v1(233.56,9.97) 233.97,10.38 237.88,10.38 240.16,8.09 249.97,8.09 250.37,8.5 250.37,14.25 250.88,14.76 250.88,18.66 250.01,19.54 250.01,22.42 251.94,24.35 254.5,24.35 255.87,25.72 257.14,25.72 257.37,25.95 257.98,25.95 258.95,26.91 261.51,26.91 262.95,28.35 264.64,28.35 265.28,29 265.28,29.78 266.03,30.52 269.54,30.52 v3(270.19,29.87)
  BOTTOM w0.114: Q6402.6 190.67,90.57 190.8,90.45 191.32,90.45 191.45,90.57 191.45,93.08 191.78,93.41 v1(192.44,93.41) ; v1(287.19,51.91) 287.19,51.83 285.86,50.5 285.86,45.22 286.48,44.6 286.48,38.89 288.33,37.04 288.33,35.02 288.69,34.66 288.69,34.65 289.05,34.29 289.05,29.78 v1(288.58,29.3) ; U6001.K8 v3(270.19,29.87)
PCH_KBC_SMDATA: length 332.3
  TOP w0.114: v1(217.05,89.43) Q2019.6 ; v3(269.54,29.87) 269.7,29.87 269.91,30.07 269.91,31.92 271.18,33.19 272.99,33.19 273.21,33.41 R6038.2 ; v1(232.82,9.98) 233.19,9.62 233.19,8.09 232.56,7.46 232.38,7.46 232.19,7.66 232.19,7.84 232.51,8.16 PU11001.5 ; v1(199.91,102.83) 199.91,102.38 198.92,101.39 198.34,101.39 197.69,100.74 197.69,98.67 194.5,95.49 194.5,93.6 193.93,93.02 192.82,93.02 192.58,92.78 v1(192.44,92.78) ; v1(286.56,51.91) 286.59,51.94 286.59,54.21 286.46,54.34 285.91,54.34 285.76,54.19 Q9009.6
  IN1 w0.076: v1(232.82,9.98) 224.78,9.98 224.06,10.71 217.63,10.71 215.68,12.66 206.84,12.66 206.51,12.99 206.51,15.1 205.37,16.25 204.81,16.25 200.65,20.41 192.18,20.41 191.76,19.99 181.53,19.99 178.78,17.24 v1(174.15,17.24)
  IN3 w0.076: 271.94,30.04 271.71,30.27
  IN3 w0.089: 271.71,30.27 269.94,30.27 v3(269.54,29.87) ; 271.94,30.04 272.14,29.84 272.14,29.56 272.8,28.9 273.08,28.9 273.09,28.89 274.36,28.89 274.5,29.03 277.97,29.03 278.29,28.71 278.29,28.28 278.66,27.91 284.29,27.91 285.02,28.63 287.29,28.63 v1(288.59,29.94)
  IN4 w0.076: v1(174.15,17.24) 174.7,17.24 175.62,18.16 175.62,21.12 177.19,22.69 177.19,25.02 178.58,26.41 181.46,26.41 182.3,27.24 184.79,27.24 188.7,31.16 188.7,44.21 189.47,44.98 189.47,50.47 188.35,51.59 188.35,61.33 187.73,61.95 187.73,69.16 188.35,69.78 188.35,77.62 190.13,79.39 190.13,86.39 192.44,88.7 v1(192.44,92.78) ; v1(232.82,9.98) 232.82,10.63 232.7,10.76 232.44,10.76 232.32,10.63 232.32,9.85 232.2,9.74 232.05,9.74 231.93,9.85 231.93,10.65 231.82,10.76 231.66,10.76 231.55,10.65 231.55,10 231.43,9.87 231.3,9.87 231.17,10 231.17,10.5 231.05,10.63 230.92,10.63 230.79,10.5 230.79,9.49 230.92,9.36 233.84,9.36 233.97,9.49 233.97,9.91 234.08,10.02 234.24,10.02 234.35,9.91 234.35,9.49 234.47,9.36 234.6,9.36 234.73,9.49 234.73,9.94 234.84,10.05 235,10.05 235.11,9.94 235.11,9.49 235.24,9.36 237.14,9.36 237.27,9.49 237.27,9.94 237.38,10.05 237.54,10.05 237.65,9.94 237.65,9.49 237.78,9.36 238.41,9.36 240.01,7.76 250.1,7.76 250.7,8.36 250.7,14.12 251.21,14.63 251.21,18.8 250.34,19.67 250.34,22.14 252.22,24.02 254.64,24.02 256.01,25.39 257.28,25.39 257.51,25.62 258.12,25.62 258.99,26.48 261.62,26.48 262.53,27.39 263.87,27.39 264.24,27.01 265.16,27.01 265.61,27.47 265.61,29.64 266.16,30.19 269.22,30.19 v3(269.54,29.87) ; v1(199.91,102.83) 199.91,102.48 200.44,101.94 200.44,100.02 203.31,97.15 203.31,95.59 202.48,94.75 202.48,93.57 204.41,91.63 204.99,91.63 205.58,92.22 206.94,92.22 208.13,91.02 209.33,91.02 211.41,88.94 215.02,88.94 215.51,89.43 v1(217.05,89.43)
  BOTTOM w0.114: U6001.K7 v3(269.54,29.87) ; v1(288.59,29.94) 288.68,30.03 288.68,34.14 288.32,34.5 288.32,34.51 287.96,34.87 287.96,36.26 286.11,38.11 286.11,44.16 285.5,44.77 285.5,50.66 286.56,51.72 v1(286.56,51.91) ; v1(192.44,92.78) 191.81,92.16 191.81,90.42 191.5,90.1 189.5,90.1 189.37,89.98 Q6402.3
PCH_LVDS_BLON_R: length 272.9
  TOP w0.114: v1(203.86,13.43) 204.29,13.86 204.29,15.48 206.56,17.74 212.43,17.74 220.96,26.28 226.96,26.28 233.41,32.73 235.89,32.73 238.14,31.8 239.06,31.62 240,31.62 240.93,31.8 241.39,31.99 242.21,31.99 244.4,34.18 245.96,34.18 246.34,34.56 246.34,35.02 246.52,35.2 U49.4 248.6,35.2 R3036.1
  IN1 w0.076: v1(72.04,49.24) 72.42,48.86 72.84,48.86 74.28,50.29 89.02,50.29 93.44,45.86 93.44,45.17 94,44.62 94.78,44.62 99.41,39.98 99.41,31.69 101.04,30.07 101.04,24.46 103.64,21.86 104.64,21.86 112.15,14.35 178.15,14.35 182.21,18.42 200.53,18.42 203.33,15.62 203.33,13.95 v1(203.86,13.43)
  IN2 w0.089: v1(35.12,45.02) 36.57,43.58 60.29,43.58 62.94,46.22 66.4,46.22 69.03,48.86 71.66,48.86 v1(72.04,49.24)
  BOTTOM w0.114: D3001.1 v1(35.12,45.02) ; R3007.2 R3004.2 59.46,50.64 60.23,50.64 60.62,51.03 63.65,51.03 65.82,48.86 71.66,48.86 v1(72.04,49.24)
PCH_PCIE_WAKE#: length 627.9
  TOP w0.114: v1(359.06,106.14) 358.43,105.5 358.43,103.47 358.04,103.08 R8530.2 357.55,103.08 356.83,103.8 Q8012.3 356.44,103.8 355.23,102.58 353.35,102.58 352.4,101.63 350.81,101.63 350.71,101.53 350.71,100.38 351.19,99.9 Q8000.3 ; v1(21.24,112.61) 23.27,114.64 v1(23.27,116.7) 23.27,119.34 23.65,119.72 R4006.2
  IN1 w0.076: v1(292.69,29.89) 292.69,29.48 291.93,28.72 291.17,28.72 290.1,27.65 285.39,27.65 284.39,26.65 284.39,26.29 272.08,13.98 267.7,13.98 267.24,13.53 265.36,13.53 264.91,13.98 261.49,13.98 257.11,18.37 257.11,22.72 255.86,23.97 255.86,25.29 254.22,26.94 251.22,26.94 249.58,28.58 233.08,28.58 229.1,24.6 219.62,24.6 214.08,19.06 205.63,19.06 202.05,22.65 198.76,22.65 198.18,23.23 195.52,23.23 194.93,22.65 190.53,22.65 189.87,21.99 180.54,21.99 179.27,20.72 137.42,20.72 136.18,21.96 107.52,21.96 104.31,25.17 104.31,29.27 102.06,31.52 102.06,35.27 101.16,36.17 101.16,42.57 96.55,47.18 94.41,47.18 89.45,52.15 81.11,52.15 80.67,52.59 68.85,52.59 67.85,51.59 63.41,51.59 62.72,52.28 60.46,52.28 58.11,54.64 58.11,57.61 50.4,65.32 46.84,65.32 46.32,65.84 44.13,65.84 42.6,67.36 39.72,67.36 38.04,69.04 38.04,71.25 36.15,73.14 36.15,75.48 v1(36.38,75.71)
  IN2 w0.089: v1(336.84,24.3) 337.39,24.86 339.25,24.86 339.42,25.03 340.46,25.03 341.78,26.36 341.78,27.19 341.8,27.21 341.8,27.79 342.88,28.87 343.53,28.87 344.01,29.35 344.01,30.25 343.11,31.15 343.11,31.82 344.02,32.73 345.73,32.73 347.13,34.13 347.98,34.13 348.49,34.64 357.28,34.64 357.28,34.69 358.12,34.69 359.99,36.57 359.99,46.35 357.2,49.15 357.2,54.8 357.84,55.43 357.84,61.13 355.51,63.46 355.51,64.1 356.14,64.73 356.14,71.44 v1(355.56,72.02) 356.14,72.61 356.14,81.24 355,82.39 355,83.19 358.6,86.8 358.6,105.68 v1(359.06,106.14) ; v1(321.9,18.91) 321.9,24.17 318.37,27.7 315.42,27.7 312.93,30.19 312.93,32.55 312.3,33.19 310.76,33.19 305.49,38.46 305.49,45.63 304.3,46.83 299.58,46.83 298.92,47.48 298.92,48.93 298.36,49.49 293.02,49.49 292.54,49.01 290.71,49.01 v1(289.82,49.9) 289.82,49.93 289.8,49.95 289.8,51.07 286.27,54.59 283.7,54.59 283.65,54.64 283.37,54.64 283.16,54.85 282.99,55.02 282.65,55.16 282.57,55.19 282.52,55.25 282.07,55.55 281.9,55.66 281.9,55.66 281.85,55.69 281.85,55.71 281.78,55.78 281.27,56.29 280.78,57.02 280.78,57.03 280.43,57.54 280.43,57.58 279.6,58.41 279.41,58.6 279.41,60.61 276.71,63.31 276.71,65.85 276.46,66.1 275.9,66.1 v1(275.68,65.88)
  IN3 w0.089: v1(21.24,112.61) 20.1,111.47 20.1,101.76 18.35,100.01 18.35,91.64 19.66,90.33 19.66,85.78 23.53,81.91 v1(23.53,79.49) ; v1(321.9,18.91) 321.9,19.04 322.52,19.66 322.98,19.66 323.78,20.46 324.82,20.46 325.3,20.94 331.83,20.94 333.45,22.56 334.03,22.56 334.6,21.99 336.2,21.99 336.81,22.6 336.81,24.27 v1(336.84,24.3)
  BOTTOM w0.114: v1(289.82,49.9) 290.23,49.49 290.23,47.59 289.99,47.35 289.99,46.08 289.01,45.1 289.01,40.48 291.14,38.35 291.14,35.74 291.52,35.36 291.52,31.52 292.69,30.35 292.69,29.89 v1(292.69,29.89) ; R9093.2 275.75,65.95 v1(275.68,65.88) ; v1(355.56,72.02) 354.97,72.61 354.62,72.61 354.5,72.5 Q4101.6 ; R7308.1 31.02,74.51 32.21,75.71 v1(36.38,75.71) 36.38,78.04 35.72,78.7 24.31,78.7 v1(23.53,79.49)

# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Nets (continued)
FBVDDQ_MEM: C2003.1 C2004.1 C2005.1 C2006.1 C2007.1 C2057.1 C2059.1 C2063.2 C2065.2 C2066.2 C2067.2 C2068.2 C2069.1 C2077.1 C2081.2 C2091.2 C2098.2 C2107.2 C2112.2 C2120.2 C2127.2 C2139.1 C2168.1 C2169.1 C2170.1 C2171.1 C2172.1 C2173.1 C2177.1 C2181.1 C2500.1 C2501.1 C2502.2 C2503.1 C2504.1 C2505.1 C2506.2 C2507.1 C2508.2 C2509.2 C2510.1 C2511.2 C2512.2 C2514.1 C2516.2 C2517.2 C2518.2 C2519.2 C2520.2 C2521.2 C2522.2 C2523.2 C2524.1 C2525.1 C2526.1 C2528.1 C2530.2 C2531.2 C2532.1 C2533.2 C2534.2 C2537.1 C2538.1 C2539.2 C2540.2 C2541.1 C2542.2 C2543.2 C2544.1 C2545.1 C2546.1 C2547.2 C2548.2 C2549.2 C2550.2 C2551.1 C2552.1 C2554.2 C2555.1 C2556.2 C2557.2 C2559.2 C2560.1 C2561.1 C2562.1 C2563.1 C2564.2 C2565.2 C2566.1 C2567.1 C2568.1 C2569.1 C2570.1 C2571.1 C2572.1 C2573.1 C2574.1 C2575.1 C2576.1 C2577.1 C2578.2 C2579.2 C2580.2 C2581.2 C2582.2 C2583.2 C2584.2 C2585.2 C2586.2 C2587.2 C2588.1 C2589.1 C2590.2 C2591.2 C2592.2 C2593.2 C2594.2 C2595.2 C2596.2 C2597.2 C2598.2 C2599.2 C2600.1 C2601.1 C2602.2 C2603.2 C2604.2 C2605.2 C2606.2 C2607.2 C2608.2 C2609.2 C2610.2 C2611.2 C2612.1 C2613.1 C2614.2 C2615.2 C2616.2 C2617.2 C2618.2 C2619.2 C2620.2 C2621.2 C2622.2 C2623.2 PC8008.1 PC8009.1 PC8010.1 PC8011.1 PC8012.1 PC25007.1 PL8001.2 PR8006.2 PR8022.1 R2001.1 R2010.1 R2064.1 R2067.1 R2069.1 R2503.1 R2507.1 R2517.1 R2525.1 U2000.AA27(FBVDDQ_01) U2000.AA30(FBVDDQ_02) U2000.AB27(FBVDDQ_03) U2000.AB33(FBVDDQ_04) U2000.AC27(FBVDDQ_05) U2000.AD27(FBVDDQ_06) U2000.AE27(FBVDDQ_07) U2000.AF27(FBVDDQ_08) U2000.AG27(FBVDDQ_09) U2000.B13(FBVDDQ_10) U2000.B16(FBVDDQ_11) U2000.B19(FBVDDQ_12) U2000.E13(FBVDDQ_13) U2000.E16(FBVDDQ_14) U2000.E19(FBVDDQ_15) U2000.H8(FBVDDQ_30) U2000.H9(FBVDDQ_31) U2000.H10(FBVDDQ_16) U2000.H11(FBVDDQ_17) U2000.H12(FBVDDQ_18) U2000.H13(FBVDDQ_19) U2000.H14(FBVDDQ_20) U2000.H15(FBVDDQ_21) U2000.H16(FBVDDQ_22) U2000.H18(FBVDDQ_23) U2000.H19(FBVDDQ_24) U2000.H20(FBVDDQ_25) U2000.H21(FBVDDQ_26) U2000.H22(FBVDDQ_27) U2000.H23(FBVDDQ_28) U2000.H24(FBVDDQ_29) U2000.L27(FBVDDQ_32) U2000.M27(FBVDDQ_33) U2000.N27(FBVDDQ_34) U2000.P27(FBVDDQ_35) U2000.R27(FBVDDQ_36) U2000.T27(FBVDDQ_37) U2000.T30(FBVDDQ_38) U2000.T33(FBVDDQ_39) U2000.V27(FBVDDQ_40) U2000.W27(FBVDDQ_41) U2000.W30(FBVDDQ_42) U2000.W33(FBVDDQ_43) U2000.Y27(FBVDDQ_44) VRAM2500.B1(VDDQ-B1) VRAM2500.B3(VDDQ-B3) VRAM2500.B12(VDDQ-B12) VRAM2500.B14(VDDQ-B14) VRAM2500.C5(VDD-C5) VRAM2500.C10(VDD-C10) VRAM2500.D1(VDDQ-D1) VRAM2500.D3(VDDQ-D3) VRAM2500.D11(VDD-D11) VRAM2500.D12(VDDQ-D12) VRAM2500.D14(VDDQ-D14) VRAM2500.E5(VDDQ-E5) VRAM2500.E10(VDDQ-E10) VRAM2500.F1(VDDQ-F1) VRAM2500.F3(VDDQ-F3) VRAM2500.F12(VDDQ-F12) VRAM2500.F14(VDDQ-F14) VRAM2500.G1(VDD-G1) VRAM2500.G2(VDDQ-G2) VRAM2500.G4(VDD-G4) VRAM2500.G11(VDD-G11) VRAM2500.G13(VDDQ-G13) VRAM2500.G14(VDD-G14) VRAM2500.H3(VDDQ-H3) VRAM2500.H12(VDDQ-H12) VRAM2500.K3(VDDQ-K3) VRAM2500.K12(VDDQ-K12) VRAM2500.L1(VDD-L1) VRAM2500.L2(VDDQ-L2) VRAM2500.L4(VDD-L4) VRAM2500.L11(VDD-L11) VRAM2500.L13(VDDQ-L13) VRAM2500.L14(VDD-L14) VRAM2500.M1(VDDQ-M1) VRAM2500.M3(VDDQ-M3) VRAM2500.M12(VDDQ-M12) VRAM2500.M14(VDDQ-M14) VRAM2500.N5(VDDQ-N5) VRAM2500.N10(VDDQ-N10) VRAM2500.P1(VDDQ-P1) VRAM2500.P3(VDDQ-P3) VRAM2500.P11(VDD-P11) VRAM2500.P12(VDDQ-P12) VRAM2500.P14(VDDQ-P14) VRAM2500.R5(VDD-R5) VRAM2500.R10(VDD-R10) VRAM2500.T1(VDDQ-T1) VRAM2500.T3(VDDQ-T3) VRAM2500.T12(VDDQ-T12) VRAM2500.T14(VDDQ-T14) VRAM2501.B1(VDDQ-B1) VRAM2501.B3(VDDQ-B3) VRAM2501.B12(VDDQ-B12) VRAM2501.B14(VDDQ-B14) VRAM2501.C5(VDD-C5) VRAM2501.C10(VDD-C10) VRAM2501.D1(VDDQ-D1) VRAM2501.D3(VDDQ-D3) VRAM2501.D11(VDD-D11) VRAM2501.D12(VDDQ-D12) VRAM2501.D14(VDDQ-D14) VRAM2501.E5(VDDQ-E5) VRAM2501.E10(VDDQ-E10) VRAM2501.F1(VDDQ-F1) VRAM2501.F3(VDDQ-F3) VRAM2501.F12(VDDQ-F12) VRAM2501.F14(VDDQ-F14) VRAM2501.G1(VDD-G1) VRAM2501.G2(VDDQ-G2) VRAM2501.G4(VDD-G4) VRAM2501.G11(VDD-G11) VRAM2501.G13(VDDQ-G13) VRAM2501.G14(VDD-G14) VRAM2501.H3(VDDQ-H3) VRAM2501.H12(VDDQ-H12) VRAM2501.K3(VDDQ-K3) VRAM2501.K12(VDDQ-K12) VRAM2501.L1(VDD-L1) VRAM2501.L2(VDDQ-L2) VRAM2501.L4(VDD-L4) VRAM2501.L11(VDD-L11) VRAM2501.L13(VDDQ-L13) VRAM2501.L14(VDD-L14) VRAM2501.M1(VDDQ-M1) VRAM2501.M3(VDDQ-M3) VRAM2501.M12(VDDQ-M12) VRAM2501.M14(VDDQ-M14) VRAM2501.N5(VDDQ-N5) VRAM2501.N10(VDDQ-N10) VRAM2501.P1(VDDQ-P1) VRAM2501.P3(VDDQ-P3) VRAM2501.P11(VDD-P11) VRAM2501.P12(VDDQ-P12) VRAM2501.P14(VDDQ-P14) VRAM2501.R5(VDD-R5) VRAM2501.R10(VDD-R10) VRAM2501.T1(VDDQ-T1) VRAM2501.T3(VDDQ-T3) VRAM2501.T12(VDDQ-T12) VRAM2501.T14(VDDQ-T14) VRAM2502.B1(VDDQ-B1) VRAM2502.B3(VDDQ-B3) VRAM2502.B12(VDDQ-B12) VRAM2502.B14(VDDQ-B14) VRAM2502.C5(VDD-C5) VRAM2502.C10(VDD-C10) VRAM2502.D1(VDDQ-D1) VRAM2502.D3(VDDQ-D3) VRAM2502.D11(VDD-D11) VRAM2502.D12(VDDQ-D12) VRAM2502.D14(VDDQ-D14) VRAM2502.E5(VDDQ-E5) VRAM2502.E10(VDDQ-E10) VRAM2502.F1(VDDQ-F1) VRAM2502.F3(VDDQ-F3) VRAM2502.F12(VDDQ-F12) VRAM2502.F14(VDDQ-F14) VRAM2502.G1(VDD-G1) VRAM2502.G2(VDDQ-G2) VRAM2502.G4(VDD-G4) VRAM2502.G11(VDD-G11) VRAM2502.G13(VDDQ-G13) VRAM2502.G14(VDD-G14) VRAM2502.H3(VDDQ-H3) VRAM2502.H12(VDDQ-H12) VRAM2502.K3(VDDQ-K3) VRAM2502.K12(VDDQ-K12) VRAM2502.L1(VDD-L1) VRAM2502.L2(VDDQ-L2) VRAM2502.L4(VDD-L4) VRAM2502.L11(VDD-L11) VRAM2502.L13(VDDQ-L13) VRAM2502.L14(VDD-L14) VRAM2502.M1(VDDQ-M1) VRAM2502.M3(VDDQ-M3) VRAM2502.M12(VDDQ-M12) VRAM2502.M14(VDDQ-M14) VRAM2502.N5(VDDQ-N5) VRAM2502.N10(VDDQ-N10) VRAM2502.P1(VDDQ-P1) VRAM2502.P3(VDDQ-P3) VRAM2502.P11(VDD-P11) VRAM2502.P12(VDDQ-P12) VRAM2502.P14(VDDQ-P14) VRAM2502.R5(VDD-R5) VRAM2502.R10(VDD-R10) VRAM2502.T1(VDDQ-T1) VRAM2502.T3(VDDQ-T3) VRAM2502.T12(VDDQ-T12) VRAM2502.T14(VDDQ-T14) VRAM2503.B1(VDDQ-B1) VRAM2503.B3(VDDQ-B3) VRAM2503.B12(VDDQ-B12) VRAM2503.B14(VDDQ-B14) VRAM2503.C5(VDD-C5) VRAM2503.C10(VDD-C10) VRAM2503.D1(VDDQ-D1) VRAM2503.D3(VDDQ-D3) VRAM2503.D11(VDD-D11) VRAM2503.D12(VDDQ-D12) VRAM2503.D14(VDDQ-D14) VRAM2503.E5(VDDQ-E5) VRAM2503.E10(VDDQ-E10) VRAM2503.F1(VDDQ-F1) VRAM2503.F3(VDDQ-F3) VRAM2503.F12(VDDQ-F12) VRAM2503.F14(VDDQ-F14) VRAM2503.G1(VDD-G1) VRAM2503.G2(VDDQ-G2) VRAM2503.G4(VDD-G4) VRAM2503.G11(VDD-G11) VRAM2503.G13(VDDQ-G13) VRAM2503.G14(VDD-G14) VRAM2503.H3(VDDQ-H3) VRAM2503.H12(VDDQ-H12) VRAM2503.K3(VDDQ-K3) VRAM2503.K12(VDDQ-K12) VRAM2503.L1(VDD-L1) VRAM2503.L2(VDDQ-L2) VRAM2503.L4(VDD-L4) VRAM2503.L11(VDD-L11) VRAM2503.L13(VDDQ-L13) VRAM2503.L14(VDD-L14) VRAM2503.M1(VDDQ-M1) VRAM2503.M3(VDDQ-M3) VRAM2503.M12(VDDQ-M12) VRAM2503.M14(VDDQ-M14) VRAM2503.N5(VDDQ-N5) VRAM2503.N10(VDDQ-N10) VRAM2503.P1(VDDQ-P1) VRAM2503.P3(VDDQ-P3) VRAM2503.P11(VDD-P11) VRAM2503.P12(VDDQ-P12) VRAM2503.P14(VDDQ-P14) VRAM2503.R5(VDD-R5) VRAM2503.R10(VDD-R10) VRAM2503.T1(VDDQ-T1) VRAM2503.T3(VDDQ-T3) VRAM2503.T12(VDDQ-T12) VRAM2503.T14(VDDQ-T14)
FBVDDQ_SENSE: PR8023.2 U2000.F1(FBVDDQ_SENSE)
FBVDDQ_VIN: PC8002.1 PC8003.1 PC8004.1 PC8005.1 PC8006.1 PR8001.2 PR9806.2 PU8001.7(IN#1) PU8001.8(IN#2) PU8001.9(IN#3) PU8001.22(IN#4)
FLY_N: C3613.1 U3600.30(FLY_N)
FLY_P: C3613.2 U3600.29(FLY_P)
FN_KEY_LED#: Q9036.5(G) R6802.2 R18074.1 U6001.A10(GPIOD5/JTAG_TCK1_SWCLK1)
FN_KEY_LED#_R: Q9036.6(D) R6820.1 R17964.1 R18074.2
FORCEON_BL: R3091.2 R17888.1 R18008.1 U49.1(INB)
FOST1: R7320.2 U8500.L7(GPIO_P3.1)
FOST1_R: R7320.1 R7324.1 U7112.C4(FO)
FOST2: R7323.2 U8500.L8(OVP_TRIP_P2/GPIO_P2.2)
FOST2_R: R7323.1 R7327.1 U7113.C4(FO)
FPR_LOCK#: CON7200.3 ESD7200.4 R7203.2 U9002.AV18(GPP_D8/I2S2_SCLK)
FPR_OFF#: CON7200.2 ESD7200.6 R7200.1 R7204.2 U9002.BD20(GPP_C20/UART2_RXD)
G5719_EN: PC9513.2 PR9507.2 PU9502.1(EN)
G5719_LX: PL9501.1 PU9502.3(LX)
G5719_PG: PR9506.2 PU9502.5(PG)
G5719_VFB: PR9509.2 PR9510.2 PU9502.6(FB)
G5719_VFB_R: PR9510.1 PR9511.1
G5719_VIN: PC9512.1 PR9508.2 PU9502.4(IN)
G_SDO: R9507.2 R9512.1 U9500.3(SDO/SA0)
GC6_EVT#: D2003.1(CATHODE) R2136.1 R2146.2 U9002.AN37(GPP_F8/SATA_DEVSLP6)
GC6_FB_EN: Q2010.3(D) R2135.2 R9342.2
GC6_FB_EN_L: R9206.1 R9342.1 U9002.AL47(GPP_E3/CPU_GP0)
GC6FBEN: Q2013.2(G) R2087.2 U2000.M3(GPIO1) U2005.1(I1)
GFX_SCL: Q2019.4(S) R2039.2 U2000.T4(I2CS_SCL)
GFX_SDA: Q2019.1(S) R2040.2 U2000.T3(I2CS_SDA)
GLAN_CLK_REQ2#: R9180.1 U4000.48(CLK_REQ_N) U9002.AR32(GPP_B7/SRCCLKREQ2#)
GPD7: R9366.1 R9367.2 U9002.BE41(GPD7)
GPIO14_IFPA_HPD: TP2014.1 U2000.N4(GPIO14)
GPIO15_IFPB_HPD: TP2015.1 U2000.P2(GPIO15)
GPIO17_IFPD_HPD: Q2016.3(D) R2107.2 R2108.1 U2000.M6(GPIO17)
GPIO17_IFPD_HPD_Q: Q2016.2(G) R2108.2 R2109.1 R2110.1
GPIO18_IFPE_HPD: Q2017.3(D) R2114.2 R2115.1 U2000.R1(GPIO18)
GPIO18_IFPE_HPD_Q: Q2017.2(G) R2115.2 R2116.1 R2117.1
GPIO24_IFPF_HPD: Q2018.3(D) R2119.2 R2120.1 U2000.L2(GPIO24)
GPIO24_IFPF_HPD_Q: Q2018.2(G) R2120.2 R2121.1 R2122.1
GPIO26_GFX: Q2021.1(S) R2145.2 U2000.R5(GPIO26)
GPIO27_IFPC_HPD: Q2008.3(D) R2037.2 R2046.1 U2000.U3(GPIO27)
GPIO27_IFPC_HPD_Q: Q2008.2(G) R2046.2 R2057.1 R2060.1
GPP_B21: R9323.2 U9002.BD30(GPP_B21/GSPI1_MISO)
GPP_B23: R9119.1 R10048.2 U9002.BD33(GPP_B23/SML1ALERT#/PCHHOT#)
GPP_C11: R9325.2 U9002.AP24(GPP_C11/UART0_CTS#)
GPP_D11: TP9026.1 U9002.BB16(GPP_D11/ISH_SPI_MISO/GP_BSSB_CL)
GPP_D12: TP9027.1 U9002.AN18(GPP_D12/ISH_SPI_MOSI/GP_BSSB_DI)
GPP_D17: R9617.2 R9624.2 U9002.AW15(GPP_D17/DMIC_CLK1/SNDW3_CLK)
GPP_D18: R9616.2 R9623.2 U9002.AV16(GPP_D18/DMIC_DATA1/SNDW3_DATA)
GPP_D19: R9615.2 R9622.2 U9002.BD16(GPP_D19/DMIC_CLK0/SNDW4_CLK)
GPP_D20: R9614.2 R9621.2 U9002.BF15(GPP_D20/DMIC_DATA0/SNDW4_DATA)
GPP_G1: R9618.2 U9002.BE9(GPP_G1/SD_D0)
GPP_G2: R9619.2 U9002.BF8(GPP_G2/SD_D1)
GPP_G3: R9145.1 R9344.1 U9002.BF9(GPP_G3/SD_D2)
GPP_G4: R9620.2 U9002.BG8(GPP_G4/SD_D3)
GPP_H15: R9368.1 R9369.2 U9002.AC47(GPP_H15/SML3ALERT#)
GPP_J4: R9377.2 U9002.AV4(GPP_J_4_CNV_BRI_DT_UART0_RTSB)
GPP_J6: R9373.2 R9378.2 R9546.2 U9002.BA4(GPP_J6/CNV_RGI_DT/UART0_TXD)
GPP_J9: R9371.1 R9544.2 U9002.AU9(GPP_J9/CNV_MFUART2_TXD)
GPP_K21: R9255.1 R9256.2 U9002.T45(GPP_K21)
GPS_XMIT_OFF#: CON4201.26(GPIO_10) R9204.1 U9002.BC33(GPP_B4/CPU_GP3)
GPU_CLK_REQ1#: Q2012.3(D) R9178.1 U9002.BE31(GPP_B6/SRCCLKREQ1#)
GPU_PEX_RST_HOLD#: R2042.2 U2000.T8(GPIO23)
GPUEVENT#: D2003.2(ANODE) R2044.2 U2000.L6(GPIO2)
GPUMON_ALERT_EC: PR9811.2 PR9814.1 PR9824.2
GPUMON_EN_EC: PR9816.2
H_CPU_SVIDALRT#: R9030.1 U9001.BH31(VIDALERT#)
H_CPU_SVIDDAT: R9034.2 R9036.1 U9001.BH29(VIDSOUT)
H_PECI: R6026.1 U6001.M7(PECI_DATA/GPIO81)
H_PM_DOWN: R9012.1 U9002.AE2(PM_DOWN)
H_PM_DOWN_R: R9012.2 U9001.BP31(PM_DOWN)
H_PRDY#: CON400.5(OBSFN_A1) R9268.1 U9001.BP27(PROC_PRDY#)
H_PRDY#_L: R9268.2 R9271.2 U9002.AM5(PRDY#)
H_PREQ#: CON400.3(OBSFN_A0) R9267.1 R9305.2 U9001.BL30(PROC_PREQ#)
H_PREQ#_L: R9267.2 U9002.AL2(PREQ#)
H_TCK: CON400.57(TCK0) R9111.2 R9306.2 U9001.BR28(PROC_TCK)
H_TDI: CON400.56(TDI) R9115.2 R9304.2 U9001.BL32(PROC_TDI)
H_TDO: CON400.52(TDO) R9114.2 R9302.1 U9001.BT28(PROC_TDO)
H_TMS: CON400.58(TMS) R9112.2 R9303.2 U9001.BP28(PROC_TMS)
H_TRST#: CON400.54(TRSTN) R9269.1 R9307.2 U9001.BP30(PROC_TRST#)
H_TRST#_L: R9269.2 R9272.2 U9002.AM4(CPU_TRST#)
H_VCCST_PWRGD: Q9002.6(D) R9309.1 R9340.2
HD_SDIN0: R3605.2 U3600.60(HDA_SDI)
HDA_SPKR: R3630.2 R9127.2 R17956.1 U9002.AW29(GPP_B14/SPKR)
HDACCEL_CLK: Q9032.6(D) R6412.2 U6001.F5(GPIOF3/I2C4_SCL1)
HDACCEL_DAT: Q9032.3(D) R6413.2 U6001.F6(GPIOF2/I2C4_SDA1)
HDD_HALTLED#: R9227.1 R9627.1 U9002.BE20(GPP_C21/UART2_TXD)
HDMI_HPD: R9251.2 R18099.2 U9002.AP9(GPP_I2/DPPD_HPD2/DISP_MISC2)
HDMI_HPD_R: R18089.1 R18099.1 U12006.40(HPD_SRC)
HDMI_SCL_R: Q9047.1(S) R9242.1 U9002.AL9(GPP_I9/DDPD_CTRLCLK)
HDMI_SCL_R_R: Q9047.6(D) R18101.2
HDMI_SDA_R: Q9047.4(S) R9243.1 U9002.AR3(GPP_I10/DDPD_CTRLDATA)
HDMI_SDA_R_R: Q9047.3(D) R18100.2
HDMI_UP_CLK: CON3200.15(DDC CLK) R3200.2 R18090.1 R18101.1 U12006.7(SCL_SNK)
HDMI_UP_DATA: CON3200.16(DDC DATA) R3203.2 R18088.1 R18100.1 U12006.8(SDA_SNK)
HOOK2: CON400.45(HOOK2) R400.2 R407.2
HOOK3: C400.2 CON400.47(HOOK3) R408.1 R409.1
HP_EAPD: D3600.3 R3619.1 R3620.1 R3638.1 U3600.15(EAPD)
HPOUT_DET: CON3601.6 Q3600.2(G) Q3603.2(G) Q3606.2(G) R3603.1 R3683.1 VC3603.1
HPOUT_L: C3634.2 U3600.33(PORTA_L)
HPOUT_L1: L3605.1 R3641.1
HPOUT_R: C3638.2 U3600.34(PORTA_R)
HPOUT_R1: L3606.1 R3642.1
I2C_C1_CLK: R6351.1 R9506.2 U9002.BE21(GPP_C19/I2C1_SCL)
I2C_C1_DATA: R6355.1 R9505.2 U9002.BF21(GPP_C18/I2C1_SDA)
I2C_CLICK_SCL: C6352.1 CON6351.2 R6351.2 R9232.2
I2C_CLICK_SDA: C6354.1 CON6351.3 R6355.2 R9234.2
I2C_DREAM_CL_SCL: CON10002.5 R9514.2 U6004.3(A2)
I2C_DREAM_CL_SDA: CON10002.4 R9513.2 U6004.2(A1)
I2C_DREAM_INT#: CON10002.3 R9351.1
I2C_NXP_SCL_L: Q9042.3(D) R3612.1
I2C_NXP_SCL_L_AUDIO: R3612.2 U3600.6(MSCL)
I2C_NXP_SDA_L: Q9042.6(D) U3600.7(MSDA)
I2C_ROM_DREAM_SCL: CON3002.3 Q3007.1(S) R3084.1
I2C_ROM_DREAM_SDA: CON3002.4 Q3007.4(S) R3083.1
I2C_SCL_AMP: Q3602.4(S) Q9042.4(S) R3647.2 R3681.2 U3602.G1(SCL) U3603.G1(SCL)
I2C_SCL_SENSOR: Q3008.6(D) R9362.1
I2C_SCL_SENSOR_R: CON3002.7 Q3008.1(S) R3086.1
I2C_SDA_AMP: Q3602.1(S) Q9042.1(S) R3646.2 R3680.2 U3602.F1(SDA) U3603.F1(SDA)
I2C_SDA_SENSOR: Q3008.3(D) R9363.1
I2C_SDA_SENSOR_R: CON3002.8 Q3008.4(S) R3085.1
I2C_TS_SCL: C3039.2 CON3001.5 R3030.1 U9002.BC22(GPP_C17/I2C0_SCL)
I2C_TS_SDA: C3040.2 CON3001.6 R3031.1 U9002.BF23(GPP_C16/I2C0_SDA)
I2CB_SCL_G: R2033.2 U2000.R7(I2CB_SCL)
I2CB_SDA_G: R2034.2 U2000.R6(I2CB_SDA)
I2CC_SCL: PR9813.1 PR9823.1 PU9802.4(SM_CLK)
I2CC_SCL_GFX: Q2020.4(S) R2074.2 U2000.R2(I2CC_SCL)
I2CC_SDA: PR9815.1 PR9822.1 PU9802.5(SM_DATA)
I2CC_SDA_GFX: Q2020.1(S) R2073.2 U2000.R3(I2CC_SDA)
I2S1_BCLK: R3614.1 U3600.53(I2S1_BCLK)
I2S1_CODEC_RX_DAT: R3617.2 U3600.57(I2S1_DIN)
I2S1_CODEC_TX_CLK: R3613.2 R3614.2 R3655.2
I2S1_CODEC_TX_DAT: R3616.2 U3600.56(I2S1_DOUT)
I2S1_CODEC_TX_WS: R3615.2 U3600.54(I2S1_LRCLK)
I2S1_MCLK: R3613.1 U3600.52(I2S1_MCLK)
I2S1_RX_DAT: R3617.1 R3652.2 U3606.4(A)
I2S1_SFRM: R9605.1 U9002.BD12(I2S1_SFRM/SNDW2_CLK)
I2S1_TX_CLK: R3655.1 TP3606.1 U3602.B1(BCK1) U3603.B1(BCK1)
I2S1_TX_DAT: R3616.1 TP3604.1 U3602.A2(DATA1/BCKM) U3603.A2(DATA1/BCKM)
I2S1_TX_WS: R3615.1 TP3605.1 U3602.A1(WS1/MICCLK) U3603.A1(WS1/MICCLK) U3606.6(S)
I_ADP_ADC0: PR11028.1 R6241.2
I_ADP_ADC0_R: C6038.2 R6241.1 U6001.D3(GPIO42/ADC3/R\I\)
I_DCHG_ADC1: PR11029.1 R6023.2
I_DCHG_ADC1_R: C6009.2 R6023.1 U6001.E3(GPIO44/ADC1)
I_SET: PQ12009.3(COLLECTOR) PR11006.2
ICCINSERTN: CON7300.2 U7300.19(ICCINSERTN)
IFPAB_PLLVDD: U2000.AH8(IFPAB_PLLVDD)
IFPC_RSET: R2077.2 U2000.AF8(IFPCD_RSET)
IFPC_SCL: Q2024.1(S) R2076.2 R2139.2 U2000.AG3(IFPC_AUX_SCL)
IFPC_SDA: Q2024.4(S) R2075.1 R2138.2 U2000.AG2(IFPC_AUX_SDA*)
IFPEF_RSET: R2124.2 U2000.AD6(IFPEF_RSET)
ILIM_SEL: R7022.1 U6001.A12(GPIOE5/JTAG_TMS1_SWIO1)
IM_5S_CLK: R6133.1 R6353.1 U6001.C1(GPIO37/PS2_CLK2/ADC5)
IM_5S_DATA: R6132.1 R6354.1 U6001.B2(GPIO34/PS2_DAT2/ADC6)
IMON_INT#: PR9824.1 Q2021.3(D) U9002.AM45(GPP_E7/CPU_GP1)
IMON_SCL: PR9823.2 Q2020.3(D) U9002.BF17(GPP_D14/ISH_UART0_TXD/I2C2_SCL)
IMON_SDA: PR9822.2 Q2020.6(D) U9002.BE17(GPP_D13/ISH_UART0_RXD/I2C2_SDA)
IMVP_PSYS: PC11026.1 PC19013.2 PR11032.2 PR19055.2 PU19000.46(PSYS)
IN1_AEQ#_EDP: R3062.2 U3007.59(IN1_AEQ#)
IN1_PEQ_EDP: R3067.2 R3075.2 U3007.52(IN1_PEQ/SDA_CTL)
IN2_AEQ#_EDP: R3063.2 U3007.58(IN2_AEQ#)
IN2_PEQ_EDP: R3068.2 R3076.2 U3007.51(IN2_PEQ/SCL_CTL)
INT_EDP_AUXN: C3067.2 U9001.B26(EDP_AUXN)
INT_EDP_AUXN_C: C3067.1 U3007.29(IN2_AUXN)
INT_EDP_AUXP: C3066.2 U9001.C26(EDP_AUXP)
INT_EDP_AUXP_C: C3066.1 U3007.30(IN2_AUXP)
INT_EDP_TXN0: C3077.2 U9001.E29(EDP_TXN_0)
INT_EDP_TXN0_C: C3077.1 U3007.12(IN2_D0N)
INT_EDP_TXN1: C3079.2 U9001.E28(EDP_TXN_1)
INT_EDP_TXN1_C: C3079.1 U3007.15(IN2_D1N)
INT_EDP_TXN2: C3081.2 U9001.B29(EDP_TXN_2)
INT_EDP_TXN2_C: C3081.1 U3007.17(IN2_D2N)
INT_EDP_TXN3: C3083.2 U9001.B28(EDP_TXN_3)
INT_EDP_TXN3_C: C3083.1 U3007.20(IN2_D3N)
INT_EDP_TXP0: C3076.2 U9001.D29(EDP_TXP_0)
INT_EDP_TXP0_C: C3076.1 U3007.11(IN2_D0P)
INT_EDP_TXP1: C3078.2 U9001.F28(EDP_TXP_1)
INT_EDP_TXP1_C: C3078.1 U3007.14(IN2_D1P)
INT_EDP_TXP2: C3080.2 U9001.A29(EDP_TXP_2)
INT_EDP_TXP2_C: C3080.1 U3007.16(IN2_D2P)
INT_EDP_TXP3: C3082.2 U9001.C28(EDP_TXP_3)
INT_EDP_TXP3_C: C3082.1 U3007.19(IN2_D3P)
INT_HPD_PIN13: R3055.1 U3007.13(IN2_HPD)
INV_PWM: R908.2 R3021.1 R3051.1 U3010.4(A)
IO_VDD: C9500.1 CON9500.2 CON9500.3 CON9500.15 R9501.1 R9504.1
ISET_EN: R6082.2 TP22040.1 U6001.E9(GPIOF4/I2C5_SDA1)
ISH_ACCEL_INT1#: R9352.1 U9002.BF35(GPP_A18/ISH_GP0)
ISH_ALS_INT#: R9353.1 U3011.4(Y) U9002.BA33(GPP_A21/ISH_GP3)
ISH_I2C0_COLOR_SCL: R9349.1 R9354.1 U6004.6(B2)
ISH_I2C0_COLOR_SDA: R9350.1 R9355.1 U6004.7(B1)
ISH_I2C1_COMBO_SCL: R9362.2 R9364.1 U9002.AH47(GPP_H22/ISH_I2C1_SCL)
ISH_I2C1_COMBO_SDA: R9363.2 R9365.1 U9002.AH48(GPP_H21/ISH_I2C1_SDA)
ITP_PMODE: CON400.46(RESET#/HOOK6) R402.1 U9002.AL3(ITP_PMODE)
JSENSE: Q3600.3(D) R3603.2 R3607.2
JTAG_SEL: R2079.1 TP2007.1 U2000.AK11(NVJTAG_SEL)
JTAG_TCK: R2082.1 U2000.AM10(JTAG_TCK)
JTAG_TDI: R2070.1 U2000.AM11(JTAG_TDI)
JTAG_TDO: TP2004.1 U2000.AP12(JTAG_TDO)
JTAG_TMS: R2071.1 U2000.AP11(JTAG_TMS)
JTAG_TRST#: R2072.1 U2000.AN11(JTAG_TRST*)
KBC_PWR_ON: PR22007.2 PR22010.2 R6040.1 R9286.2 U6001.G7(GPIOD2)
KBD_SHARE_LED#: Q9040.5(G) R17953.1 R18076.1 U6001.F10(GPIOC7/D\T\R\_BOUT)
KBD_SHARE_LED#_R: Q9040.6(D) R6803.2 R6813.1 R18076.2
KBL_DET#: C9216.2 CON6801.3 R9210.1 U9002.BF32(GPP_B3/CPU_GP2)
KSI0: D6801.6 RP6800.1(R2) U6001.A2(KSI0/GPIO31/TRACEDATA3)
KSI1: D6801.3 RP6800.2(R4) U6001.A3(KSI1/GPIO30/TRACEDATA2)
KSI2: D6802.6 RP6800.3(R6) U6001.A4(KSI2/GPIO27/TRACEDATA1)
KSI3: D6802.3 RP6800.4(R8) U6001.B3(KSI3/GPIO26/TRACEDATA0)
KSI4: D6800.6 RP6800.6(R9) U6001.B4(KSI4/GPIO25/TRACECLK)
KSI5: D6800.3 RP6800.7(R7) U6001.C3(KSI5/GPIO24)
KSI6: D6803.6 RP6800.8(R5) U6001.C4(KSI6/GPIO23/S_SBUB)
KSI7: C6815.2 CON6800.20 RP6800.9(R3) U6001.C5(KSI7/GPIO22/S_SBUA)
KSI_D_0: C6801.2 CON6800.34 D6801.1
KSI_D_1: C6803.2 CON6800.31 D6801.5
KSI_D_2: C6805.2 CON6800.32 D6802.1
KSI_D_3: C6807.2 CON6800.30 D6802.5
KSI_D_4: C6809.2 CON6800.33 D6800.1
KSI_D_5: C6811.2 CON6800.22 D6800.5
KSI_D_6: C6813.2 CON6800.21 D6803.1
KSI_D_8: C6817.2 CON6800.37 D6801.2
KSI_D_9: C6819.2 CON6800.17 D6801.4
KSI_D_10: C6821.2 CON6800.35 D6802.2
KSI_D_11: C6823.2 CON6800.18 D6802.4
KSI_D_12: C6826.2 CON6800.36 D6800.2
KSI_D_13: C6827.2 CON6800.19 D6800.4
KSI_D_14: C6828.2 CON6800.38 D6803.2
KSO0: C6802.2 CON6800.41 JCN9000.17(JTAG_TCK0) U6001.B5(KSO00/GPIO21/JTAG_TCK0_SWCLK0)
KSO1: C6804.2 CON6800.23 JCN9000.18(JTAG_TMS0) U6001.B6(KSO01/GPIO20/JTAG_TMS0_SWIO0)
KSO2: C6806.2 CON6800.40 JCN9000.20(JTAG_TDI0) U6001.B7(KSO02/GPIO17/JTAG_TDI0)
KSO3: C6808.2 CON6800.29 JCN9000.19(JTAG_TDO0) U6001.B8(KSO03/GPIO16/JTAG_TDO0_SWO0)
KSO4: C6810.2 CON6800.27 U6001.C7(KSO04/GPIO15/XNOR)
KSO5: C6812.2 CON6800.39 U6001.C6(KSO05/GPIO14)
KSO6: C6814.2 CON6800.25 U6001.C8(KSO06/GPIO13)
KSO7: C6816.2 CON6800.26 JCN9000.21(JEN0#) R6075.2 U6001.B9(KSO07/GPO12/J\E\N\0\)
KSO8: C6818.2 CON6800.28 U6001.C9(KSO08/GPIO11/CR_SOUT)
KSO9: C6820.2 CON6800.16 U6001.C10(KSO09/GPIO10/CR_SIN)
KSO10: C6822.2 CON6800.24 U6001.B11(KSO10&P80_CLK/GPIO07)
KSO11: C6824.2 CON6800.42 U6001.B10(KSO11&P80_DAT/GPIO06)
KSO12: C6830.2 CON6800.15 U6001.C11(KSO12/GPIO05)
KSO13: C6831.2 CON6800.14 U6001.D11(KSO13/GPIO04)
L_SPK+: C3666.1 L3609.2 L3615.1
L_SPK+_R: C3661.2 CON3602.4 L3609.1
L_SPK-: C3667.1 L3610.2 L3616.1
L_SPK-_R: C3662.2 CON3602.3 L3610.1
LAN_DIS#: R4005.2 R4011.1 R4022.2 R4026.2 U9002.BF41(GPD11/LANPHYPC)
LAN_JTAG_TCK: R4002.1 TP4003.1 U4000.35(JTAG_TCK)
LAN_JTAG_TDI: TP4000.1 U4000.32(JTAG_TDI)
LAN_JTAG_TDO: TP4001.1 U4000.34(JTAG_TDO)
LAN_JTAG_TMS: R4001.1 TP4002.1 U4000.33(JTAG_TMS)
LAN_MCT0: C4011.2 U4001.22(MCT1)
LAN_MCT1: C4013.2 U4001.21(MCT2)
LAN_MCT2: C4015.2 U4001.16(MCT3)
LAN_MCT3: C4017.2 U4001.15(MCT4)
LAN_MX0+: CON4000.1 U4001.24(MX1+)
LAN_MX0-: CON4000.2 U4001.23(MX1-)
LAN_MX1+: CON4000.3 U4001.20(MX2+)
LAN_MX1-: CON4000.6 U4001.19(MX2-)
LAN_MX2+: CON4000.4 U4001.18(MX3+)
LAN_MX2-: CON4000.5 U4001.17(MX3-)
LAN_MX3+: CON4000.7 U4001.14(MX4+)
LAN_MX3-: CON4000.8 U4001.13(MX4-)
LAN_WAKE#: R4021.2 R9337.2
LAN_XTAL1: C4009.2 U4000.10(XTAL_IN) Y4000.3
LAN_XTAL2: R4007.1 U4000.9(XTAL_OUT)
LANLINK_STATUS#: Q4001.3(COLLECTOR) U9002.BF18(GPP_D3/SPI1_MOSI/SBK3_BK3)
LANLINK_STATUS#_R_DK: CON4000.10(A2_GREEN-) Q4000.6(D)
LANWAKE#_R: R4003.1 R4006.1 R4021.1 U4000.2(LANWAKE_N)
LANWAKE_N: R9104.1 R9337.1 R9592.1 U9002.BG44(GPD2/LAN_WAKE#)
LDO_AVDD: C3606.2 U3600.49(LDO_AVDD)
LDO_VDD_CORE: C3609.2 U3600.51(LDO_VDD_CORE)
LED#: CON6000.2 CON6000.3 Q6002.3(D) R6092.1
LED_3S_LANLINK#: Q4000.1(S) Q4001.1(EMITTER) R4010.1 U4000.26(LED0)
LED_ACT_LAN#: Q4000.4(S) U4000.27(LED1)
LED_ACT_LAN#_DK: CON4000.12(B2_AMBER-) Q4000.3(D)
LED_STANDBY#: C6022.1 Q6002.2(G) R6092.2 R6183.1 R6186.2 U6003.6(Y1)
LEFT+: TP3600.1 U3600.22(PORTG_LEFT_P)
LEFT-: TP3601.1 U3600.24(PORTG_LEFT_N)
LID_OFF_CN: Q3009.2(G) Q3009.3(D) Q3010.2(G) R3008.1
LID_SW#_3: Q6008.1(S) Q6351.5(G) R3092.1 R6053.2 R6093.1 U6001.H4(GPIO65) VC6000.1
LID_SW#_3_Q: Q6007.2(G) Q6008.3(D) R6169.2
LID_SW#_3_R: CON6000.6 R6093.2
LIMIT_SIGNAL: PCN10000.5(SIGNAL) PR12018.2
LINEOUT_L_1: C3635.1 U3601.2(LEFTINP+)
LINEOUT_R_1: C3636.1 U3601.4(RIGHTINP+)
LOW_PWR_VTG_SHIFT: PQ24000.2 PR17004.2 PU24000.4(Y)
LOW_PWR_VTG_SHIFT_N: PQ24000.3 PR17005.2 PR24002.2
LP#: PR13002.2 PR13010.2 PR17012.1 PR23007.2
LPC_ESPI_CLK_EC_R: R6134.1 U6001.M1(PCI_CLK/ESPI_CLK/GPIO55)
LPC_ESPI_CLK_R_R: JCN9000.11(LPC_ESPI_CLK) R9008.1
LPC_ESPI_RESET#_R: R6223.2 R9026.2 U6001.K3(L\R\E\S\E\T\/E\S\P\I\_\R\S\T\/G)
LPC_ESPI_RESET#_R_R: JCN9000.12(LPC_ESPI_RESET#) R9009.1
LPC_PIRQAB: R9057.2 U9002.BA36(GPP_A7/PIRQA#/ESPI_ALERT0#)
M_A_A0: JDIM1000.144(A0) JDIM1001.144(A0) U9001.AH3(DDR0_CAB_9/DDR0_MA_0)
M_A_A1: JDIM1000.133(A1) JDIM1001.133(A1) U9001.AP4(DDR0_CAB_8/DDR0_MA_1)
M_A_A2: JDIM1000.132(A2) JDIM1001.132(A2) U9001.AN4(DDR0_CAB_5/DDR0_MA_2)
M_A_A3: JDIM1000.131(A3) JDIM1001.131(A3) U9001.AP5(NC/DDR0_MA_3)
M_A_A4: JDIM1000.128(A4) JDIM1001.128(A4) U9001.AP2(NC/DDR0_MA_4)
M_A_A5: JDIM1000.126(A5) JDIM1001.126(A5) U9001.AP1(DDR0_CAA_0/DDR0_MA_5)
M_A_A6: JDIM1000.127(A6) JDIM1001.127(A6) U9001.AP3(DDR0_CAA_2/DDR0_MA_6)
M_A_A7: JDIM1000.122(A7) JDIM1001.122(A7) U9001.AN1(DDR0_CAA_4/DDR0_MA_7)
M_A_A8: JDIM1000.125(A8) JDIM1001.125(A8) U9001.AN3(DDR0_CAA_3/DDR0_MA_8)
M_A_A9: JDIM1000.121(A9) JDIM1001.121(A9) U9001.AT4(DDR0_CAA_1/DDR0_MA_9)
M_A_A10: JDIM1000.146(A10/AP) JDIM1001.146(A10/AP) U9001.AH2(DDR0_CAB_7/DDR0_MA_10)
M_A_A11: JDIM1000.120(A11) JDIM1001.120(A11) U9001.AN2(DDR0_CAA_7/DDR0_MA_11)
M_A_A12: JDIM1000.119(A12) JDIM1001.119(A12) U9001.AU4(DDR0_CAA_6/DDR0_MA_12)
M_A_A13: JDIM1000.158(A13) JDIM1001.158(A13) U9001.AE3(DDR0_CAB_0/DDR0_MA_13)
M_A_A14: JDIM1000.151(A14/WE#) JDIM1001.151(A14/WE#) U9001.AG4(DDR0_CAB_2/DDR0_MA_14)
M_A_A15: JDIM1000.156(A15/CAS#) JDIM1001.156(A15/CAS#) U9001.AD1(DDR0_CAB_1/DDR0_MA_15)
M_A_A16: JDIM1000.152(A16/RAS#) JDIM1001.152(A16/RAS#) U9001.AH4(DDR0_CAB_3/DDR0_MA_16)
M_A_BG#0: JDIM1000.115(BG0) JDIM1001.115(BG0) U9001.AU1(DDR0_CAA_5/DDR0_BG_0)
M_A_BG#1: JDIM1000.113(BG1) JDIM1001.113(BG1) U9001.AU2(DDR0_CAA_9/DDR0_BG_1)
M_A_BS#0: JDIM1000.150(BA0) JDIM1001.150(BA0) U9001.AH5(DDR0_CAB_4/DDR0_BA_0)
M_A_BS#1: JDIM1000.145(BA1) JDIM1001.145(BA1) U9001.AH1(DDR0_CAB_6/DDR0_BA_1)
M_A_CB0: JDIM1000.88(CB4) JDIM1001.88(CB4) U9001.BA2(NC/DDR0_ECC_0)
M_A_CB1: JDIM1000.92(CB0) JDIM1001.92(CB0) U9001.BA1(NC/DDR0_ECC_1)
M_A_CB2: JDIM1000.104(CB7) JDIM1001.104(CB7) U9001.AY4(NC/DDR0_ECC_2)
M_A_CB3: JDIM1000.105(CB3) JDIM1001.105(CB3) U9001.AY5(NC/DDR0_ECC_3)
M_A_CB4: JDIM1000.87(CB5) JDIM1001.87(CB5) U9001.BA5(NC/DDR0_ECC_4)
M_A_CB5: JDIM1000.91(CB1) JDIM1001.91(CB1) U9001.BA4(NC/DDR0_ECC_5)
M_A_CB6: JDIM1000.101(CB2) JDIM1001.101(CB2) U9001.AY1(NC/DDR0_ECC_6)
M_A_CB7: JDIM1000.100(CB6) JDIM1001.100(CB6) U9001.AY2(NC/DDR0_ECC_7)
M_A_CKE0: JDIM1001.109(CKE0) U9001.AT1(DDR0_CKE_0/DDR0_CKE_0)
M_A_CKE1: JDIM1001.110(CKE1) U9001.AT2(DDR0_CKE_1/DDR0_CKE_1)
M_A_CKE2: JDIM1000.109(CKE0) U9001.AT3(DDR0_CKE_2/DDR0_CKE_2)
M_A_CKE3: JDIM1000.110(CKE1) U9001.AT5(DDR0_CKE_3/DDR0_CKE_3)
M_A_CLKN0: JDIM1001.139(CK0#) U9001.AG2(DDR0_CKN_0/DDR0_CKN_0)
M_A_CLKN1: JDIM1001.140(CK1#) U9001.AK1(DDR0_CKN_1/DDR0_CKN_1)
M_A_CLKN2: JDIM1000.139(CK0#) U9001.AK3(NC/DDR0_CKN_2)
M_A_CLKN3: JDIM1000.140(CK1#) U9001.AL1(NC/DDR0_CKN_3)
M_A_CLKP0: JDIM1001.137(CK0) U9001.AG1(DDR0_CKP_0/DDR0_CKP_0)
M_A_CLKP1: JDIM1001.138(CK1) U9001.AK2(DDR0_CKP_1/DDR0_CKP_1)
M_A_CLKP2: JDIM1000.137(CK0) U9001.AL3(NC/DDR0_CKP_2)
M_A_CLKP3: JDIM1000.138(CK1) U9001.AL2(NC/DDR0_CKP_3)
M_A_CS#0: JDIM1001.149(S0#) U9001.AD5(DDR0_CS#_0/DDR0_CS#_0)
M_A_CS#1: JDIM1001.157(S1#) U9001.AE2(DDR0_CS#_1/DDR0_CS#_1)
M_A_CS#2: JDIM1000.149(S0#) U9001.AD2(NC/DDR0_CS#_2)
M_A_CS#3: JDIM1000.157(S1#) U9001.AE5(NC/DDR0_CS#_3)
M_A_DQ0: JDIM1000.7(DQ1) JDIM1001.7(DQ1) U9001.BR6(DDR0_DQ_0/DDR0_DQ_0)
M_A_DQ1: JDIM1000.16(DQ6) JDIM1001.16(DQ6) U9001.BT6(DDR0_DQ_1/DDR0_DQ_1)
M_A_DQ2: JDIM1000.20(DQ2) JDIM1001.20(DQ2) U9001.BP3(DDR0_DQ_2/DDR0_DQ_2)
M_A_DQ3: JDIM1000.3(DQ5) JDIM1001.3(DQ5) U9001.BR3(DDR0_DQ_3/DDR0_DQ_3)
M_A_DQ4: JDIM1000.8(DQ0) JDIM1001.8(DQ0) U9001.BN5(DDR0_DQ_4/DDR0_DQ_4)
M_A_DQ5: JDIM1000.4(DQ4) JDIM1001.4(DQ4) U9001.BP6(DDR0_DQ_5/DDR0_DQ_5)
M_A_DQ6: JDIM1000.17(DQ7) JDIM1001.17(DQ7) U9001.BP2(DDR0_DQ_6/DDR0_DQ_6)
M_A_DQ7: JDIM1000.21(DQ3) JDIM1001.21(DQ3) U9001.BN3(DDR0_DQ_7/DDR0_DQ_7)
M_A_DQ8: JDIM1000.28(DQ8) JDIM1001.28(DQ8) U9001.BL4(DDR0_DQ_8/DDR0_DQ_8)
M_A_DQ9: JDIM1000.24(DQ12) JDIM1001.24(DQ12) U9001.BL5(DDR0_DQ_9/DDR0_DQ_9)
M_A_DQ10: JDIM1000.38(DQ14) JDIM1001.38(DQ14) U9001.BL2(DDR0_DQ_10/DDR0_DQ_10)
M_A_DQ11: JDIM1000.42(DQ11) JDIM1001.42(DQ11) U9001.BM1(DDR0_DQ_11/DDR0_DQ_11)
M_A_DQ12: JDIM1000.29(DQ9) JDIM1001.29(DQ9) U9001.BK4(DDR0_DQ_12/DDR0_DQ_12)
M_A_DQ13: JDIM1000.25(DQ13) JDIM1001.25(DQ13) U9001.BK5(DDR0_DQ_13/DDR0_DQ_13)
M_A_DQ14: JDIM1000.41(DQ10) JDIM1001.41(DQ10) U9001.BK1(DDR0_DQ_14/DDR0_DQ_14)
M_A_DQ15: JDIM1000.37(DQ15) JDIM1001.37(DQ15) U9001.BK2(DDR0_DQ_15/DDR0_DQ_15)
M_A_DQ16: JDIM1000.46(DQ20) JDIM1001.46(DQ20) U9001.BG4(DDR0_DQ_16/DDR0_DQ_32)
M_A_DQ17: JDIM1000.50(DQ16) JDIM1001.50(DQ16) U9001.BG5(DDR0_DQ_17/DDR0_DQ_33)
M_A_DQ18: JDIM1000.63(DQ19) JDIM1001.63(DQ19) U9001.BF4(DDR0_DQ_18/DDR0_DQ_34)
M_A_DQ19: JDIM1000.58(DQ22) JDIM1001.58(DQ22) U9001.BF5(DDR0_DQ_19/DDR0_DQ_35)
M_A_DQ20: JDIM1000.49(DQ17) JDIM1001.49(DQ17) U9001.BG2(DDR0_DQ_20/DDR0_DQ_36)
M_A_DQ21: JDIM1000.45(DQ21) JDIM1001.45(DQ21) U9001.BG1(DDR0_DQ_21/DDR0_DQ_37)
M_A_DQ22: JDIM1000.62(DQ18) JDIM1001.62(DQ18) U9001.BF1(DDR0_DQ_22/DDR0_DQ_38)
M_A_DQ23: JDIM1000.59(DQ23) JDIM1001.59(DQ23) U9001.BF2(DDR0_DQ_23/DDR0_DQ_39)
M_A_DQ24: JDIM1000.66(DQ28) JDIM1001.66(DQ28) U9001.BD2(DDR0_DQ_24/DDR0_DQ_40)
M_A_DQ25: JDIM1000.67(DQ29) JDIM1001.67(DQ29) U9001.BD1(DDR0_DQ_25/DDR0_DQ_41)
M_A_DQ26: JDIM1000.80(DQ31) JDIM1001.80(DQ31) U9001.BC4(DDR0_DQ_26/DDR0_DQ_42)
M_A_DQ27: JDIM1000.84(DQ27) JDIM1001.84(DQ27) U9001.BC5(DDR0_DQ_27/DDR0_DQ_43)
M_A_DQ28: JDIM1000.71(DQ25) JDIM1001.71(DQ25) U9001.BD5(DDR0_DQ_28/DDR0_DQ_44)
M_A_DQ29: JDIM1000.70(DQ24) JDIM1001.70(DQ24) U9001.BD4(DDR0_DQ_29/DDR0_DQ_45)
M_A_DQ30: JDIM1000.83(DQ26) JDIM1001.83(DQ26) U9001.BC1(DDR0_DQ_30/DDR0_DQ_46)
M_A_DQ31: JDIM1000.79(DQ30) JDIM1001.79(DQ30) U9001.BC2(DDR0_DQ_31/DDR0_DQ_47)
M_A_DQ32: JDIM1000.174(DQ32) JDIM1001.174(DQ32) U9001.AB1(DDR0_DQ_32/DDR1_DQ_0)
M_A_DQ33: JDIM1000.169(DQ37) JDIM1001.169(DQ37) U9001.AB2(DDR0_DQ_33/DDR1_DQ_1)
M_A_DQ34: JDIM1000.186(DQ35) JDIM1001.186(DQ35) U9001.AA4(DDR0_DQ_34/DDR1_DQ_2)
M_A_DQ35: JDIM1000.182(DQ39) JDIM1001.182(DQ39) U9001.AA5(DDR0_DQ_35/DDR1_DQ_3)
M_A_DQ36: JDIM1000.170(DQ36) JDIM1001.170(DQ36) U9001.AB5(DDR0_DQ_36/DDR1_DQ_4)
M_A_DQ37: JDIM1000.173(DQ33) JDIM1001.173(DQ33) U9001.AB4(DDR0_DQ_37/DDR1_DQ_5)
M_A_DQ38: JDIM1000.183(DQ38) JDIM1001.183(DQ38) U9001.AA2(DDR0_DQ_38/DDR1_DQ_6)
M_A_DQ39: JDIM1000.187(DQ34) JDIM1001.187(DQ34) U9001.AA1(DDR0_DQ_39/DDR1_DQ_7)
M_A_DQ40: JDIM1000.190(DQ45) JDIM1001.190(DQ45) U9001.V5(DDR0_DQ_40/DDR1_DQ_8)
M_A_DQ41: JDIM1000.191(DQ44) JDIM1001.191(DQ44) U9001.V2(DDR0_DQ_41/DDR1_DQ_9)
M_A_DQ42: JDIM1000.208(DQ43) JDIM1001.208(DQ43) U9001.U1(DDR0_DQ_42/DDR1_DQ_10)
M_A_DQ43: JDIM1000.203(DQ46) JDIM1001.203(DQ46) U9001.U2(DDR0_DQ_43/DDR1_DQ_11)
M_A_DQ44: JDIM1000.195(DQ40) JDIM1001.195(DQ40) U9001.V1(DDR0_DQ_44/DDR1_DQ_12)
M_A_DQ45: JDIM1000.194(DQ41) JDIM1001.194(DQ41) U9001.V4(DDR0_DQ_45/DDR1_DQ_13)
M_A_DQ46: JDIM1000.207(DQ42) JDIM1001.207(DQ42) U9001.U5(DDR0_DQ_46/DDR1_DQ_14)
M_A_DQ47: JDIM1000.204(DQ47) JDIM1001.204(DQ47) U9001.U4(DDR0_DQ_47/DDR1_DQ_15)
M_A_DQ48: JDIM1000.229(DQ51) JDIM1001.229(DQ51) U9001.R2(DDR0_DQ_48/DDR1_DQ_32)
M_A_DQ49: JDIM1000.225(DQ55) JDIM1001.225(DQ55) U9001.P5(DDR0_DQ_49/DDR1_DQ_33)
M_A_DQ50: JDIM1000.211(DQ52) JDIM1001.211(DQ52) U9001.R4(DDR0_DQ_50/DDR1_DQ_34)
M_A_DQ51: JDIM1000.216(DQ48) JDIM1001.216(DQ48) U9001.P4(DDR0_DQ_51/DDR1_DQ_35)
M_A_DQ52: JDIM1000.215(DQ49) JDIM1001.215(DQ49) U9001.R5(DDR0_DQ_52/DDR1_DQ_36)
M_A_DQ53: JDIM1000.224(DQ54) JDIM1001.224(DQ54) U9001.P2(DDR0_DQ_53/DDR1_DQ_37)
M_A_DQ54: JDIM1000.212(DQ53) JDIM1001.212(DQ53) U9001.R1(DDR0_DQ_54/DDR1_DQ_38)
M_A_DQ55: JDIM1000.228(DQ50) JDIM1001.228(DQ50) U9001.P1(DDR0_DQ_55/DDR1_DQ_39)
M_A_DQ56: JDIM1000.232(DQ60) JDIM1001.232(DQ60) U9001.M4(DDR0_DQ_56/DDR1_DQ_40)
M_A_DQ57: JDIM1000.233(DQ61) JDIM1001.233(DQ61) U9001.M1(DDR0_DQ_57/DDR1_DQ_41)
M_A_DQ58: JDIM1000.250(DQ59) JDIM1001.250(DQ59) U9001.L4(DDR0_DQ_58/DDR1_DQ_42)
M_A_DQ59: JDIM1000.245(DQ62) JDIM1001.245(DQ62) U9001.L2(DDR0_DQ_59/DDR1_DQ_43)
M_A_DQ60: JDIM1000.236(DQ57) JDIM1001.236(DQ57) U9001.M5(DDR0_DQ_60/DDR1_DQ_44)
M_A_DQ61: JDIM1000.237(DQ56) JDIM1001.237(DQ56) U9001.M2(DDR0_DQ_61/DDR1_DQ_45)
M_A_DQ62: JDIM1000.246(DQ63) JDIM1001.246(DQ63) U9001.L5(DDR0_DQ_62/DDR1_DQ_46)
M_A_DQ63: JDIM1000.249(DQ58) JDIM1001.249(DQ58) U9001.L1(DDR0_DQ_63/DDR1_DQ_47)
M_A_DQSN0: JDIM1000.11(DQS#0) JDIM1001.11(DQS#0) U9001.BR5(DDR0_DQSN_0/DDR0_DQSN_0)
M_A_DQSN1: JDIM1000.32(DQS#1) JDIM1001.32(DQS#1) U9001.BL3(DDR0_DQSN_1/DDR0_DQSN_1)
M_A_DQSN2: JDIM1000.53(DQS#2) JDIM1001.53(DQS#2) U9001.BG3(DDR0_DQSN_2/DDR0_DQSN_4)
M_A_DQSN3: JDIM1000.74(DQS#3) JDIM1001.74(DQS#3) U9001.BD3(DDR0_DQSN_3/DDR0_DQSN_5)
M_A_DQSN4: JDIM1000.177(DQS#4) JDIM1001.177(DQS#4) U9001.AA3(DDR0_DQSN_4/DDR1_DQSN_0)
M_A_DQSN5: JDIM1000.198(DQS#5) JDIM1001.198(DQS#5) U9001.U3(DDR0_DQSN_5/DDR1_DQSN_1)
M_A_DQSN6: JDIM1000.219(DQS#6) JDIM1001.219(DQS#6) U9001.P3(DDR0_DQSN_6/DDR1_DQSN_4)
M_A_DQSN7: JDIM1000.240(DQS#7) JDIM1001.240(DQS#7) U9001.L3(DDR0_DQSN_7/DDR1_DQSN_5)
M_A_DQSN8: JDIM1000.95(DQS#8) JDIM1001.95(DQS#8) U9001.BA3(DDR0_DQSN_8/DDR0_DQSN_8)
M_A_DQSP0: JDIM1000.13(DQS0) JDIM1001.13(DQS0) U9001.BP5(DDR0_DQSP_0/DDR0_DQSP_0)
M_A_DQSP1: JDIM1000.34(DQS1) JDIM1001.34(DQS1) U9001.BK3(DDR0_DQSP_1/DDR0_DQSP_1)
M_A_DQSP2: JDIM1000.55(DQS2) JDIM1001.55(DQS2) U9001.BF3(DDR0_DQSP_2/DDR0_DQSP_4)
M_A_DQSP3: JDIM1000.76(DQS3) JDIM1001.76(DQS3) U9001.BC3(DDR0_DQSP_3/DDR0_DQSP_5)
M_A_DQSP4: JDIM1000.179(DQS4) JDIM1001.179(DQS4) U9001.AB3(DDR0_DQSP_4/DDR1_DQSP_0)
M_A_DQSP5: JDIM1000.200(DQS5) JDIM1001.200(DQS5) U9001.V3(DDR0_DQSP_5/DDR1_DQSP_1)
M_A_DQSP6: JDIM1000.221(DQS6) JDIM1001.221(DQS6) U9001.R3(DDR0_DQSP_6/DDR1_DQSP_4)
M_A_DQSP7: JDIM1000.242(DQS7) JDIM1001.242(DQS7) U9001.M3(DDR0_DQSP_7/DDR1_DQSP_5)
M_A_DQSP8: JDIM1000.97(DQS8) JDIM1001.97(DQS8) U9001.AY3(DDR0_DQSP_8/DDR0_DQSP_8)
M_A_ODT0: JDIM1001.155(ODT0) U9001.AD3(DDR0_ODT_0/DDR0_ODT_0)
M_A_ODT1: JDIM1001.161(ODT1) U9001.AE4(NC/DDR0_ODT_1)
M_A_ODT2: JDIM1000.155(ODT0) U9001.AE1(NC/DDR0_ODT_2)
M_A_ODT3: JDIM1000.161(ODT1) U9001.AD4(NC/DDR0_ODT_3)
M_B_A0: JDIM1002.144(A0) JDIM1003.144(A0) U9001.AJ9(DDR1_CAB_9/DDR1_MA_0)
M_B_A1: JDIM1002.133(A1) JDIM1003.133(A1) U9001.AK6(DDR1_CAB_8/DDR1_MA_1)
M_B_A2: JDIM1002.132(A2) JDIM1003.132(A2) U9001.AK5(DDR1_CAB_5/DDR1_MA_2)
M_B_A3: JDIM1002.131(A3) JDIM1003.131(A3) U9001.AL5(NC/DDR1_MA_3)
M_B_A4: JDIM1002.128(A4) JDIM1003.128(A4) U9001.AL6(NC/DDR1_MA_4)
M_B_A5: JDIM1002.126(A5) JDIM1003.126(A5) U9001.AM6(DDR1_CAA_0/DDR1_MA_5)
M_B_A6: JDIM1002.127(A6) JDIM1003.127(A6) U9001.AN7(DDR1_CAA_2/DDR1_MA_6)
M_B_A7: JDIM1002.122(A7) JDIM1003.122(A7) U9001.AN10(DDR1_CAA_4/DDR1_MA_7)
M_B_A8: JDIM1002.125(A8) JDIM1003.125(A8) U9001.AN8(DDR1_CAA_3/DDR1_MA_8)
M_B_A9: JDIM1002.121(A9) JDIM1003.121(A9) U9001.AR11(DDR1_CAA_1/DDR1_MA_9)
M_B_A10: JDIM1002.146(A10/AP) JDIM1003.146(A10/AP) U9001.AH7(DDR1_CAB_7/DDR1_MA_10)
M_B_A11: JDIM1002.120(A11) JDIM1003.120(A11) U9001.AN11(DDR1_CAA_7/DDR1_MA_11)
M_B_A12: JDIM1002.119(A12) JDIM1003.119(A12) U9001.AR10(DDR1_CAA_6/DDR1_MA_12)
M_B_A13: JDIM1002.158(A13) JDIM1003.158(A13) U9001.AF9(DDR1_CAB_0/DDR1_MA_13)
M_B_A14: JDIM1002.151(A14/WE#) JDIM1003.151(A14/WE#) U9001.AH11(DDR1_CAB_2/DDR1_MA_14)
M_B_A15: JDIM1002.156(A15/CAS#) JDIM1003.156(A15/CAS#) U9001.AF8(DDR1_CAB_1/DDR1_MA_15)
M_B_A16: JDIM1002.152(A16/RAS#) JDIM1003.152(A16/RAS#) U9001.AH10(DDR1_CAB_3/DDR1_MA_16)
M_B_BG#0: JDIM1002.115(BG0) JDIM1003.115(BG0) U9001.AR9(DDR1_CAA_5/DDR1_BG_0)
M_B_BG#1: JDIM1002.113(BG1) JDIM1003.113(BG1) U9001.AR7(DDR1_CAA_9/DDR1_BG_1)
M_B_BS#0: JDIM1002.150(BA0) JDIM1003.150(BA0) U9001.AH8(DDR1_CAB_4/DDR1_BA_0)
M_B_BS#1: JDIM1002.145(BA1) JDIM1003.145(BA1) U9001.AH9(DDR1_CAB_6/DDR1_BA_1)
M_B_CB0: JDIM1002.104(CB7) JDIM1003.104(CB7) U9001.AW11(NC/DDR1_ECC_0)
M_B_CB1: JDIM1002.88(CB4) JDIM1003.88(CB4) U9001.AY11(NC/DDR1_ECC_1)
M_B_CB2: JDIM1002.91(CB1) JDIM1003.91(CB1) U9001.AY8(NC/DDR1_ECC_2)
M_B_CB3: JDIM1002.105(CB3) JDIM1003.105(CB3) U9001.AW8(NC/DDR1_ECC_3)
M_B_CB4: JDIM1002.87(CB5) JDIM1003.87(CB5) U9001.AY10(NC/DDR1_ECC_4)
M_B_CB5: JDIM1002.100(CB6) JDIM1003.100(CB6) U9001.AW10(NC/DDR1_ECC_5)
M_B_CB6: JDIM1002.92(CB0) JDIM1003.92(CB0) U9001.AY7(NC/DDR1_ECC_6)
M_B_CB7: JDIM1002.101(CB2) JDIM1003.101(CB2) U9001.AW7(NC/DDR1_ECC_7)
M_B_CKE0: JDIM1002.109(CKE0) U9001.AT8(DDR1_CKE_0/DDR1_CKE_0)
M_B_CKE1: JDIM1002.110(CKE1) U9001.AT10(DDR1_CKE_1/DDR1_CKE_1)
M_B_CKE2: JDIM1003.109(CKE0) U9001.AT7(DDR1_CKE_2/DDR1_CKE_2)
M_B_CKE3: JDIM1003.110(CKE1) U9001.AT11(DDR1_CKE_3/DDR1_CKE_3)
M_B_CLKN0: JDIM1002.139(CK0#) U9001.AN9(DDR1_CKN_0/DDR1_CKN_0)
M_B_CLKN1: JDIM1002.140(CK1#) U9001.AM8(DDR1_CKN_1/DDR1_CKN_1)
M_B_CLKN2: JDIM1003.139(CK0#) U9001.AM10(NC/DDR1_CKN_2)
M_B_CLKN3: JDIM1003.140(CK1#) U9001.AJ11(NC/DDR1_CKN_3)
M_B_CLKP0: JDIM1002.137(CK0) U9001.AM9(DDR1_CKP_0/DDR1_CKP_0)
M_B_CLKP1: JDIM1002.138(CK1) U9001.AM7(DDR1_CKP_1/DDR1_CKP_1)
M_B_CLKP2: JDIM1003.137(CK0) U9001.AM11(NC/DDR1_CKP_2)
M_B_CLKP3: JDIM1003.138(CK1) U9001.AJ10(NC/DDR1_CKP_3)
M_B_CS#0: JDIM1002.149(S0#) U9001.AF11(DDR1_CS#_0/DDR1_CS#_0)
M_B_CS#1: JDIM1002.157(S1#) U9001.AE7(DDR1_CS#_1/DDR1_CS#_1)
M_B_CS#2: JDIM1003.149(S0#) U9001.AF10(NC/DDR1_CS#_2)
M_B_CS#3: JDIM1003.157(S1#) U9001.AE10(NC/DDR1_CS#_3)
M_B_DQ0: JDIM1002.3(DQ5) JDIM1003.3(DQ5) U9001.BT11(DDR1_DQ_0/DDR0_DQ_16)
M_B_DQ1: JDIM1002.4(DQ4) JDIM1003.4(DQ4) U9001.BR11(DDR1_DQ_1/DDR0_DQ_17)
M_B_DQ2: JDIM1002.21(DQ3) JDIM1003.21(DQ3) U9001.BT9(DDR1_DQ_2/DDR0_DQ_18)
M_B_DQ3: JDIM1002.16(DQ6) JDIM1003.16(DQ6) U9001.BR8(DDR1_DQ_3/DDR0_DQ_19)
M_B_DQ4: JDIM1002.8(DQ0) JDIM1003.8(DQ0) U9001.BP11(DDR1_DQ_4/DDR0_DQ_20)
M_B_DQ5: JDIM1002.7(DQ1) JDIM1003.7(DQ1) U9001.BN11(DDR1_DQ_5/DDR0_DQ_21)
M_B_DQ6: JDIM1002.17(DQ7) JDIM1003.17(DQ7) U9001.BP8(DDR1_DQ_6/DDR0_DQ_22)
M_B_DQ7: JDIM1002.20(DQ2) JDIM1003.20(DQ2) U9001.BN8(DDR1_DQ_7/DDR0_DQ_23)
M_B_DQ8: JDIM1002.24(DQ12) JDIM1003.24(DQ12) U9001.BL12(DDR1_DQ_8/DDR0_DQ_24)
M_B_DQ9: JDIM1002.28(DQ8) JDIM1003.28(DQ8) U9001.BL11(DDR1_DQ_9/DDR0_DQ_25)
M_B_DQ10: JDIM1002.25(DQ13) JDIM1003.25(DQ13) U9001.BL8(DDR1_DQ_10/DDR0_DQ_26)
M_B_DQ11: JDIM1002.38(DQ14) JDIM1003.38(DQ14) U9001.BJ8(DDR1_DQ_11/DDR0_DQ_27)
M_B_DQ12: JDIM1002.37(DQ15) JDIM1003.37(DQ15) U9001.BJ11(DDR1_DQ_12/DDR0_DQ_28)
M_B_DQ13: JDIM1002.41(DQ10) JDIM1003.41(DQ10) U9001.BJ10(DDR1_DQ_13/DDR0_DQ_29)
M_B_DQ14: JDIM1002.29(DQ9) JDIM1003.29(DQ9) U9001.BL7(DDR1_DQ_14/DDR0_DQ_30)
M_B_DQ15: JDIM1002.42(DQ11) JDIM1003.42(DQ11) U9001.BJ7(DDR1_DQ_15/DDR0_DQ_31)
M_B_DQ16: JDIM1002.50(DQ16) JDIM1003.50(DQ16) U9001.BG11(DDR1_DQ_16/DDR0_DQ_48)
M_B_DQ17: JDIM1002.46(DQ20) JDIM1003.46(DQ20) U9001.BG10(DDR1_DQ_17/DDR0_DQ_49)
M_B_DQ18: JDIM1002.49(DQ17) JDIM1003.49(DQ17) U9001.BG8(DDR1_DQ_18/DDR0_DQ_50)
M_B_DQ19: JDIM1002.62(DQ18) JDIM1003.62(DQ18) U9001.BF8(DDR1_DQ_19/DDR0_DQ_51)
M_B_DQ20: JDIM1002.63(DQ19) JDIM1003.63(DQ19) U9001.BF11(DDR1_DQ_20/DDR0_DQ_52)
M_B_DQ21: JDIM1002.59(DQ23) JDIM1003.59(DQ23) U9001.BF10(DDR1_DQ_21/DDR0_DQ_53)
M_B_DQ22: JDIM1002.45(DQ21) JDIM1003.45(DQ21) U9001.BG7(DDR1_DQ_22/DDR0_DQ_54)
M_B_DQ23: JDIM1002.58(DQ22) JDIM1003.58(DQ22) U9001.BF7(DDR1_DQ_23/DDR0_DQ_55)
M_B_DQ24: JDIM1002.83(DQ26) JDIM1003.83(DQ26) U9001.BB11(DDR1_DQ_24/DDR0_DQ_56)
M_B_DQ25: JDIM1002.66(DQ28) JDIM1003.66(DQ28) U9001.BC11(DDR1_DQ_25/DDR0_DQ_57)
M_B_DQ26: JDIM1002.80(DQ31) JDIM1003.80(DQ31) U9001.BB8(DDR1_DQ_26/DDR0_DQ_58)
M_B_DQ27: JDIM1002.70(DQ24) JDIM1003.70(DQ24) U9001.BC8(DDR1_DQ_27/DDR0_DQ_59)
M_B_DQ28: JDIM1002.67(DQ29) JDIM1003.67(DQ29) U9001.BC10(DDR1_DQ_28/DDR0_DQ_60)
M_B_DQ29: JDIM1002.84(DQ27) JDIM1003.84(DQ27) U9001.BB10(DDR1_DQ_29/DDR0_DQ_61)
M_B_DQ30: JDIM1002.71(DQ25) JDIM1003.71(DQ25) U9001.BC7(DDR1_DQ_30/DDR0_DQ_62)
M_B_DQ31: JDIM1002.79(DQ30) JDIM1003.79(DQ30) U9001.BB7(DDR1_DQ_31/DDR0_DQ_63)
M_B_DQ32: JDIM1002.187(DQ34) JDIM1003.187(DQ34) U9001.AA11(DDR1_DQ_32/DDR1_DQ_16)
M_B_DQ33: JDIM1002.183(DQ38) JDIM1003.183(DQ38) U9001.AA10(DDR1_DQ_33/DDR1_DQ_17)
M_B_DQ34: JDIM1002.170(DQ36) JDIM1003.170(DQ36) U9001.AC11(DDR1_DQ_34/DDR1_DQ_18)
M_B_DQ35: JDIM1002.173(DQ33) JDIM1003.173(DQ33) U9001.AC10(DDR1_DQ_35/DDR1_DQ_19)
M_B_DQ36: JDIM1002.182(DQ39) JDIM1003.182(DQ39) U9001.AA7(DDR1_DQ_36/DDR1_DQ_20)
M_B_DQ37: JDIM1002.186(DQ35) JDIM1003.186(DQ35) U9001.AA8(DDR1_DQ_37/DDR1_DQ_21)
M_B_DQ38: JDIM1002.169(DQ37) JDIM1003.169(DQ37) U9001.AC8(DDR1_DQ_38/DDR1_DQ_22)
M_B_DQ39: JDIM1002.174(DQ32) JDIM1003.174(DQ32) U9001.AC7(DDR1_DQ_39/DDR1_DQ_23)
M_B_DQ40: JDIM1002.191(DQ44) JDIM1003.191(DQ44) U9001.W8(DDR1_DQ_40/DDR1_DQ_24)
M_B_DQ41: JDIM1002.195(DQ40) JDIM1003.195(DQ40) U9001.W7(DDR1_DQ_41/DDR1_DQ_25)
M_B_DQ42: JDIM1002.203(DQ46) JDIM1003.203(DQ46) U9001.V10(DDR1_DQ_42/DDR1_DQ_26)
M_B_DQ43: JDIM1002.208(DQ43) JDIM1003.208(DQ43) U9001.V11(DDR1_DQ_43/DDR1_DQ_27)
M_B_DQ44: JDIM1002.190(DQ45) JDIM1003.190(DQ45) U9001.W11(DDR1_DQ_44/DDR1_DQ_28)
M_B_DQ45: JDIM1002.194(DQ41) JDIM1003.194(DQ41) U9001.W10(DDR1_DQ_45/DDR1_DQ_29)
M_B_DQ46: JDIM1002.207(DQ42) JDIM1003.207(DQ42) U9001.V7(DDR1_DQ_46/DDR1_DQ_30)
M_B_DQ47: JDIM1002.204(DQ47) JDIM1003.204(DQ47) U9001.V8(DDR1_DQ_47/DDR1_DQ_31)
M_B_DQ48: JDIM1002.215(DQ49) JDIM1003.215(DQ49) U9001.R11(DDR1_DQ_48/DDR1_DQ_48)
M_B_DQ49: JDIM1002.229(DQ51) JDIM1003.229(DQ51) U9001.P11(DDR1_DQ_49/DDR1_DQ_49)
M_B_DQ50: JDIM1002.225(DQ55) JDIM1003.225(DQ55) U9001.P7(DDR1_DQ_50/DDR1_DQ_50)
M_B_DQ51: JDIM1002.212(DQ53) JDIM1003.212(DQ53) U9001.R8(DDR1_DQ_51/DDR1_DQ_51)
M_B_DQ52: JDIM1002.211(DQ52) JDIM1003.211(DQ52) U9001.R10(DDR1_DQ_52/DDR1_DQ_52)
M_B_DQ53: JDIM1002.228(DQ50) JDIM1003.228(DQ50) U9001.P10(DDR1_DQ_53/DDR1_DQ_53)
M_B_DQ54: JDIM1002.216(DQ48) JDIM1003.216(DQ48) U9001.R7(DDR1_DQ_54/DDR1_DQ_54)
M_B_DQ55: JDIM1002.224(DQ54) JDIM1003.224(DQ54) U9001.P8(DDR1_DQ_55/DDR1_DQ_55)
M_B_DQ56: JDIM1002.245(DQ62) JDIM1003.245(DQ62) U9001.L11(DDR1_DQ_56/DDR1_DQ_56)
M_B_DQ57: JDIM1002.233(DQ61) JDIM1003.233(DQ61) U9001.M11(DDR1_DQ_57/DDR1_DQ_57)
M_B_DQ58: JDIM1002.250(DQ59) JDIM1003.250(DQ59) U9001.L7(DDR1_DQ_58/DDR1_DQ_58)
M_B_DQ59: JDIM1002.232(DQ60) JDIM1003.232(DQ60) U9001.M8(DDR1_DQ_59/DDR1_DQ_59)
M_B_DQ60: JDIM1002.249(DQ58) JDIM1003.249(DQ58) U9001.L10(DDR1_DQ_60/DDR1_DQ_60)
M_B_DQ61: JDIM1002.237(DQ56) JDIM1003.237(DQ56) U9001.M10(DDR1_DQ_61/DDR1_DQ_61)
M_B_DQ62: JDIM1002.236(DQ57) JDIM1003.236(DQ57) U9001.M7(DDR1_DQ_62/DDR1_DQ_62)
M_B_DQ63: JDIM1002.246(DQ63) JDIM1003.246(DQ63) U9001.L8(DDR1_DQ_63/DDR1_DQ_63)
M_B_DQSN0: JDIM1002.11(DQS#0) JDIM1003.11(DQS#0) U9001.BN9(DDR1_DQSN_0/DDR0_DQSN_2)
M_B_DQSN1: JDIM1002.32(DQS#1) JDIM1003.32(DQS#1) U9001.BL9(DDR1_DQSN_1/DDR0_DQSN_3)
M_B_DQSN2: JDIM1002.53(DQS#2) JDIM1003.53(DQS#2) U9001.BG9(DDR1_DQSN_2/DDR0_DQSN_6)
M_B_DQSN3: JDIM1002.74(DQS#3) JDIM1003.74(DQS#3) U9001.BC9(DDR1_DQSN_3/DDR0_DQSN_7)
M_B_DQSN4: JDIM1002.177(DQS#4) JDIM1003.177(DQS#4) U9001.AC9(DDR1_DQSN_4/DDR1_DQSN_2)
M_B_DQSN5: JDIM1002.198(DQS#5) JDIM1003.198(DQS#5) U9001.W9(DDR1_DQSN_5/DDR1_DQSN_3)
M_B_DQSN6: JDIM1002.219(DQS#6) JDIM1003.219(DQS#6) U9001.R9(DDR1_DQSN_6/DDR1_DQSN_6)
M_B_DQSN7: JDIM1002.240(DQS#7) JDIM1003.240(DQS#7) U9001.M9(DDR1_DQSN_7/DDR1_DQSN_7)
M_B_DQSN8: JDIM1002.95(DQS#8) JDIM1003.95(DQS#8) U9001.AY9(DDR1_DQSN_8/DDR1_DQSN_8)
M_B_DQSP0: JDIM1002.13(DQS0) JDIM1003.13(DQS0) U9001.BP9(DDR1_DQSP_0/DDR0_DQSP_2)
M_B_DQSP1: JDIM1002.34(DQS1) JDIM1003.34(DQS1) U9001.BJ9(DDR1_DQSP_1/DDR0_DQSP_3)
M_B_DQSP2: JDIM1002.55(DQS2) JDIM1003.55(DQS2) U9001.BF9(DDR1_DQSP_2/DDR0_DQSP_6)
M_B_DQSP3: JDIM1002.76(DQS3) JDIM1003.76(DQS3) U9001.BB9(DDR1_DQSP_3/DDR0_DQSP_7)
M_B_DQSP4: JDIM1002.179(DQS4) JDIM1003.179(DQS4) U9001.AA9(DDR1_DQSP_4/DDR1_DQSP_2)
M_B_DQSP5: JDIM1002.200(DQS5) JDIM1003.200(DQS5) U9001.V9(DDR1_DQSP_5/DDR1_DQSP_3)
M_B_DQSP6: JDIM1002.221(DQS6) JDIM1003.221(DQS6) U9001.P9(DDR1_DQSP_6/DDR1_DQSP_6)
M_B_DQSP7: JDIM1002.242(DQS7) JDIM1003.242(DQS7) U9001.L9(DDR1_DQSP_7/DDR1_DQSP_7)
M_B_DQSP8: JDIM1002.97(DQS8) JDIM1003.97(DQS8) U9001.AW9(DDR1_DQSP_8/DDR1_DQSP_8)
M_B_ODT0: JDIM1002.155(ODT0) U9001.AF7(DDR1_ODT_0/DDR1_ODT_0)
M_B_ODT1: JDIM1002.161(ODT1) U9001.AE8(NC/DDR1_ODT_1)
M_B_ODT2: JDIM1003.155(ODT0) U9001.AE9(NC/DDR1_ODT_2)
M_B_ODT3: JDIM1003.161(ODT1) U9001.AE11(NC/DDR1_ODT_3)
MAIN_BAT_DET#: PR11021.1 PR12014.1
MDI0+: U4000.13(MDI_PLUS0) U4001.1(TD1+)
MDI0-: U4000.14(MDI_MINUS0) U4001.2(TD1-\)
MDI1+: U4000.17(MDI_PLUS1) U4001.5(TD2+)
MDI1-: U4000.18(MDI_MINUS1) U4001.6(TD2-)
MDI2+: U4000.20(MDI_PLUS2) U4001.7(TD3+)
MDI2-: U4000.21(MDI_MINUS2) U4001.8(TD3-)
MDI3+: U4000.23(MDI_PLUS3) U4001.11(TD4+)
MDI3-: U4000.24(MDI_MINUS3) U4001.12(TD4-)
ME_UNLOCK#: Q9006.2 R6050.2 U6001.G4(GPIO64)
MEM_VDD_CTRL: PR8018.1 R2088.2 U2000.L3(GPIO8)
MEM_VREF_CTL: Q2500.2(G) Q2501.2(G) R2081.2 U2000.L1(GPIO10)
MEM_VREF_CTL_QA: Q2500.3(D) R2508.1
MEM_VREF_CTL_QB: Q2501.3(D) R2523.1
MID1: R9157.2 R9158.1 U9002.AM43(GPP_F2/SATAXPCIE5/SATAGP5)
MID2: R9159.2 R9160.1 U9002.AM47(GPP_F3/SATAXPCIE6/SATAGP6)
MOD_ID1_TBT: R8505.2 R8506.1 U8500.A8(UART_TX_P1/GPIO_P4.0)
MOD_ID2_TBT: R8507.1 R8512.1 U8500.A9(UART_RX_P1/GPIO_P4.1)
MODEM_CLKREQ: R4132.1 R9607.1 U9002.BA17(GPP_D6/I2S2_TXD/MODEM_CLKREQ)
MODEM_CLKREQ_R: R4134.1 U4102.4(Y)
MP2949A_ADDR_P: PR19030.2 PR19031.1 PU19000.25(ADDR_P)
MP2949A_ALT#: PR19023.1 PU19000.29(ALT#)
MP2949A_EN: PC19005.1 PR19010.1 PU19000.37(EN)
MP2949A_IMONA: PC19009.2 PR19041.2 PU19000.21(IMONA)
MP2949A_IMONB: PC19010.2 PR19043.2 PU19000.22(IMONB)
MP2949A_IMONC: PC19011.2 PR19045.2 PU19000.23(IMONC)
MP2949A_IREF: PR19036.2 PU19000.24(IREF)
MP2949A_PE: PC19007.1 PR19029.1 PR19034.1 PR19057.2 PU19000.36(PE)
MP2949A_SCL_P: PR19014.2 PU19000.33(SCL_P)
MP2949A_SCLK: PR19028.2 PU19000.27(SCLK)
MP2949A_SDA_P: PR19016.2 PU19000.32(SDA_P)
MP2949A_SDIO: PR19025.2 PU19000.28(SDIO)
MP2949A_SLP_SO#: PR19005.1 PR19012.2 PU19000.35(SLP_S0#)
MP2949A_STB: PR19011.1 PU19000.34(STB)
MP2949A_TEMP: PC19014.2 PR19052.2 PR19056.1 PU19000.45(TEMP)
MP2949A_VDD18: PC19003.2 PR19030.1 PU19000.26(VDD18)
MP2949A_VIN_SEN: PC19004.2 PR19008.2 PR19009.2 PU19000.47(VIN_SEN)
MP2949A_VRHOT#: PR19019.2 PU19000.31(VRHOT#)
MP2949A_VRRDY: PR19021.1 PU19000.30(VRRDY)
MPHY_EXT_PWR_GATE: R9068.1 TP9016.1 U9002.AP29(GPP_B11/I2S_MCLK)
MSR_ENABLE_N: CON400.60(GND17) R406.2
NB679A_AGND: PC13007.2 PR13001.2 PU13000.10(AGND)
NB679A_BST: PR13000.1 PU13000.8(BST)
NB679A_EN: PC13014.2 PR13006.2 PU13000.11(EN)
NB679A_LP#: PR13002.1 PR13005.2 PU13000.12(LP#)
NB679A_PG: PR13007.2 PU13000.3(PG)
NB679A_SW: PC13006.2 PL13001.1 PR13003.2 PU13000.7(SW)
NB679A_VCC: PC13007.1 PU13000.9(VCC)
NB679A_VOUT: PR13004.1 PU13000.5(VOUT)
NB680A_AGND: PC13021.2 PR13008.2 PU13001.10(AGND)
NB680A_BST: PR13009.1 PU13001.8(BST)
NB680A_EN: PC13029.2 PR13014.1 PU13001.11(EN)
NB680A_LP#: PR13010.1 PR13013.2 PU13001.12(LP#)
NB680A_PG: PR13015.2 PU13001.3(PG)
NB680A_SW: PC13022.2 PL13003.1 PR13011.2 PU13001.7(SW)
NB680A_VCC: PC13021.1 PU13001.9(VCC)
NB680A_VOUT: PR13012.1 PU13001.5(VOUT)
NB681_3.3_1.8: PC16000.1 PR16000.2 PU16000.10(3V3)
NB681_3.3_2.5: PC15000.2 PR15000.2 PU15000.10(3V3)
NB681BST_1.8: PR16004.2 PU16000.9(BST)
NB681BST_2.5: PR15003.2 PU15000.9(BST)
NB681BST_S_1.8: PC16006.1 PR16004.1
NB681BST_S_2.5: PC15006.1 PR15003.1
NB681EN_1.8: PC16012.2 PR16013.2 PU16000.5(EN)
NB681EN_2.5: PC15007.2 PR15002.2 PR15004.2 PU15000.5(EN)
NB681FB_1.8: PR16006.1 PU16000.12(VOUT)
NB681FB_2.5: PR15006.1 PU15000.12(VOUT)
NB681PG_1.8: PR16014.2 PU16000.13(PG)
NB681PG_2.5: PR15012.2 PU15000.13(PG)
NB681SW_1.8: PC16006.2 PL16001.1 PR16005.2 PU16000.8(SW)
NB681SW_2.5: PC15006.2 PL15001.1 PR15005.2 PU15000.8(SW)
NB685BST: PR14003.2 PU14000.10(BST)
NB685EN1: PC14017.2 PR14007.2 PU14000.16(EN1)
NB685EN2: PC14018.2 PR14009.2 PU14000.15(EN2)
NB685FB1: PC14019.2 PR14006.1 PR14011.2
NB685PG: PR14010.2 PU14000.12(PG)
NB685SW: PC14006.2 PL14001.1 PR14004.2 PU14000.9(SW)
NB685VTTREF: PC14015.1 PR14005.2 PU14000.7(VTTREF)
NCTF_CPU_A3: TP9052.1 U9001.A3(VSS_A3)
NCTF_CPU_B2: TP9051.1 U9001.B2(RSVD6)
NCTF_CPU_BP1: TP9053.1 U9001.BP1(RSVD16)
NCTF_CPU_BR38: TP9054.1 U9001.BR38(VSS_BR38)
NCTF_CPU_BT37: TP9055.1 U9001.BT37(VCCGT168)
NCTF_CPU_C1: TP9050.1 U9001.C1(RSVD20)
NCTF_PCH_A2: TP9056.1 U9002.A2(VSS_1)
NCTF_PCH_A3: TP9057.1 U9002.A3(VSS_3)
NCTF_PCH_A46: TP9058.1 U9002.A46(VSS_8)
NCTF_PCH_A47: TP9059.1 U9002.A47(VSS_9)
NCTF_PCH_BF1: TP9060.1 U9002.BF1(VSS_135)
NCTF_PCH_BF49: TP9061.1 U9002.BF49(VSS_139)
NCTF_PCH_BG2: TP9062.1 U9002.BG2(VSS_141)
NCTF_TBT_A1: TP8006.1 U8001.A1(PB_MONDC)
NCTF_TBT_A23: TP8005.1 U8001.A23(PA_MONDC)
NCTF_TBT_AC1: TP8008.1 U8001.AC1(USB_MONDC)
NCTF_TBT_AC23: TP8007.1 U8001.AC23(PC_MONDC)
NFC_DWL_REQ: CON9500.5 R9509.1 U9002.BB26(GPP_B15/GSPI0_CS0#)
NFC_INT: CON9500.11 R9253.1 R9543.1 U9002.AN40(GPP_F23/DDPF_CTRLDATA)
NFC_MOD_DET: CON9500.1 R9103.1 R9383.1 U9002.BE32(GPP_B2/VRALERT#)
NFC_RST#: CON9500.6 R9248.1 R9370.1 U9002.BE30(GPP_B18/GSPI0_MOSI)
NFC_SML0_CLK: CON9500.8 R9506.1
NFC_SML0_DATA: CON9500.9 R9505.1
NFC_SWP: CON9500.13 TP9500.1
NGFF_RESET#_R: C4215.1 CON4201.67(RESET#) R4211.1 R4225.1
NIC_SMCLK: R4023.1 U4000.28(SMB_CLK) U9002.BF25(GPP_C3/SML0CLK)
NIC_SMDAT: R4024.1 U4000.31(SMB_DATA) U9002.BE24(GPP_C4/SML0DATA)
NMI_SMI_DBG#: JCN9000.5(NMI_SMI_DBG#) Q6001.1(S) R9223.2 U9002.AU26(GPP_B20/GSPI1_CLK)
NPCE576H_AGND: C6008.1 C6009.1 C6011.1 C6017.2 C6018.1 C6038.1 C6039.1 R6027.2 U6001.E1(AVSS)
NUM_LOCK_LED#: JCN9000.15(NUM_LOCK_LED#) Q9037.5(G) R17940.2 R18102.1 U6001.D7(KSO15/GPIO83)
NUM_LOCK_LED#_R: C6829.2 Q9037.6(D) R6817.1 R17965.1 R18102.2
NV_GPU_DET: R2227.2 U9002.AP47(GPP_F9/SATA_DEVSLP7)
NVVDD: C2058.1 C2070.1 C2072.1 C2073.1 C2074.1 C2075.1 C2076.1 C2078.1 C2079.1 C2082.1 C2083.1 C2085.1 C2086.1 C2087.1 C2088.1 C2092.1 C2094.1 C2096.1 C2097.1 C2099.1 C2103.1 C2108.1 C2109.1 C2110.1 C2111.1 C2113.1 C2116.1 C2117.1 C2118.1 C2119.1 C2121.1 C2122.1 C2123.1 C2124.1 C2126.1 C2128.1 C2129.1 C2130.1 C2131.1 C2134.1 C2146.1 C2150.1 C2154.1 C2156.1 C2157.1 C2158.1 C2160.1 C2162.1 C2164.1 C2174.1 C2175.1 C2176.1 C2178.1 C2179.1 C2180.1 C2184.1 C2185.1 C2186.1 C2187.1 C2226.2 C2227.2 PC9026.1 PC9027.1 PC9028.1 PC9029.1 PC9043.1 PL9001.2 PL9004.2 PL9005.2 PR9023.2 U2000.AA1(XVDD_28) U2000.AA2(XVDD_29) U2000.AA3(XVDD_30) U2000.AA4(XVDD_31) U2000.AA5(XVDD_32) U2000.AA6(XVDD_33) U2000.AA7(XVDD_34) U2000.AA8(XVDD_35) U2000.AA12(VDDS_1) U2000.AA14(VDD_01) U2000.AA16(VDDS_2) U2000.AA19(VDDS_3) U2000.AA21(VDD_02) U2000.AA23(VDDS_4) U2000.AB13(VDD_03) U2000.AB15(VDD_04) U2000.AB17(VDD_05) U2000.AB18(VDD_06) U2000.AB20(VDD_07) U2000.AB22(VDD_08) U2000.AC12(VDD_09) U2000.AC14(VDDS_5) U2000.AC16(VDD_10) U2000.AC19(VDD_11) U2000.AC21(VDDS_6) U2000.AC23(VDD_12) U2000.M12(VDD_13) U2000.M14(VDDS_7) U2000.M16(VDD_14) U2000.M19(VDD_15) U2000.M21(VDDS_8) U2000.M23(VDD_16) U2000.N13(VDD_17) U2000.N15(VDD_18) U2000.N17(VDD_19) U2000.N18(VDD_20) U2000.N20(VDD_21) U2000.N22(VDD_22) U2000.P12(VDDS_9) U2000.P14(VDD_23) U2000.P16(VDDS_10) U2000.P19(VDDS_11) U2000.P21(VDD_24) U2000.P23(VDDS_12) U2000.R13(VDD_25) U2000.R15(VDD_26) U2000.R17(VDD_27) U2000.R18(VDD_28) U2000.R20(VDD_29) U2000.R22(VDD_30) U2000.T12(VDD_31) U2000.T14(VDDS_13) U2000.T16(VDD_32) U2000.T19(VDD_33) U2000.T21(VDDS_14) U2000.T23(VDD_34) U2000.U4(XVDD_01) U2000.U5(XVDD_02) U2000.U6(XVDD_03) U2000.U7(XVDD_04) U2000.U8(XVDD_05) U2000.U13(VDD_35) U2000.U15(VDD_36) U2000.U17(VDDS_15) U2000.U18(VDD_37) U2000.U20(VDD_38) U2000.U22(VDD_39) U2000.V1(XVDD_06) U2000.V2(XVDD_07) U2000.V3(XVDD_08) U2000.V4(XVDD_09) U2000.V5(XVDD_10) U2000.V6(XVDD_11) U2000.V7(XVDD_12) U2000.V8(XVDD_13) U2000.V13(VDD_40) U2000.V15(VDD_41) U2000.V17(VDD_42) U2000.V18(VDDS_16) U2000.V20(VDD_43) U2000.V22(VDD_44) U2000.W2(XVDD_14) U2000.W3(XVDD_15) U2000.W4(XVDD_16) U2000.W5(XVDD_17) U2000.W7(XVDD_18) U2000.W8(XVDD_19) U2000.W12(VDD_45) U2000.W14(VDDS_17) U2000.W16(VDD_46) U2000.W19(VDD_47) U2000.W21(VDDS_18) U2000.W23(VDD_48) U2000.Y1(XVDD_20) U2000.Y2(XVDD_21) U2000.Y3(XVDD_22) U2000.Y4(XVDD_23) U2000.Y5(XVDD_24) U2000.Y6(XVDD_25) U2000.Y7(XVDD_26) U2000.Y8(XVDD_27) U2000.Y13(VDD_49) U2000.Y15(VDD_50) U2000.Y17(VDD_51) U2000.Y18(VDD_52) U2000.Y20(VDD_53) U2000.Y22(VDD_54)
NVVDD_CORE1_EN: C2229.2 PD9005.1(CATHODE) PR9222.1 R2128.1 R2129.2
NVVDD_EN: R2129.1 U2008.4(OUT Y)
NVVDD_PWM_GPU: PR9014.1 U2000.P6(GPIO0)
NVVDD_VIN: PC9001.1 PC9003.1 PC9004.1 PC9006.1 PC9007.1 PC9008.1 PC9010.1 PC9011.1 PC9017.1 PC9018.1 PC9019.1 PC9022.1 PC9023.1 PC9037.1 PC9038.1 PC9040.1 PC9046.1 PQ9001.3(D1#1) PQ9001.4(D1#2) PQ9001.9(D1#3) PQ9004.3(D1#1) PQ9004.4(D1#2) PQ9004.9(D1#3) PQ9005.3(D1#1) PQ9005.4(D1#2) PQ9005.9(D1#3) PQ9006.3(D1#1) PQ9006.4(D1#2) PQ9006.9(D1#3) PQ9007.3(D1#1) PQ9007.4(D1#2) PQ9007.9(D1#3) PQ9008.3(D1#1) PQ9008.4(D1#2) PQ9008.9(D1#3) PR9001.1 PR9805.1
NVVDDPG: D2008.1(CATHODE1) PR9006.2 PR9522.2 PU9001.16(PGOOD) PU9503.2(INA) PU25002.1(INB) U2006.1(INB)
NVVDDS_PSI: TP2012.1 U2000.P4(GPIO20)
NVVDDS_VID: TP2010.1 U2000.P5(GPIO3)
OCP_CHG#: PR11020.1 PR12009.1
OCP_IN_ADC: PC12009.1 PR12023.2 R6021.2 R6231.1
OCP_IN_ADC_R: C6008.2 R6021.1 U6001.F2(GPIO45/ADC0)
OCP_OC#: PQ12004.3(D) PR12011.2 R9229.1 U9002.BE15(GPP_D4/ISH_I2C2_SDA/I2C3_SDA/SB)
OCP_PWM_OUT: PQ12003.2(G) PQ12004.2(G) Q6300.2(G) U6001.G6(GPIO60/PWM7)
ON_OFF#: C6020.1 CON6000.7 Q6007.1(S) RV6000.1
ON_OFF#1: Q6006.3(D) Q6007.3(D) R6170.2 R6176.1
ON_OFF#1_Q: CON400.41(HOOK1) CON401.11 Q6006.1(S) R6080.1

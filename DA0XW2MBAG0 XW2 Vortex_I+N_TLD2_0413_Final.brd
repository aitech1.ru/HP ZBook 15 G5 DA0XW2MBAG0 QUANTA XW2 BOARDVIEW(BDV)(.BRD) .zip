# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSO7: length 59.9
  TOP w0.114: v1(232.82,45.94) 232.88,45.99 CON6800.26
  IN1 w0.076: v1(269.86,22.29) 268.9,22.29 268.01,21.4 267.16,21.4 266.92,21.64 265.79,21.64 265.51,21.92 265.09,21.92 264.36,22.66 264.29,22.66 264.13,22.82 263.72,22.82 261.99,24.56 261.99,25.24 258.51,28.72 257.94,28.72 256.01,30.65 254.68,30.65 250.69,34.63 246.63,34.63 245.8,35.46 245.19,35.46 240.51,40.15 238.36,40.15 235.79,42.71 234.88,42.71 234.25,43.34 234.25,44.51 v1(232.82,45.94)
  BOTTOM w0.114: U6001.B9 270.2,24.03 270.2,23.29 270.29,23.2 270.29,22.72 v1(269.86,22.29) 270.03,22.11 R6075.2 270.47,19.83 270.47,19.15 269.98,18.66 269.98,16.81 270.24,16.55 JCN9000.21 ; C6816.2 232.82,45.94 v1(232.82,45.94)
KSO8: length 59.4
  TOP w0.114: CON6800.28 232.88,44.99 v1(232.82,44.94) ; v3(270.84,24.67) 270.95,24.56 270.95,24.22 v1(270.82,24.09)
  IN1 w0.076: v3(270.84,24.67) 270.54,24.37 270.54,22.24 269.98,21.68 268.73,21.68 268.01,20.96 267.17,20.96 266.82,21.31 266.24,21.31 266.11,21.19 262.9,21.19 262.52,21.56 262.52,23.52 261.68,24.36 261.68,25.12 258.4,28.4 257.83,28.4 255.91,30.32 254.51,30.32 252.17,32.65 247.56,32.65 246.69,33.52 245.42,33.52 244.6,32.69 239.92,32.69 236.13,36.48 236.13,41.47 235.19,42.41 234.75,42.41 233.85,43.31 233.85,43.91 v1(232.82,44.94)
  BOTTOM w0.114: U6001.C9 v3(270.84,24.67) ; v1(232.82,44.94) 232.84,44.92 C6818.2
KSO9: length 62.1
  TOP w0.114: v3(271.49,24.67) 271.81,24.35 v1(272.19,24.35) ; v1(232.92,50.94) 232.98,50.99 CON6800.16
  IN1 w0.076: v3(271.49,24.67) 271.17,24.99 269.27,24.99 268.76,25.49 268.76,29.33 268.54,29.55 262.62,29.55 262.49,29.68 262.49,31.03 263.67,32.21 263.67,32.9 263.3,33.26 262.08,33.26 261.51,33.83 258.85,33.83 257.04,35.65 256.07,35.65 254.07,37.64 249.21,37.64 244.43,42.42 244.43,44.25 241.91,46.78 240.01,46.78 238.41,45.18 237.78,45.18 236.38,46.57 236.38,48.94 234.38,50.94 v1(232.92,50.94)
  BOTTOM w0.114: v1(232.92,50.94) 233.01,51.02 C6820.2 ; U6001.C10 v3(271.49,24.67)
KSO10: length 66.7
  TOP w0.114: CON6800.24 232.88,46.99 v1(232.82,46.94)
  IN1 w0.076: v1(233.99,35.55) 235.31,34.23 235.31,33.81 237.92,31.21 247.85,31.21 248.53,31.89 250.45,31.89 251.12,31.22 252.5,31.22 254.19,29.53 255.62,29.53 257.51,27.64 258.08,27.64 260.92,24.8 260.92,24.04 261.76,23.2 261.76,21.07 262.57,20.26 266.19,20.26 266.75,19.7 266.99,19.7 267.34,19.34 269.32,19.34 269.98,20 269.98,21.39 271.05,22.46 271.05,22.52 v1(271.61,23.08)
  IN3 w0.089: v1(233.99,35.55) 233.64,35.9 233.2,35.9 231.8,37.31 231.8,47.2 231.93,47.32 232.48,47.32 232.82,46.98 v1(232.82,46.94)
  BOTTOM w0.114: C6822.2 232.84,46.95 v1(232.82,46.94) ; v1(271.61,23.08) 271.5,23.19 271.5,24.03 U6001.B11
KSO11: length 57.1
  TOP w0.114: v1(232.82,37.94) 232.88,37.99 CON6800.42
  IN1 w0.076: v1(232.82,37.94) 233.33,37.43 233.33,35.57 237.84,31.05 247.91,31.05 248.57,31.71 250.35,31.71 251,31.07 252.44,31.07 254.13,29.38 255.53,29.38 257.42,27.48 258.02,27.48 260.77,24.74 260.77,23.98 261.6,23.14 261.6,20.97 262.46,20.11 264.36,20.11 265.69,18.77 267.01,18.77 267.43,19.19 269.39,19.19 270.14,19.94 270.14,21.33 270.62,21.81 v1(271.61,21.81)
  BOTTOM w0.114: v1(232.82,37.94) 232.95,37.81 C6824.2 ; U6001.B10 270.85,24.03 270.85,22.57 v1(271.61,21.81)
KSO12: length 62.6
  TOP w0.114: v1(232.29,50.94) 232.84,51.49 CON6800.15
  IN1 w0.076: v1(273.31,23.56) 272.29,24.58 272.29,29.92 271.44,30.77 269.36,30.77 268.83,31.31 266.02,31.31 265.6,31.73 265.6,33.7 264.78,34.51 264.01,34.51 263.69,34.84 259.14,34.84 257.42,36.57 256.45,36.57 253.5,39.51 251.96,39.51 249.22,42.25 249.22,42.76 248.93,43.05 247.52,43.05 247.36,42.89 246.22,42.89 241.88,47.23 238.79,47.23 234.63,51.4 232.75,51.4 v1(232.29,50.94)
  BOTTOM w0.114: U6001.C11 272.13,24.68 272.7,24.68 273.31,24.07 v1(273.31,23.56) ; v1(232.29,50.94) 232.21,51.02 C6830.2
KSO13: length 59.4
  TOP w0.114: CON6800.14 232.98,51.99 v1(232.92,51.94)
  IN1 w0.076: v1(273.56,25.01) 272.47,26.1 272.47,29.96 271.51,30.93 269.42,30.93 268.89,31.46 266.08,31.46 265.75,31.79 265.75,33.76 264.8,34.71 264.04,34.71 263.1,35.65 262.03,35.65 261.7,35.98 258.53,35.98 258.43,36.08 258.12,36.08 257.48,36.72 256.57,36.72 253.63,39.66 252.02,39.66 249.37,42.32 249.37,42.83 248.98,43.22 247.48,43.22 247.3,43.04 246.29,43.04 241.94,47.39 238.89,47.39 234.34,51.94 v1(232.92,51.94)
  BOTTOM w0.114: C6831.2 233.02,52.03 v1(232.92,51.94) ; U6001.D11 272.13,25.33 273.24,25.33 v1(273.56,25.01)
L_SPK+:
  vias: v1(218.22,156.61)
L_SPK+_R:
  vias: v1(215.55,154.4) v1(215.68,153.63) v1(215.68,153)
L_SPK-:
  vias: v1(220.33,153.38)
L_SPK-_R:
  vias: v1(213.77,152.11) v1(213.77,151.47) v1(215.42,151.73)
LAN_DIS#: length 433.7
  TOP w0.114: 23.66,123.03 24.25,122.44 25.89,122.44 26.32,122.01 R4005.2 26.44,121.51 26.83,121.12 v1(28.73,121.12) 27.85,122.01 27.85,125.82 28.1,126.07 R4022.2 R4011.1
  IN1 w0.076: v1(28.73,121.12) 28.73,119.6 26.47,117.34 26.47,112.71 27.08,112.1 27.08,104.76 27.31,104.54 27.31,99.87 27.59,99.59 27.59,97.58 28.23,96.95 28.23,93.69 29.78,92.14 29.78,84.65 36.86,77.56 36.86,75.53 36.48,75.15 36.48,73.03 38.2,71.31 38.2,69.12 39.79,67.52 42.66,67.52 44.19,65.99 46.39,65.99 46.91,65.47 50.59,65.47 58.26,57.8 58.26,54.7 59.86,53.1 62.1,53.1 62.76,52.44 62.78,52.44 63.47,51.75 67.77,51.75 68.77,52.75 80.73,52.75 81.17,52.3 89.51,52.3 94.48,47.33 96.62,47.33 101.46,42.49 101.46,41.87 101.93,41.4 101.93,35.62 102.21,35.34 102.21,31.59 104.46,29.33 104.46,25.23 107.58,22.11 136.24,22.11 137.48,20.87 179.21,20.87 180.48,22.14 189.81,22.14 190.48,22.81 194.88,22.81 195.45,23.38 198.33,23.38 198.91,22.8 202.11,22.8 205.7,19.22 214,19.22 219.54,24.75 229.04,24.75 233.01,28.73 249.65,28.73 251.29,27.09 254.28,27.09 256.08,25.29 256.08,23.96 257.26,22.79 257.26,18.51 259.96,15.8 273.32,15.8 v1(280.16,22.63)
  BOTTOM w0.102: 268.4,71.06 268.04,71.06 267.57,70.59 267.02,70.59 266.99,70.56 265.29,70.56 264.66,69.93 U9002.BF41
  BOTTOM w0.114: 268.4,71.06 268.76,71.06 271.07,73.38 272.19,73.38 272.3,73.49 272.85,73.49 273.17,73.17 275.19,73.17 279.28,69.08 279.28,67.11 279.88,66.51 279.88,64.19 277.27,61.58 277.27,56.74 279.83,54.17 279.83,53.73 279.46,53.35 279.46,48.57 279.83,48.2 279.83,46.83 280.19,46.46 280.19,41.08 281.46,39.81 281.46,36.81 282.16,36.11 282.16,35.45 283.45,34.16 283.45,31.16 283.36,31.07 283.36,28.67 283.69,28.34 283.69,26.14 283.3,25.74 281.59,25.74 281.21,25.36 281.21,24.73 279.94,23.46 279.94,22.85 v1(280.16,22.63)
LAN_JTAG_TCK: length 4
  TOP w0.114: R4002.1 TP4003.1 30.13,120.87 v1(30.13,120.99)
  BOTTOM w0.114: v1(30.13,120.99) 29.88,121.25 29.88,121.88 29.52,122.24 U4000.35
LAN_JTAG_TDI: length 2.8
  BOTTOM w0.114: U4000.32 29.59,123.44 29.75,123.28 30.89,123.28 31.4,123.79 TP4000.1
LAN_JTAG_TDO: length 2
  BOTTOM w0.114: U4000.34 29.63,122.64 TP4001.1
LAN_JTAG_TMS: length 4.5
  TOP w0.114: R4001.1 29.37,122.9 TP4002.1 30.64,122.39 v1(30.99,122.39)
  BOTTOM w0.114: v1(30.99,122.39) 30.26,122.39 29.61,123.04 U4000.33
LAN_MCT0: length 5.6
  TOP w0.508: U4001.22 22.99,136.23 24.01,137.25 v1(24.95,137.25)
  BOTTOM w0.508: C4011.2 v1(24.95,137.25)
LAN_MCT1: length 5.8
  TOP w0.508: v1(24.97,138.77) 23.81,138.77 22.54,137.5 U4001.21
  BOTTOM w0.508: C4013.2 v1(24.97,138.77)
LAN_MCT2: length 5.5
  TOP w0.508: U4001.16 22.77,143.85 v1(23.75,142.87)
  BOTTOM w0.254: C4015.2 v1(25.18,143.73)
  BOTTOM w0.508: v1(23.75,142.87) C4015.2
LAN_MCT3: length 5.9
  TOP w0.508: v1(24.05,146.11) 23.07,145.12 U4001.15
  BOTTOM w0.254: C4017.2 v1(25.18,145.25)
  BOTTOM w0.508: C4017.2 23.75,145.8 v1(24.05,146.11)
LAN_MX0+: length 42.4
  TOP w0.102: U4001.24 19.97,133.69 19.46,134.2 18.32,134.2 v1(17.69,134.84)
  IN4 w0.076: CON4000.1 13.51,128.76 14.06,129.32 15.07,129.32 15.27,129.52 15.27,130.1 15.07,130.3 14.33,130.3 14.13,130.51 14.13,131.01 15.36,132.24 15.36,133.73 14.8,134.29 12.99,134.29 12.69,134.59 10.96,134.59 10.66,134.89 10.66,135.59 10.96,135.89 12.03,135.89 12.31,136.18 12.31,137.24 12.61,137.54 13.58,137.54 13.88,137.24 13.88,135.8 14.08,135.6 14.94,135.6 15.15,135.8 15.15,137.24 15.44,137.54 19.27,137.54 19.95,138.22 20.37,138.22 20.89,137.71 20.89,137.28 19.86,136.25 16.75,136.25 16.54,136.04 16.54,134.41 16.75,134.2 17.71,134.2 17.9,134.4 17.9,134.62 v1(17.69,134.84)
LAN_MX0-: length 42.4
  TOP w0.102: v1(18.45,134.84) 18.33,134.72 18.33,134.48 18.4,134.41 19.34,134.41 19.89,134.96 20.96,134.96
  IN4 w0.076: v1(18.45,134.84) 18.19,134.84 18.07,134.71 18.07,134.33 17.77,134.04 16.68,134.04 16.38,134.34 16.38,136.11 16.68,136.41 19.79,136.41 20.73,137.35 20.73,137.64 20.31,138.06 20.02,138.06 19.34,137.38 15.51,137.38 15.31,137.17 15.31,135.73 15.01,135.43 14.01,135.43 13.71,135.73 13.71,137.17 13.51,137.38 12.68,137.38 12.48,137.17 12.48,136.11 12.1,135.73 11.03,135.73 10.83,135.52 10.83,134.96 11.03,134.76 12.75,134.76 13.05,134.46 14.87,134.46 15.53,133.8 15.53,132.17 14.29,130.94 14.29,130.58 14.4,130.47 15.14,130.47 15.44,130.17 15.44,129.45 15.14,129.15 14.13,129.15 13.95,128.97 CON4000.2
LAN_MX1+: length 38.8
  TOP w0.102: v1(19.34,138.39) 19.72,138.77 U4001.20
  IN1 w0.076: CON4000.3 14.37,126.72 14.76,126.33 14.76,125.95 15.04,125.67 15.27,125.67 15.41,125.81 15.41,129.52 15.21,129.72 14.14,129.72 13.84,130.02 13.84,130.73 14.14,131.03 15.21,131.03 15.41,131.23 15.41,133.58 15.04,133.95 12.75,133.95 12.31,134.39 12.31,137.12 12.61,137.42 13.7,137.42 14,137.12 14,135.55 14.21,135.35 14.94,135.35 15.15,135.55 15.15,137.12 15.44,137.42 16.15,137.42 16.45,137.12 16.45,135.68 16.66,135.47 17.23,135.47 17.43,135.68 17.43,137.1 17.83,137.5 18.43,137.5 18.81,137.12 19.61,137.12 20.31,137.83 20.31,138.45 20.05,138.71 19.66,138.71 v1(19.34,138.39)
LAN_MX1-: length 38.9
  TOP w0.102: v1(19.34,139.16) 20.23,140.04 U4001.19
  IN1 w0.076: CON4000.6 13.95,124.12 15.58,125.74 15.58,129.59 15.28,129.88 14.21,129.88 14,130.09 14,130.66 14.21,130.86 15.28,130.86 15.58,131.16 15.58,133.64 15.11,134.11 12.82,134.11 12.48,134.46 12.48,137.05 12.68,137.25 13.63,137.25 13.84,137.05 13.84,135.48 14.14,135.18 15.01,135.18 15.31,135.48 15.31,137.05 15.51,137.25 16.08,137.25 16.29,137.05 16.29,135.61 16.59,135.31 17.3,135.31 17.6,135.61 17.6,137.04 17.9,137.34 18.36,137.34 18.74,136.96 19.68,136.96 20.48,137.76 20.48,138.52 20.12,138.88 19.61,138.88 v1(19.34,139.16)
LAN_MX2+: length 27.7
  TOP w0.102: U4001.18 21.39,141.31 21.95,141.87 22.38,141.87 22.51,141.75 v1(22.51,141.44)
  IN4 w0.076: CON4000.4 13.54,125.29 13.54,124.88 13.72,124.7 14.94,124.7 16.5,126.27 16.5,132.26 17.32,133.07 18.44,133.07 23.49,138.12 23.49,141.75 23.04,142.2 22.64,142.2 22.51,142.08 v1(22.51,141.44)
LAN_MX2-: length 27.7
  TOP w0.102: 20.96,142.58 21.42,142.58 21.93,142.08 22.36,142.08 22.54,142.25 v1(22.54,142.71)
  IN4 w0.076: v1(22.54,142.71) 22.54,142.5 22.66,142.37 23.11,142.37 23.65,141.82 23.65,138.05 18.51,132.91 17.39,132.91 16.67,132.19 16.67,126.2 15.01,124.54 13.65,124.54 13.51,124.68 CON4000.5
LAN_MX3+: length 33
  TOP w0.102: v1(22.51,146.45) 22.51,146.78 22.36,146.93 21.98,146.93 21.44,146.39 U4001.14
  IN1 w0.076: CON4000.7 14.33,122.64 16.54,124.85 16.54,132.4 23.18,139.05 23.18,144.96 23.49,145.26 23.49,146.58 23.07,147 22.59,147 22.51,146.93 v1(22.51,146.45)
LAN_MX3-: length 33.2
  TOP w0.102: U4001.13 21.42,147.66 21.95,147.13 22.36,147.13 22.55,147.32 v1(22.55,147.75)
  IN1 w0.076: v1(22.55,147.75) 22.55,147.3 22.68,147.17 23.14,147.17 23.65,146.65 23.65,145.2 23.35,144.89 23.35,138.98 16.71,132.34 16.71,124.78 13.95,122.02 CON4000.8
LAN_WAKE#: length 1.9
  TOP w0.114: R4021.2 R9337.2 v1(24.66,121.13)
LAN_XTAL1: length 6.1
  BOTTOM w0.114: Y4000.3 21.2,129.21 20.47,128.48 C4009.2 20.47,127.48 v1(20.63,127.32) 20.63,126.81 21.24,126.2 21.42,126.2 22.18,125.44 U4000.10
LAN_XTAL2: length 3.3
  BOTTOM w0.114: U4000.9 22.15,125.04 21.52,125.67 v1(21.37,125.67) 20.73,126.3 R4007.1
LANLINK_STATUS#: length 504.2
  TOP w0.114: v1(311.94,53.25) 311.94,52.67 311.72,52.44 311.72,50 311.08,49.37 311.08,47.97 310.61,47.49 310.61,44.27 306.1,39.76 306.1,36.29 305.18,35.37 305.18,33.46 302.06,30.34 302.06,28.93 v1(300.91,27.78) ; v1(33.56,132.55) 29.76,132.55 27.83,130.62 Q4001.3
  IN1 w0.076: v1(300.91,27.78) 300.4,27.27 296.7,27.27 296.5,27.47 296.5,28.11 296.32,28.28 290.99,28.28 290.2,27.5 285.63,27.5 284.66,26.53 284.66,26.3 272.17,13.81 267.75,13.81 267.29,13.35 265.21,13.35 264.76,13.8 261.44,13.8 256.95,18.29 256.95,22.66 255.61,24.01 255.61,25.29 254.67,26.23 253.6,26.23 253.5,26.13 251.82,26.13 249.52,28.42 233.14,28.42 229.17,24.45 219.68,24.45 214.14,18.91 205.57,18.91 201.99,22.49 198.57,22.49 198.11,22.95 195.61,22.95 195.1,22.44 190.54,22.44 189.91,21.81 180.58,21.81 179.34,20.56 137.26,20.56 136.01,21.81 107.46,21.81 104.15,25.11 104.15,29.21 101.1,32.27 101.1,36.02 101.01,36.1 101.01,42.51 96.49,47.03 94.35,47.03 89.38,52 81.05,52 80.6,52.44 68.91,52.44 67.91,51.44 63.34,51.44 62.66,52.13 60.4,52.13 57.95,54.57 57.95,57.41 50.2,65.17 46.78,65.17 46.26,65.69 44.06,65.69 42.55,67.2 39.66,67.2 37.89,68.96 37.89,71.15 36,73.04 36,78.11 29.57,84.53 29.57,92.09 28.05,93.61 28.05,96.91 27.44,97.52 27.44,99.53 27.16,99.81 27.16,104.15 26.83,104.48 26.83,111.98 26.32,112.49 26.32,117.69 27.72,119.09 27.72,121.12 29.47,122.87 30.79,122.87 31.32,123.41 31.32,127.54 33.31,129.52 33.31,132.3 v1(33.56,132.55)
  IN2 w0.089: v3(258.88,83.43) 258.86,83.43 258.73,83.3 258.73,82.84 258.95,82.63 259.54,82.63 259.74,82.83 260.78,82.83 263.02,80.59 263.02,80.03 265.49,77.56 265.49,76.95 265.34,76.8 265.34,76.32 265.65,76 265.98,76 266.37,76.39 267.02,76.39 270.98,72.43 271.48,72.43 273.69,70.22 274.31,70.22 275.1,69.43 275.48,69.43 275.97,68.94 277.64,68.94 278.29,68.29 278.78,67.81 279.71,66.88 279.71,65.52 280.38,64.85 280.38,63.94 281.87,62.45 286.17,62.45 288.32,60.31 288.32,58.97 290.68,56.61 293.66,56.61 294.16,56.1 294.16,54.95 294.8,54.32 298.61,54.32 299.86,53.07 311.76,53.07 v1(311.94,53.25)
  BOTTOM w0.102: U9002.BF18 257.18,77.83 257.89,78.54 257.89,80.51 258.22,80.84 258.22,82.62 258.64,83.03 258.64,83.19 v3(258.88,83.43)
LANLINK_STATUS#_R_DK: length 25.4
  IN1 w0.076: v1(30.37,128.29) 30.11,128.29 28.53,126.71 24.16,126.71 23.02,125.57 23.02,122.52 21.62,121.12 16.29,121.12 15.27,120.11 13.37,120.11 12.33,119.06 CON4000.10
  BOTTOM w0.114: Q4000.6 30.37,128.3 v1(30.37,128.29)
LANWAKE#_R: length 4.2
  TOP w0.114: v1(21.88,122.14) 22,122.01 R4021.1 22.88,121.38 22.64,121.13 R4003.1 R4006.1
  BOTTOM w0.114: U4000.2 21.98,122.24 v1(21.88,122.14)
LANWAKE_N: length 418.2
  TOP w0.114: R9337.1 25.44,120.75 25.18,120.49 25.18,115.79 v1(21.24,111.85) ; R9592.1 275.94,66.41 276.26,66.08 v1(276.26,65.62)
  IN2 w0.089: v1(276.26,65.62) 276.53,65.36 276.53,64.75 275.83,64.06 275.83,63 275,62.16 275,62.11 274.96,62.06 274.96,61.76 274.82,61.62 274.82,61.14 272.6,58.93 272.6,57.19 271.63,56.22 271.63,55.58 271.76,55.44 271.76,54.01 270.69,52.94 270.02,52.94 268.48,51.39 268.48,49.53 267.18,48.24 267.18,47.28 264.68,44.77 263.72,44.77 260.64,41.7 260.64,39.91 260.16,39.43 260.16,38.14 260.02,37.99 260.02,37.98 258.33,36.29 255.81,36.29 251.11,31.6 251.11,31.33 247.62,27.85 238.77,27.85 237.49,26.57 235.11,26.57 232.99,24.45 224.06,24.45 219.25,19.64 216.83,19.64 213.03,15.84 207.26,15.84 204.44,18.66 196.47,18.66 195.89,18.08 182.56,18.08 180.98,16.5 175.96,16.5 175.04,15.58 163.94,15.58 162.49,17.04 107.9,17.04 107.08,16.22 104.74,16.22 103.85,17.1 102.56,17.1 102.05,16.59 101.27,16.59 99.97,17.89 99.97,19.17 98.12,21.02 98.12,38.41 94.09,42.44 93.51,42.44 92.16,43.79 92.16,46.51 89.02,49.66 74.87,49.66 73.9,48.68 69.11,48.68 66.47,46.05 63.01,46.05 60.36,43.4 33.69,43.4 29.67,47.41 v1(26.4,47.41)
  IN3 w0.089: v1(21.24,111.85) 20.48,111.09 20.48,101.89 18.52,99.93 18.52,91.71 19.83,90.4 19.83,85.86 23.95,81.75 23.95,78.02 14.18,68.25 14.18,59.36 26.13,47.41 v1(26.4,47.41)
  BOTTOM w0.102: U9002.BG44 266.28,69.34 267.53,69.34 267.56,69.37 268.16,69.37 268.34,69.18
  BOTTOM w0.114: 268.34,69.18 270.71,69.18 272.08,70.55 R9104.1 272.91,70.32 274.25,70.32 275.19,69.38 275.19,69.09 276.26,68.02 v1(276.26,65.62)
LDO_AVDD: length 4.6
  TOP w0.203: v1(344.91,6.97) 344.85,7.03 344.85,7.52 343.93,8.45 343.93,8.52 343.77,8.68 U3600.49
  TOP w0.254: C3606.2 345.87,6.97 v1(344.91,6.97)
LDO_VDD_CORE: length 3.1
  TOP w0.203: U3600.51 343.88,9.48
  TOP w0.254: C3609.2 345.91,9.46 v1(345.42,9.46) 344.23,9.46 344.21,9.48 343.88,9.48
LED#: length 6.2
  BOTTOM w0.114: 33.47,143.51 33.73,143.76 CON6000.3 ; 33.47,143.51 v1(33.47,142.77) 33.19,142.49 R6092.1 33.19,140.8 32.94,140.55 Q6002.3 ; 33.47,143.51 33.23,143.75 CON6000.2
LED_3S_LANLINK#: length 8.6
  TOP w0.114: R4010.1 30.13,131.92 v1(29.62,131.41) 29.13,130.92 Q4001.1
  BOTTOM w0.114: U4000.26 29.52,125.84 29.88,126.2 29.88,130.01 30.37,130.5 Q4000.1 30.07,130.96 v1(29.62,131.41)
LED_ACT_LAN#: length 5.2
  BOTTOM w0.114: U4000.27 29.55,125.44 30.13,126.02 30.13,126.96 v1(30.77,127.6) 31.02,127.6 31.67,128.25 Q4000.4
LED_ACT_LAN#_DK: length 39.2
  IN1 w0.076: v1(31.78,131.69) 31.4,131.31 31.4,130.14 30.61,129.35 30.49,129.35 28.1,126.96 24.2,126.96 22.87,125.63 22.87,122.58 21.56,121.27 16.22,121.27 15.31,120.36 12.99,120.36 11.97,121.38 11.97,131.91 CON4000.12
  BOTTOM w0.114: v1(31.78,131.69) 31.67,131.58 Q4000.3
LED_STANDBY#: length 411.2
  TOP w0.114: v1(264.83,11.14) R6186.2 R6183.1 264.57,12.52 U6003.6
  IN3 w0.089: v1(31.28,142.2) 31.17,142.09 31.17,129.78 29.24,127.85 29.24,120.23 27.58,118.57 23.44,118.57 23.17,118.83 22.41,118.83 21.61,118.03 21.61,115.65 19.92,113.96 19.92,101.83 18.17,100.08 18.17,91.56 19.48,90.25 19.48,85.71 23.01,82.17 23.01,77.43 13.75,68.16 13.75,57.49 24.42,46.83 32.42,46.83 33.81,45.43 37.95,45.43 38.21,45.18 49.31,45.18 50.25,44.24 58.15,44.24 58.83,44.92 68.87,44.92 70.17,46.23 72.41,46.23 75.02,48.83 88.93,48.83 89.05,48.72 89.83,48.72 92.53,46.02 92.53,43.8 98.06,38.27 98.06,21.06 99.98,19.14 99.98,17.49 103.59,13.88 103.59,8.17 104.04,7.71 176.32,7.71 176.32,7.71 176.62,7.71 176.62,7.71 176.74,7.71 184.87,15.84 196.9,15.84 204.62,8.13 204.91,8.13 217.24,8.13 217.34,8.23 219.11,10 223.07,10 224.24,8.83 235.59,8.83 236.15,9.39 238.87,9.39 240.08,8.17 243.83,8.17 244.35,7.66 250.58,7.66 250.88,7.36 251.95,7.36 253.07,8.47 253.55,8.47 254.46,9.39 254.46,11.51 255.62,12.66 256.19,12.66 256.57,12.28 257.33,12.28 258.3,13.25 261.63,13.25 263.74,11.14 v1(264.83,11.14)
  BOTTOM w0.114: v1(31.28,142.2) C6022.1 R6092.2 32.41,140.81 32.29,140.69 Q6002.2
LEFT+: length 1.8
  TOP w0.203: TP3600.1 334.68,11.43 335.42,10.68 U3600.22
LEFT-: length 3.5
  TOP w0.203: U3600.24 334.55,9.88 334.47,9.96 333.34,9.96 TP3601.1
LID_OFF_CN: length 21.9
  TOP w0.114: v1(45.63,44.67) 46.12,45.16 Q3010.2
  IN2 w0.089: v1(45.63,44.67) 47.78,46.83 50.83,46.83 51.19,47.18 59.01,47.18 v1(59.42,47.59)
  BOTTOM w0.114: Q3009.3 58.58,48.61 58.46,48.73 58.46,49 58.57,49.11 Q3009.2 59.33,49.11 R3008.1 59.97,48.14 v1(59.42,47.59)
LID_SW#_3: length 425
  TOP w0.076: 265.84,28.92 265.87,28.89 266.62,28.89 v3(266.94,28.57)
  TOP w0.114: v1(258.1,46.06) 257.96,46.2 Q6008.1 ; 265.84,28.92 264.7,28.92 264.45,28.67 262.54,28.67 261.95,29.26 261.95,30.38 261.85,30.48 261.4,30.48 261.05,30.82 258.8,30.82 v1(258.34,30.39) 257.88,29.93 255.81,29.93 VC6000.1 254.14,30.69 R6053.2 253.9,30.45 244.76,30.45 244.29,30.92 241.19,30.92 240.09,30.7 238.97,30.7 237.87,30.92 235.71,31.82 234.07,31.82 227.54,25.29 221.27,25.29 210.55,14.57 207.01,14.57 205.21,12.77 v1(205.21,12.74) ; v1(105.16,15.28) 105.37,15.08 105.37,10.63 105.98,10.02 105.98,8.82 106.59,8.22 106.59,2.25 106.18,1.84 100.36,1.84 100.13,2.07 100.13,2.78 99.88,3.04 Q6351.5
  IN1 w0.076: v1(105.16,15.28) 105.37,15.48 107.12,15.48 112.35,10.25 177.32,10.25 183.12,16.05 197.07,16.05 200.97,12.16 204.38,12.16 205.01,11.52 205.31,11.52 205.65,11.85 205.65,12.66 205.57,12.74 v1(205.21,12.74) ; v1(68.13,46.45) 67.1,47.47 60.71,47.47 60.09,48.1 58.2,48.1 56.15,50.14 53.58,50.14 53.14,50.57 53.14,51.25 53.3,51.4 53.3,54.43 52.48,55.25 52.48,58 52.62,58.14 52.62,60.25 49.33,63.54 43.36,63.54 40.54,66.36 39.3,66.36 37.03,68.63 37.03,70.91 35.21,72.72 35.21,76.12 33.65,77.69 33.65,79.31 28.84,84.13 28.84,91.7 26.78,93.75 26.78,99.33 26.47,99.64 26.47,101.7 25.91,102.25 25.91,111.28 25.15,112.04 25.15,120.3 29.5,124.64 29.5,126.15 33,129.66 33,134.49 34.45,135.94 v1(34.45,140.68)
  IN2 w0.089: v1(105.16,15.28) 104.71,14.83 102.3,14.83 97.65,19.48 97.65,38.3 93.87,42.08 93.37,42.08 91.22,44.23 91.22,46.78 88.7,49.3 76.65,49.3 74,46.66 68.34,46.66 v1(68.13,46.45)
  BOTTOM w0.114: v1(68.13,46.45) 67.62,45.94 R3092.1 ; U6001.H4 v3(266.94,28.57) ; v1(258.34,30.39) 258.15,30.62 258.15,32.55 259.61,34.01 259.61,35.33 259.88,35.61 259.88,35.63 260.13,35.88 261.2,35.88 261.83,36.51 261.83,37.77 262.46,38.4 262.46,40.32 261.78,41.01 261.78,43.02 v1(261.28,43.51) 258.73,46.06 v1(258.1,46.06) ; R6093.1 v1(34.45,140.68)
LID_SW#_3_Q: length 4.4
  TOP w0.114: Q6008.3 257.46,48.39 257.25,48.6 v1(257.25,48.99) 257.25,49.73 Q6007.2 256.53,50.44 R6169.2
LID_SW#_3_R: length 2.8
  BOTTOM w0.114: CON6000.6 v1(35.23,143.09) 35.23,143.06 34.83,142.66 34.83,142.47 R6093.2
LIMIT_SIGNAL: length 148.8
  TOP w0.114: PR12018.2 297.09,41.68 297.41,41.68 297.54,41.54 297.54,41.04 297.85,40.73 298.69,40.73 299.22,41.26 301.05,41.26 301.4,41.62 303.1,41.62 304.17,42.69 308.7,42.69 310.38,44.36 310.38,47.77 310.85,48.24 310.85,49.77 311.44,50.36 311.44,53.43 312.51,54.5 312.51,56.27 310.8,57.98 v1(310.8,58.85)
  IN2 w0.089: PCN10000.5 355.87,143.67 355.87,143.29 354.67,142.09 354.67,134.55 349.06,128.95 339.45,128.95 334.91,124.4 334.91,120.64 337.2,118.35 337.2,104.99 335.92,103.71 335.92,92.77 334.55,91.4 334.55,85.95 333.4,84.8 331.98,84.8 327.27,80.09 327.27,79.5 317.57,69.8 317.57,63.32 317.67,63.21 318.07,63.21 v1(318.29,62.99)
  BOTTOM w0.114: v1(310.8,58.85) 310.8,59.53 314.48,63.21 318.07,63.21 v1(318.29,62.99)
LINEOUT_L_1: length 2.8
  TOP w0.254: C3635.1 355.43,21.3 354.95,21.78 v1(354.95,22.09) 354.95,22.29 354.4,22.83 U3601.2
LINEOUT_R_1: length 2.7
  TOP w0.254: C3636.1 355.75,22.93 354.92,23.76 v1(354.92,23.83) U3601.4
LOW_PWR_VTG_SHIFT: length 10
  TOP w0.254: v1(190.66,154.14) 191.17,154.14 191.56,153.75 PR17004.2 191.95,153.11 v1(191.95,152.64)
  BOTTOM w0.254: PU24000.4 189.73,157.91 190.37,158.55 PQ24000.2 191.27,157.8 191.37,157.7 191.37,156.13 190.66,155.42 v1(190.66,154.14)
LOW_PWR_VTG_SHIFT_N: length 4.3
  TOP w0.254: v1(192.06,155.41) 192.06,155.23 191.73,154.9 PR17005.2
  BOTTOM w0.254: v1(192.06,155.41) 192.06,155.23 191.48,154.66 PR24002.2 191.29,155.53 PQ24000.3
LP#: length 301.1
  TOP w0.114: PR23007.2 v1(108.74,99.91)
  TOP w0.254: v1(201.2,43.65) 201.2,43.56 PR13002.2
  IN2 w0.089: v1(184.56,47.21) 185.46,48.1 185.46,66.05 181.46,70.04 181.46,87.6 179.74,89.33 179.74,93.18 182.02,95.47 182.57,95.47 182.84,95.73 184.73,95.73 189.66,100.67 189.66,120.85 190.67,121.86 191.16,121.86 191.97,122.68 191.97,127.63 190.91,128.69 190.91,132.33 190.06,133.19 190.06,148.14 189.38,148.81 189.38,149.56 v1(189.77,149.95) 189.77,150.97 190.46,151.65 190.46,153.54 189.77,154.22 189.77,154.7 186.45,158.02 183.91,158.02 182.45,159.48 176.4,159.48 174.43,161.45 140.34,161.45 139.64,160.75 139.64,157.55 138.02,155.93 134.01,155.93 133.36,156.58 130.66,156.58 130.51,156.43 123.7,156.43 122.83,155.55 122.83,154.29 121.2,152.66 121.2,144.74 119.92,143.46 119.92,140.81 119.03,139.92 119.03,138.39 118.4,137.76 118.4,132.33 116.62,130.55 116.62,105.01 111.9,100.29 109.13,100.29 v1(108.74,99.91)
  IN3 w0.089: v1(184.56,47.21) 184.66,47.21 185.25,46.62 185.25,43.91 186.62,42.53 187.48,42.53 189.89,40.12 191.85,40.12 196.3,44.57 200.29,44.57 v1(201.2,43.65) 201.71,44.16 202.85,44.16 203.29,43.72 206.76,43.72 207.05,43.42 214.26,43.42 214.92,42.76 v1(214.92,39.46)
  BOTTOM w0.254: PR13010.2 214.66,39.71 v1(214.92,39.46) ; PR17012.1 189.51,150.34 189.77,150.08 v1(189.77,149.95)
LPC_ESPI_CLK_EC_R: length 3.7
  BOTTOM w0.114: R6134.1 263.94,33.26 v1(264.24,32.96) 265.41,31.79 265.41,30.94 U6001.M1
LPC_ESPI_CLK_R_R: length 3.1
  BOTTOM w0.114: R9008.1 265.19,18.18 v1(265.08,18.07) 265.24,17.91 JCN9000.11
LPC_ESPI_RESET#_R: length 9.5
  TOP w0.114: v3(266.29,29.87) 266.12,29.87 v1(265.71,30.28) 265.67,30.32 264.63,30.32 264.3,30.65 264.3,31.14 264,31.44 263.54,31.9 262.82,31.9 262.24,32.48 262.24,34.61 R6223.2 R9026.2
  BOTTOM w0.114: U6001.K3 v3(266.29,29.87)
LPC_ESPI_RESET#_R_R: length 2.7
  BOTTOM w0.114: JCN9000.12 265.74,16.5 266.48,17.24 v1(266.48,17.31) 266.48,17.36 266.61,17.49 R9009.1
LPC_PIRQAB: length 8.6
  TOP w0.114: R9057.2 266.02,73.09 265.12,73.09 264.79,72.76 264.5,72.76 263.66,71.92 v1(263.66,71.7) 263.64,71.67 263.64,71.65 262.38,70.39 261.72,70.39 261.47,70.13 260.59,70.13 v1(260.39,70.33)
  BOTTOM w0.114: v1(260.39,70.33) 260.8,69.92 U9002.BA36
M_A_A0: length 64.9
  TOP w0.102: v1(150.81,52.91) 151.26,53.37 151.26,54.32 150.8,54.79 150.27,54.79 149.35,55.71 JDIM1000.144
  IN4 w0.152: v1(158.72,96) 159.13,95.59 159.13,94.52 158.76,94.14 158.76,88.6 160.5,86.86 160.5,77.72 151.32,68.54 151.32,63.98 150.93,63.59 150.93,55.62 151.32,55.23 151.32,53.42 v1(150.81,52.91)
  BOTTOM w0.076: v1(158.72,96) 158.73,96 159.24,96.51 159.24,97.42 159.9,98.08 159.9,101.4 U9001.AH3
  BOTTOM w0.102: v1(150.81,52.91) 150.17,52.27 150.17,50.4 149.35,49.59 JDIM1001.144
M_A_A1: length 69.7
  TOP w0.102: JDIM1000.133 146.6,49.6 146.69,49.69 146.96,49.69 147.1,49.83 147.1,50.02 146.96,50.16 146.29,50.16 146.21,50.24 146.21,50.45 146.68,50.92 146.68,51.56 146.5,51.73 146.31,51.73 146.21,51.63 146.21,50.99 146.14,50.91 v1(145.77,50.91)
  IN4 w0.152: v1(153.7,98.19) 155.1,96.79 155.1,87.31 156.33,86.08 156.33,79.47 146.82,69.95 146.82,67.69 146.45,67.32 146.45,52.62 146.29,52.46 146.29,51.43 v1(145.77,50.91)
  BOTTOM w0.076: U9001.AP4 154.33,102.34 154.03,102.04 154.03,101.21 153.98,101.16 153.98,99.32 154.08,99.22 154.08,98.57 v1(153.7,98.19)
  BOTTOM w0.102: JDIM1001.133 146.6,55.68 146.4,55.48 146.4,52.95 146.18,52.74 146.18,51.33 v1(145.77,50.91)
M_A_A2: length 65.8
  TOP w0.102: JDIM1000.132 146.35,55.49 146.59,55.25 146.59,52.42 v1(147.09,51.92)
  IN4 w0.076: 155.4,91.32 155.4,101.6 v1(155.81,102.01)
  IN4 w0.152: v1(147.09,51.92) 146.94,52.07 146.94,67.12 147.31,67.48 147.31,69.75 156.83,79.26 156.83,86.09 155.4,87.51 155.4,91.32
  BOTTOM w0.076: U9001.AN4 155.49,102.34 v1(155.81,102.01)
  BOTTOM w0.102: v1(147.09,51.92) 147.09,52.36 146.97,52.48 146.67,52.48 146.54,52.36 146.54,51.24 146.35,51.06 JDIM1001.132
M_A_A3: length 66.2
  TOP w0.102: JDIM1000.131 146.1,49.84 145.36,50.59 145.36,51.32 145.13,51.55 145.13,51.97 145.35,52.18 v1(145.77,52.18)
  IN4 w0.152: v1(145.77,52.18) 145.76,52.19 145.76,52.64 145.95,52.83 145.95,67.53 146.32,67.9 146.32,70.16 155.84,79.67 155.84,86.06 154.82,87.08 154.82,96.43 v1(153.7,97.55)
  BOTTOM w0.076: v1(153.7,97.55) 154.26,98.12 154.26,100.01 154.15,100.12 154.15,101.01 154.29,101.15 154.29,101.86 154.44,102.02 154.79,102.02 154.97,102.19 154.97,102.7 154.69,102.99 U9001.AP5
  BOTTOM w0.102: v1(145.77,52.18) 145.77,52.89 146.1,53.23 JDIM1001.131
M_A_A4: length 64.4
  TOP w0.102: v1(145.46,53.33) 145.61,53.17 145.93,53.17 146.21,53.45 146.21,54.16 146.34,54.29 146.34,54.91 146.02,55.23 145.55,55.23 145.35,55.42 JDIM1000.128
  IN4 w0.152: v1(145.46,53.33) 144.96,53.82 144.96,70.2 154.85,80.08 154.85,85.91 154.24,86.52 154.24,94.14 154,94.38 153.54,94.38 152.94,94.98 152.94,96.2 153.14,96.4 153.46,96.4 v1(153.7,96.16)
  BOTTOM w0.076: v1(153.7,96.16) 153.74,96.16 154.13,96.56 154.13,97.66 154.46,97.99 154.46,100.11 154.3,100.27 154.3,100.76 U9001.AP2
  BOTTOM w0.102: v1(145.46,53.33) 145.35,53.22 JDIM1001.128
M_A_A5: length 66.3
  TOP w0.102: JDIM1000.126 144.85,55.56 145.17,55.25 145.17,55.02 145.02,54.87 144.74,54.87 144.25,55.35 143.97,55.35 143.75,55.13 143.75,54.85 143.9,54.69 144.28,54.69 144.43,54.54 144.43,54.16 144.61,53.98 144.84,53.98 v1(145.46,54.6)
  IN4 w0.152: v1(153.68,95.53) 154.15,96 154.41,96 154.54,95.87 154.54,95.51 154.21,95.18 154.21,94.7 154.51,94.39 154.51,86.88 155.34,86.05 155.34,79.88 145.46,69.99 145.46,69.62 145.61,69.48 145.68,69.48 145.82,69.33 145.82,69.12 145.68,68.97 145.61,68.97 145.46,68.82 145.46,68.61 145.61,68.46 145.68,68.46 145.82,68.31 145.82,68.1 145.68,67.95 145.61,67.95 145.46,67.8 v1(145.46,54.6)
  BOTTOM w0.076: v1(153.68,95.53) 154.27,95.53 154.43,95.69 154.43,97.5 154.67,97.74 154.67,100.3 U9001.AP1
  BOTTOM w0.102: v1(145.46,54.6) 145.05,54.19 145.05,50.44 144.85,50.25 JDIM1001.126
M_A_A6: length 70.3
  TOP w0.102: v1(144.42,51.06) 144.69,51.33 144.95,51.33 145.1,51.18 145.1,50.66 145,50.55 144.28,50.55 144.18,50.45 144.18,50.1 144.43,49.84 144.69,49.84 144.97,50.12 145.24,50.12 145.42,49.94 145.42,49.75 145.1,49.44 JDIM1000.127
  IN4 w0.152: v1(152.43,94.93) 153.91,93.45 153.91,86.22 154.35,85.77 154.35,80.29 144.47,70.4 144.47,53.62 144.94,53.14 144.94,51.58 v1(144.42,51.06)
  BOTTOM w0.076: U9001.AP3 154.88,101.38 154.88,97.44 154.69,97.25 154.69,95.36 153.75,94.42 152.94,94.42 v1(152.43,94.93)
  BOTTOM w0.102: v1(144.42,51.06) 144.85,51.49 144.85,55.13 145.1,55.38 JDIM1001.127
M_A_A7: length 66.6
  TOP w0.102: JDIM1000.122 143.85,55.62 143.42,55.18 143.42,54.69 144.43,53.68 144.43,53.16 144.28,53.01 144.01,53.01 143.88,53.13 143.88,53.53 v1(143.4,54.01)
  IN4 w0.152: v1(143.4,54.01) 143.4,60.8 142.81,61.4 142.81,61.8 142.95,61.95 143.31,61.95 143.46,62.1 143.46,62.31 143.31,62.46 142.95,62.46 142.81,62.61 142.81,62.82 142.95,62.96 143.31,62.96 143.46,63.11 143.46,63.32 143.31,63.47 142.95,63.47 142.81,63.62 142.81,64.5 143.4,65.09 143.4,70.74 153.36,80.7 153.36,85.28 153.19,85.44 153.19,92.26 v1(152.43,93.02)
  BOTTOM w0.076: v1(152.43,93.02) 153.09,93.02 155.32,95.25 U9001.AN1
  BOTTOM w0.102: JDIM1001.122 143.85,50.44 144.02,50.6 144.02,53.39 v1(143.4,54.01)
M_A_A8: length 65.6
  TOP w0.102: v1(144.42,52.33) 143.85,51.76 143.85,50.05 144.6,49.29 JDIM1000.125
  IN4 w0.152: v1(144.42,52.33) 144.42,52.96 143.95,53.43 143.95,63.53 143.48,64 143.48,64.48 143.95,64.94 143.95,70.59 153.85,80.49 153.85,85.5 153.55,85.81 153.55,93.3 153.2,93.66 v1(152.43,93.66)
  BOTTOM w0.076: v1(152.43,93.66) 153.28,93.66 155.1,95.48 155.1,100.09 155.04,100.15 155.04,101.17 155.32,101.45 U9001.AN3
  BOTTOM w0.102: JDIM1001.125 144.6,55.58 144.42,55.39 v1(144.42,52.33)
M_A_A9: length 68.5
  TOP w0.102: JDIM1000.121 143.6,50.33 143.51,50.43 143.16,50.43 142.96,50.22 142.78,50.22 142.65,50.35 142.65,50.6 142.91,50.86 142.91,51.11 142.63,51.39 142.63,51.75 142.78,51.9 142.97,51.9 v1(143.4,51.47)
  IN4 w0.076: 152.37,89.97 152.05,90.29 152.05,96.07 153.19,97.21 153.19,98.99 153.7,99.5 153.7,101.61 v1(153.25,102.06)
  IN4 w0.152: 152.37,89.97 152.37,81.11 142.41,71.15 142.41,67.1 141.81,66.51 141.81,60.99 142.41,60.39 142.41,53.01 142.9,52.52 142.9,52 143.42,51.47 v1(143.4,51.47)
  BOTTOM w0.076: U9001.AT4 152.97,102.34 v1(153.25,102.06)
  BOTTOM w0.102: v1(143.4,51.47) 142.99,51.88 142.99,54.25 143.6,54.86 JDIM1001.121
M_A_A10: length 65.8
  TOP w0.102: v1(152.38,53.61) 152.13,53.61 152,53.47 152,53.2 151.84,53.04 151.67,53.04 151.54,53.17 151.54,53.91 151.67,54.03 152,54.03 152.23,54.26 152.23,54.68 151.85,55.05 JDIM1000.146
  IN4 w0.152: v1(152.38,53.61) 152.38,55.62 151.96,56.04 151.96,61.01 152.11,61.17 152.23,61.17 152.38,61.32 152.38,61.55 152.23,61.7 152.11,61.7 151.96,61.85 151.96,62.08 152.11,62.23 152.23,62.23 152.38,62.39 152.38,62.61 152.23,62.77 152.11,62.77 151.96,62.92 151.96,63.16 152.38,63.58 152.38,68.15 161.53,77.29 161.53,86.85 159.29,89.09 159.29,94.01 159.65,94.37 159.65,97.72 159.43,97.93 v1(158.72,97.93)
  BOTTOM w0.076: U9001.AH2 159.32,100.74 159.32,98.23 159.02,97.93 v1(158.72,97.93)
  BOTTOM w0.102: v1(152.38,53.61) 151.78,53.01 151.78,49.86 151.85,49.78 JDIM1001.146
M_A_A11: length 65.2
  TOP w0.102: v1(143.4,52.74) 143.11,52.74 142.74,53.11 142.74,55.13 143.35,55.74 JDIM1000.120
  IN4 w0.152: v1(143.4,52.74) 142.9,53.24 142.9,60.6 142.31,61.19 142.31,65 142.46,65.15 142.75,65.15 142.9,65.3 142.9,65.51 142.75,65.66 142.46,65.66 142.31,65.8 142.31,66.15 142.51,66.35 142.78,66.35 142.9,66.48 142.9,70.94 152.86,80.9 152.86,90.18 152.51,90.53 152.51,90.82 152.81,91.12 152.81,91.37 v1(152.43,91.75)
  BOTTOM w0.076: U9001.AN2 155.61,100.75 155.61,94.93 v1(152.43,91.75)
  BOTTOM w0.102: JDIM1001.120 143.36,48.47 143.36,50.48 143.81,50.94 143.81,52.33 v1(143.4,52.74)
M_A_A12: length 65.6
  TOP w0.102: v1(141.9,53.9) 142.4,53.4 142.4,50.09 143.1,49.38 JDIM1000.119
  IN4 w0.076: 151.87,89.72 151.87,96.48 152.35,96.96 152.35,97.78 v1(151.62,98.51)
  IN4 w0.152: v1(141.9,53.9) 141.9,60.21 141.32,60.78 141.32,66.71 141.9,67.29 141.9,71.34 151.87,81.31 151.87,89.72
  BOTTOM w0.076: v1(151.62,98.51) 151.62,101.89 U9001.AU4
  BOTTOM w0.102: JDIM1001.119 143.1,55.77 142.9,55.57 142.53,55.57 142.39,55.42 142.39,55.27 142.81,54.84 142.81,54.7 142.64,54.53 142.49,54.53 142.27,54.75 141.97,55.05 141.8,55.05 141.59,54.83 141.59,54.56 141.74,54.41 142.02,54.41 142.25,54.19 142.25,54.01 142.14,53.9 v1(141.9,53.9)
M_A_A13: length 68
  TOP w0.102: v1(156.97,54.02) 155.81,54.02 155.48,53.69 155.48,53.14 155.35,53.02 154.97,53.02 154.85,53.14 JDIM1000.158
  IN4 w0.152: v1(161.23,96.03) 161.89,96.03 162.12,95.8 162.12,93.43 162.62,92.93 162.62,89.56 165.94,86.24 165.94,75.46 156.84,66.35 156.84,60.2 156.95,60.09 156.95,59.57 156.84,59.45 156.84,59.04 156.95,58.92 156.95,58.4 156.84,58.29 156.84,57.87 156.95,57.75 156.95,57.23 156.84,57.12 156.84,56.7 156.95,56.58 156.95,56.06 156.84,55.95 156.84,55.53 156.95,55.42 156.95,54.9 156.84,54.78 156.84,54.16 v1(156.97,54.02)
  BOTTOM w0.076: U9001.AE3 162.27,101.69 162.4,101.56 162.4,97.53 162.21,97.34 161.96,97.34 161.73,97.12 161.73,96.53 v1(161.23,96.03)
  BOTTOM w0.102: v1(156.97,54.02) 156.23,53.28 156.23,50.75 154.85,49.38 JDIM1001.158
M_A_A14: length 66.9
  TOP w0.102: v1(153.91,53.93) 153.27,53.29 153.27,49.53 153.1,49.37 JDIM1000.151
  IN4 w0.152: v1(160.79,102.64) 161.27,102.16 161.27,101.18 160.51,100.42 160.51,94.12 160.07,93.68 160.07,89.57 163.05,86.6 163.05,76.66 153.91,67.52 153.91,58.18 153.91,58.17 153.91,57.96 153.48,57.54 153.48,56.68 153.91,56.25 153.91,53.94 v1(153.91,53.93)
  BOTTOM w0.076: v1(160.79,102.64) 160.49,102.34 U9001.AG4
  BOTTOM w0.102: JDIM1001.151 153.1,55.28 153.45,54.94 154.24,54.94 154.34,54.83 154.34,54.55 154.24,54.45 153.1,54.45 152.98,54.33 152.98,54.05 153.09,53.93 v1(153.91,53.93)
M_A_A15: length 66.8
  TOP w0.102: v1(153.91,51.88) 154.35,52.32 JDIM1000.156
  IN4 w0.152: v1(153.91,51.88) 154.1,51.88 154.97,52.75 154.97,67.13 164.08,76.23 164.08,86.48 160.59,89.97 160.59,90.23 160.84,90.48 160.84,90.76 160.59,91.02 160.59,93.48 v1(161.23,94.12)
  BOTTOM w0.076: U9001.AD1 162.86,99.78 163.01,99.63 163.01,99.25 162.85,99.08 162.85,98.78 163.01,98.61 163.01,98.27 162.85,98.1 162.85,97.51 163.01,97.34 163.01,96.74 162.67,96.4 162.67,96.16 162.97,95.86 162.97,95.69 162.85,95.56 162.62,95.56 162.34,95.84 162.23,95.84 161.93,95.54 161.93,94.82 v1(161.23,94.12)
  BOTTOM w0.102: JDIM1001.156 154.35,50.15 154.25,50.26 153.68,50.26 153.58,50.36 153.58,50.64 153.68,50.74 154.25,50.74 154.41,50.89 154.41,51.39 v1(153.91,51.88)
M_A_A16: length 68.6
  TOP w0.102: JDIM1000.152 153.35,55.34 153.07,55.05 153.07,52.33 v1(152.39,51.65)
  IN4 w0.152: v1(152.39,51.65) 152.43,51.65 153.41,52.63 153.41,56.05 152.99,56.47 152.99,57.75 153.41,58.17 153.41,67.72 162.55,76.87 162.55,86.63 159.82,89.37 159.82,93.81 160.18,94.17 160.18,101.37 v1(160.79,101.99)
  BOTTOM w0.076: v1(160.79,101.99) 160.73,102.04 159.9,102.04 U9001.AH4
  BOTTOM w0.102: v1(152.39,51.65) 152.72,51.65 152.81,51.75 152.81,52.27 152.94,52.4 153.2,52.4 153.35,52.25 JDIM1001.152
M_A_BG#0: length 65.4
  TOP w0.102: v1(140.43,53.9) 140.85,53.48 140.85,50.95 142.1,49.69 JDIM1000.115
  IN4 w0.076: 151.16,91.12 151.36,91.32 151.36,95.85 151.02,96.2 v1(150.81,96.2)
  IN4 w0.114: v1(140.43,53.9) 140.43,59.6 139.85,60.17 139.85,67.32 140.43,67.89 140.43,71.94 150.41,81.92 150.41,90.36 151.16,91.12
  BOTTOM w0.076: U9001.AU1 152.07,99.82 152.48,99.4 152.48,97.09 151.59,96.2 v1(150.81,96.2)
  BOTTOM w0.102: JDIM1001.115 142.1,55.64 141.13,54.66 141.13,54.39 141.36,54.16 141.36,52.94 141.23,52.81 141.03,52.81 140.88,52.97 140.88,53.78 140.76,53.9 v1(140.43,53.9)
M_A_BG#1: length 64.8
  TOP w0.102: JDIM1000.113 141.61,49.74 140.99,50.35 140.62,50.35 140.43,50.54 v1(140.43,52.63)
  IN4 w0.076: v1(150.81,94.93) 151.21,94.53 151.21,91.57 150.91,91.27
  IN4 w0.114: v1(140.43,52.63) 140.01,53.05 140.01,59.42 139.43,60 139.43,67.49 140.01,68.07 140.01,72.17 149.99,82.15 149.99,90.35 150.91,91.27
  BOTTOM w0.076: U9001.AU2 152.07,100.78 152.34,100.5 152.34,99.97 152.74,99.58 152.74,96.96 151.72,95.94 151.72,95.63 151.02,94.93 v1(150.81,94.93)
  BOTTOM w0.102: JDIM1001.113 141.61,55.65 140.02,54.07 140.02,53.04 v1(140.43,52.63)
M_A_BS#0: length 66.4
  TOP w0.102: v1(152.39,52.34) 152.85,52.8 JDIM1000.150
  IN4 w0.114: v1(152.39,52.34) 152.9,52.84 152.9,55.83 152.47,56.26 152.47,60.68 152.9,61.1 152.9,67.93 162.04,77.08 162.04,86.74 159.54,89.24 159.54,93.91 159.9,94.27 159.9,98.51 159.2,99.2 v1(158.72,99.2)
  BOTTOM w0.076: v1(158.72,99.2) 159.11,99.6 159.11,102.49 U9001.AH5
  BOTTOM w0.102: JDIM1001.150 152.85,49.48 152.55,49.78 152.33,49.78 151.98,50.13 151.98,51.93 v1(152.39,52.34)
M_A_BS#1: length 65.6
  TOP w0.102: v1(150.81,51.64) 151.37,52.21 151.72,52.21 151.92,52 151.92,51.62 151.29,50.99 151.29,50.22 151.6,49.91 JDIM1000.145
  IN4 w0.114: v1(150.81,51.64) 151.84,52.67 151.84,55.44 151.44,55.83 151.44,63.37 151.84,63.76 151.84,68.33 161.01,77.51 161.01,86.89 159.06,88.84 159.06,94.12 159.39,94.45 159.39,95.82 159.17,96.03 159.17,96.85 v1(158.72,97.3)
  BOTTOM w0.076: U9001.AH1 159.61,98.19 v1(158.72,97.3)
  BOTTOM w0.102: JDIM1001.145 151.6,55.18 151.29,54.86 151.29,52.12 v1(150.81,51.64)
M_A_CB0: length 70.4
  TOP w0.102: JDIM1000.88 135.35,55.75 134.73,55.12 133.86,55.12 132.87,54.13 132.87,52.47 v1(133.28,52.06)
  IN4 w0.102: v1(133.28,52.06) 133.59,52.06 133.69,52.17 133.69,53.06 133.89,53.25 133.89,53.36 133.67,53.58 133.67,53.69 133.79,53.81 133.94,53.81 134.02,53.89 134.02,54.41 133.69,54.74 133.69,71.78 133.79,71.88 133.86,71.88 133.97,71.98 133.97,72.19 133.86,72.29 133.79,72.29 133.69,72.39 133.69,72.59 133.79,72.69 133.86,72.69 133.97,72.79 133.97,73 133.86,73.1 133.79,73.1 133.69,73.2 133.69,73.59 145.07,84.97 145.07,85.69 144.91,85.85 144.91,93.17 147.76,96.02 147.76,96.83 147.86,96.94 v1(148.22,96.94)
  BOTTOM w0.076: U9001.BA2 149.55,100.79 149.26,100.49 149.26,100.29 149.27,100.27 149.27,100.27 149.33,100.21 149.33,99.35 149.13,99.15 149.13,98.77 149.26,98.64 149.26,97.97 149.17,97.89 148.88,97.89 148.62,97.63 148.62,97.34 v1(148.22,96.94)
  BOTTOM w0.102: JDIM1001.88 135.35,49.59 134.85,50.1 134.02,50.1 133.89,50.22 133.89,50.45 134.04,50.6 134.58,50.6 134.7,50.73 134.7,50.96 134.55,51.11 133.89,51.11 133.76,51.24 133.76,51.58 v1(133.28,52.06)
M_A_CB1: length 69.6
  TOP w0.102: JDIM1000.92 136.35,55.43 136.2,55.28 135.77,55.28 135.57,55.08 135.57,54.77 135.74,54.6 135.74,53.49 135.57,53.32 135.34,53.32 135.16,53.5 135.16,54.44 135.06,54.54 134.87,54.54 v1(134.43,54.1)
  IN4 w0.102: v1(134.43,54.1) 134.43,54.47 134.02,54.87 134.02,71.38 134.3,71.65 134.3,73.73 145.4,84.84 145.4,85.88 145.24,86.04 145.24,86.28 145.4,86.45 145.4,86.69 145.24,86.86 145.24,87.1 145.4,87.26 145.4,87.5 145.24,87.67 145.24,87.91 145.4,88.08 145.4,88.32 145.24,88.48 145.24,88.72 145.4,88.89 145.4,89.13 145.24,89.29 145.24,89.54 145.4,89.7 145.4,89.94 145.24,90.11 145.24,90.35 145.4,90.51 145.4,90.75 145.24,90.92 145.24,91.16 145.4,91.33 145.4,91.57 145.24,91.73 145.24,92.37 145.35,92.47 145.55,92.47 145.65,92.57 145.65,92.78 145.55,92.88 145.35,92.88 145.24,92.98 145.24,93.25 145.48,93.49 145.63,93.49 145.81,93.31 145.96,93.31 146.1,93.45 146.1,93.6 145.91,93.78 145.91,93.92 148.22,96.23 v1(148.22,96.3)
  BOTTOM w0.076: U9001.BA1 149.55,97.67 149.26,97.37 149.26,97.12 149.46,96.92 149.46,96.81 149.24,96.59 149.13,96.59 148.92,96.8 148.81,96.8 148.65,96.64 148.65,96.53 148.86,96.32 148.86,96.21 148.72,96.08 148.44,96.08 v1(148.22,96.3)
  BOTTOM w0.102: v1(134.43,54.1) 134.89,53.64 134.89,52.27 135.16,52 135.16,50.71 136.35,49.51 JDIM1001.92
M_A_CB2: length 70.1
  TOP w0.102: JDIM1000.104 139.35,55.75 137.95,54.35 137.95,52.46 137.66,52.16 v1(137.2,52.16)
  IN4 w0.102: v1(137.2,52.16) 136.49,52.88 136.49,55.32 136.11,55.7 136.11,65.5 136.35,65.75 136.35,66.08 136.25,66.18 136.21,66.18 136.11,66.28 136.11,66.49 136.21,66.59 136.25,66.59 136.35,66.69 136.35,66.89 136.25,66.99 136.21,66.99 136.11,67.1 136.11,67.3 136.21,67.4 136.25,67.4 136.35,67.5 136.35,67.71 136.25,67.81 136.21,67.81 136.11,67.91 136.11,68.11 136.21,68.21 136.25,68.21 136.35,68.32 136.35,68.52 136.25,68.62 136.21,68.62 136.11,68.72 136.11,68.92 136.21,69.03 136.25,69.03 136.35,69.13 136.35,69.33 136.25,69.43 136.21,69.43 136.11,69.53 136.11,69.74 136.21,69.84 136.25,69.84 136.35,69.94 136.35,72.88 147.23,83.75 147.23,92.51 148.93,94.22 148.93,101.06 149.88,102.01 v1(150.73,102.01)
  BOTTOM w0.076: v1(150.73,102.01) 150.41,102.34 U9001.AY4
  BOTTOM w0.102: v1(137.2,52.16) 136.79,51.76 136.79,50.73 137.17,50.35 138.43,50.35 139.35,49.43 JDIM1001.104
M_A_CB3: length 71.5
  TOP w0.102: v1(137.22,51.53) 137.46,51.3 137.6,51.3 137.7,51.4 137.7,51.82 137.83,51.94 138.12,51.94 138.22,51.84 138.22,50.22 138.47,49.97 139.48,49.97 139.61,49.84 JDIM1000.105
  IN4 w0.102: v1(150.73,102.66) 150.07,102.66 148.65,101.23 148.65,94.32 146.89,92.57 146.89,83.88 136.02,73.01 136.02,70.94 135.78,70.69 135.78,55.56 136.16,55.18 136.16,52.16 136.79,51.53 v1(137.22,51.53)
  BOTTOM w0.076: U9001.AY5 150.41,102.99 v1(150.73,102.66)
  BOTTOM w0.102: v1(137.22,51.53) 137.32,51.53 137.7,51.91 137.7,53.9 139.61,55.8 JDIM1001.105
M_A_CB4: length 71.7
  TOP w0.102: v1(133.28,52.69) 133.63,52.69 133.76,52.56 133.76,50.55 133.89,50.43 134.7,50.43 135.1,50.03 JDIM1000.87
  IN4 w0.102: v1(133.28,52.69) 132.98,52.69 132.88,52.8 132.88,64.7 133.03,64.85 133.03,65.1 132.88,65.26 132.88,65.51 133.03,65.66 133.03,65.92 132.88,66.07 132.88,66.32 133.03,66.48 133.03,66.73 132.88,66.88 132.88,67.14 133.03,67.29 133.03,67.54 132.88,67.69 132.88,67.95 133.03,68.1 133.03,68.36 132.88,68.51 132.88,68.76 133.03,68.91 133.03,69.17 132.88,69.32 132.88,69.57 133.03,69.73 133.03,69.98 132.88,70.13 132.88,70.39 133.03,70.54 133.03,70.79 132.88,70.95 132.88,71.2 133.03,71.35 133.03,71.61 132.88,71.76 132.88,72.01 133.03,72.17 133.03,72.42 132.88,72.57 132.88,72.83 133.03,72.98 133.03,73.23 132.88,73.38 132.88,73.71 144.39,85.23 144.39,85.43 144.25,85.58 144.25,93.07 145.19,94.02 147.35,96.17 147.35,98.77 147.68,99.1 147.96,99.1 v1(148.22,98.84)
  BOTTOM w0.076: v1(148.22,98.84) 148.49,98.84 148.62,98.97 148.62,99.42 148.96,99.75 148.96,100.81 149.08,100.93 149.08,101.61 148.98,101.71 148.98,102.88 149.21,103.1 149.44,103.1 U9001.BA5
  BOTTOM w0.102: v1(133.28,52.69) 132.87,53.1 132.87,54.48 133.64,55.24 134.02,55.24 134.33,55.55 134.96,55.55 135.1,55.7 JDIM1001.87
M_A_CB5: length 71.9
  TOP w0.102: JDIM1000.91 136.1,49.31 134.43,50.99 134.43,50.99 134.02,51.4 134.02,53.23 v1(133.28,53.96)
  IN4 w0.102: v1(133.28,53.96) 133.41,53.96 133.61,54.17 133.61,54.35 133.36,54.6 133.36,54.93 133.21,55.08 133.21,55.34 133.36,55.49 133.36,55.74 133.21,55.89 133.21,56.15 133.36,56.3 133.36,56.55 133.21,56.71 133.21,56.96 133.36,57.11 133.36,57.37 133.21,57.52 133.21,57.77 133.36,57.93 133.36,58.18 133.21,58.33 133.21,58.59 133.36,58.74 133.36,58.99 133.21,59.15 133.21,59.4 133.36,59.55 133.36,59.81 133.21,59.96 133.21,60.21 133.36,60.36 133.36,60.62 133.21,60.77 133.21,61.03 133.36,61.18 133.36,61.43 133.21,61.58 133.21,61.84 133.36,61.99 133.36,62.24 133.21,62.4 133.21,62.65 133.36,62.8 133.36,63.06 133.21,63.21 133.21,63.46 133.36,63.62 133.36,63.87 133.21,64.02 133.21,64.28 133.36,64.43 133.36,73.73 144.74,85.11 144.74,85.55 144.58,85.72 144.58,93.12 147.55,96.1 147.55,97.12 147.76,97.32 147.76,97.86 147.58,98.04 147.58,98.31 147.78,98.52 147.91,98.52 v1(148.22,98.21)
  BOTTOM w0.076: v1(148.22,98.21) 148.44,97.98 148.62,97.98 148.88,98.24 148.88,99.27 149.11,99.5 149.11,99.69 149.11,99.69 149.11,100.65 149.26,100.8 149.26,102.22 149.37,102.34 U9001.BA4
  BOTTOM w0.102: JDIM1001.91 136.1,55.68 136.3,55.49 136.3,55.33 136.04,55.08 135.74,55.08 135.67,55.15 135.67,55.43 135.54,55.56 135.33,55.56 135.23,55.46 135.23,55.09 135.13,54.99 134.87,54.99 134.78,55.08 134.78,55.28 134.71,55.35 134.41,55.35 134.05,54.99 133.7,54.99 133.15,54.44 133.15,54.1 v1(133.28,53.96)
M_A_CB6: length 69.6
  TOP w0.102: v1(137.2,54.07) 136.79,53.66 136.79,50.73 137.17,50.35 137.69,50.35 138.61,49.44 JDIM1000.101
  IN4 w0.102: v1(150.73,100.09) 150.28,100.53 149.65,100.53 149.51,100.4 149.51,100.05 149.61,99.94 150.17,99.94 150.27,99.84 150.27,99.56 150.17,99.46 149.61,99.46 149.51,99.36 149.51,99.08 149.61,98.98 149.92,98.98 150.02,98.88 150.02,98.6 149.92,98.5 149.56,98.5 149.46,98.4 149.46,93.86 147.78,92.18 147.78,83.37 137.01,72.6 137.01,61.36 136.77,61.12 136.77,56.17 137.2,55.74 v1(137.2,54.07)
  BOTTOM w0.076: v1(150.73,100.09) 150.43,100.39 U9001.AY1
  BOTTOM w0.102: v1(137.2,54.07) 136.78,53.65 135.69,53.65 135.55,53.79 135.55,54.02 135.69,54.16 136.56,54.16 137.45,55.05 137.96,55.05 138.61,55.69 JDIM1001.101
M_A_CB7: length 68.7
  TOP w0.102: v1(137.2,52.8) 137.62,53.23 137.62,54.29 137.32,54.59 136.94,54.59 136.81,54.72 136.81,55.02 136.96,55.17 137.83,55.17 138.35,55.7 JDIM1000.100
  IN4 w0.102: v1(150.73,100.71) 150.41,101.03 149.49,101.03 149.18,100.73 149.18,94.09 147.5,92.41 147.5,83.56 136.68,72.74 136.68,65.56 136.58,65.46 136.54,65.46 136.44,65.36 136.44,65.16 136.54,65.06 136.58,65.06 136.68,64.95 136.68,64.75 136.58,64.65 136.54,64.65 136.44,64.55 136.44,64.35 136.54,64.24 136.58,64.24 136.68,64.14 136.68,63.94 136.58,63.84 136.54,63.84 136.44,63.74 136.44,63.53 136.54,63.43 136.58,63.43 136.68,63.33 136.68,63.13 136.58,63.02 136.54,63.02 136.44,62.92 136.44,62.72 136.54,62.62 136.58,62.62 136.68,62.52 136.68,62.31 136.58,62.21 136.54,62.21 136.44,62.11 136.44,61.91 136.54,61.81 136.58,61.81 136.68,61.7 136.68,61.5 136.58,61.4 136.54,61.4 136.44,61.3 136.44,55.84 136.82,55.46 136.82,53.18 v1(137.2,52.8)
  BOTTOM w0.076: U9001.AY2 150.41,101.04 v1(150.73,100.71)
  BOTTOM w0.102: JDIM1001.100 138.35,49.43 137.83,49.96 137.16,49.96 136.53,50.59 136.53,52.13 v1(137.2,52.8)
M_A_CKE0: length 61.2
  IN4 w0.076: v1(153.25,100.11) 152.7,100.11 150.74,98.15
  IN4 w0.114: 150.74,98.15 150.42,97.83 150.42,92.74 149.15,91.47 149.15,82.5 138.6,71.95 138.6,56.57 138.78,56.39 138.78,53.94 v1(139.4,53.32)
  BOTTOM w0.076: U9001.AT1 152.97,100.39 v1(153.25,100.11)
  BOTTOM w0.102: v1(139.4,53.32) 138.84,52.76 138.84,52.64 138.72,52.52 138.33,52.52 138.21,52.64 138.21,53.4 138.72,53.91 138.72,54.47 139.64,55.4 140.34,55.4 140.61,55.66 JDIM1001.109
M_A_CKE1: length 60.3
  IN4 w0.114: v1(139.4,52.68) 138.36,53.72 138.36,56.22 138.18,56.4 138.18,72.12 148.73,82.67 148.73,91.67 150.14,93.08 150.14,97.86 153.05,100.76 v1(153.25,100.76)
  BOTTOM w0.076: U9001.AT2 152.97,101.04 v1(153.25,100.76)
  BOTTOM w0.102: JDIM1001.110 140.85,49.84 140.11,50.58 140.11,51.97 v1(139.4,52.68)
M_A_CKE2: length 67.7
  TOP w0.102: JDIM1000.109 140.61,49.42 139.8,50.22 139.38,50.22 138.61,50.99 138.61,53.8 v1(139.4,54.59)
  IN4 w0.114: v1(150.81,93.66) 150.81,92.48 150.63,92.29 150.43,92.29 150.15,92.01 150.15,91.75 150.4,91.5 150.4,91.37 150.16,91.14 150,91.14 149.87,91.27 149.69,91.27 149.57,91.15 149.57,82.33 139.59,72.35 139.59,71.93 139.48,71.81 139.17,71.81 139.01,71.66 139.01,71.35 139.13,71.24 139.48,71.24 139.59,71.12 139.59,70.91 139.48,70.79 139.13,70.79 139.01,70.68 139.01,70.46 139.13,70.35 139.48,70.35 139.59,70.24 139.59,70.02 139.48,69.91 139.13,69.91 139.01,69.79 139.01,69.58 139.13,69.46 139.48,69.46 139.59,69.35 139.59,69.13 139.48,69.02 139.13,69.02 139.01,68.9 139.01,68.69 139.13,68.57 139.48,68.57 139.59,68.46 139.59,68.24 139.48,68.13 139.13,68.13 139.01,68.01 139.01,57.82 139.13,57.71 139.48,57.71 139.59,57.59 139.59,57.38 139.48,57.26 139.13,57.26 139.01,57.15 139.01,56.83 139.12,56.73 139.45,56.73 139.59,56.59 139.59,56.3 139.48,56.18 139.31,56.18 139.2,56.07 139.2,55.85 139.31,55.74 139.48,55.74 139.59,55.62 139.59,55.3 139.4,55.12 v1(139.4,54.59)
  BOTTOM w0.076: U9001.AT3 152.52,101.41 152.52,100.17 153.17,99.53 153.17,96.89 151.94,95.66 151.94,94.06 151.54,93.66 v1(150.81,93.66)
M_A_CKE3: length 66.1
  TOP w0.102: JDIM1000.110 140.85,55.38 140.01,54.54 140.01,51.38 v1(139.4,50.78)
  IN4 w0.114: v1(153.25,102.71) 151.67,101.13 151.67,99.71 149.82,97.85 149.82,93.45 148.31,91.95 148.31,82.85 137.76,72.29 137.76,56.23 137.94,56.04 137.94,52.24 v1(139.4,50.78)
  BOTTOM w0.076: U9001.AT5 152.97,102.99 v1(153.25,102.71)
M_A_CLKN0: length 66.9
  IN4 w0.076: v1(148,53.73) 148,53.58 147.87,53.45 147.68,53.45 147.63,53.5 147.63,55.12 147.68,55.17 147.83,55.17 148,55.34 148,55.9 147.81,56.09 147.7,56.09 147.63,56.16 147.63,56.55 147.7,56.62 147.83,56.62 148,56.78 148,57.37 147.83,57.54 147.7,57.54 147.63,57.61 147.63,58.07 147.7,58.15 147.83,58.15 148,58.31 148,58.9 147.83,59.06 147.7,59.06 147.63,59.14 147.63,59.52 147.7,59.59 147.81,59.59 148,59.78 148,60.32 147.81,60.51 147.7,60.51 147.63,60.58 147.63,60.96 147.7,61.04 147.81,61.04 148,61.23 148,61.77 147.81,61.96 147.7,61.96 147.63,62.03 147.63,62.41 147.7,62.49 147.81,62.49 148,62.68 148,63.22 147.81,63.4 147.7,63.4 147.63,63.48 147.63,63.86 147.7,63.94 147.81,63.94 148,64.12 148,64.66 147.81,64.85 147.7,64.85 147.63,64.93 147.63,65.31 147.7,65.38 147.81,65.38 148,65.57 148,66.11 147.81,66.3 147.7,66.3 147.63,66.38 147.63,66.83 148,67.2 148,69.46 157.51,78.98 157.51,86.18 155.95,87.74 155.95,89.21 156.03,89.29 156.18,89.29 156.37,89.48 156.37,90.02 156.18,90.2 156.03,90.2 155.95,90.28 155.95,90.66 156.03,90.74 156.18,90.74 156.37,90.93 156.37,91.46 156.18,91.65 156.03,91.65 155.95,91.73 155.95,91.92 155.8,92.07 155.8,92.81 155.93,92.95 156.11,92.95 v1(156.21,92.85)
  BOTTOM w0.076: v1(156.21,92.85) 156.45,93.1 v5(157.92,93.1) 158.62,93.1 158.67,93.16 160.49,94.97 160.49,97.61 160.76,97.89 160.76,100.62 U9001.AG2
  BOTTOM w0.102: v1(148,53.73) 147.74,53.48 147.52,53.48 147.39,53.35 147,53.35 146.87,53.48 146.87,53.7 147.1,53.93 147.1,54.39 146.87,54.62 146.87,54.86 147,55 147.72,55 147.94,55.22 147.94,55.55 148.1,55.72 JDIM1001.139

# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TXN4_WWAN: length 18.4
  BOTTOM w0.102: C9170.2 335.94,18.14 336.05,18.02 336.05,17.6 335.91,17.46 335.33,17.46 334.6,16.73 333.83,16.73 333.33,16.22 333.33,15.03 336.71,11.65 341.6,11.65 342.4,10.85 342.4,9.68 342.25,9.53 CON4201.47
PCIE_TXN4_WWAN_C: length 145.2
  IN4 w0.076: v1(232.82,53.94) 232.56,53.67 232.56,52.68 232.7,52.54 233.65,52.54 238.14,48.06 239.55,46.64 239.55,45.35 240.16,44.74 240.16,42.92 241.97,41.11 241.97,40.6 242.18,40.39 244.46,40.39 246.3,38.55 248.22,38.55 248.57,38.19 258.1,38.19 258.27,38.37 277.33,38.37 278.12,37.58 281.35,37.58 282.29,36.64 285.69,36.64 286.05,36.29 287.91,36.29 289.2,35 295.42,35 295.68,34.75 312.83,34.75 315.06,32.51 323.05,32.51 324.31,33.77 328.43,33.77 330.11,32.09 330.61,32.09 334.23,28.48 334.23,27.84 334.77,27.31 335.53,27.31 336.33,26.51 336.33,23.85 337.38,22.8 337.38,20.6 337.06,20.28 337.06,19.29 336.71,18.94 336.22,18.94 335.85,19.31 335.85,19.52 v1(335.6,19.77)
  BOTTOM w0.102: U9002.D20 243.13,62.5 242.26,61.64 241.95,61.64 240.79,60.48 240.13,60.48 237.65,58 236.63,58 v6(235.34,56.71) 233.2,54.57 232.84,54.57 232.65,54.38 232.65,54.12 v1(232.82,53.94) ; C9170.1 335.92,19.16 335.92,19.45 v1(335.6,19.77)
PCIE_TXN5_TBT: length 6.5
  BOTTOM w0.076: U8001.Y22 340.32,110.33 339.63,110.33 339.53,110.23 339.53,108.57 338.49,107.53 338.49,106.93 338.51,106.91 338.51,106.9
  BOTTOM w0.102: 338.51,106.9 338.51,106.62 338.18,106.29 337.72,106.29 C9174.1
PCIE_TXN5_TBT_C: length 213.7
  IN4 w0.076: v1(336.46,106.01) 336.46,106.3 336.57,106.42 336.81,106.42 336.99,106.24 336.99,103.29 335.87,102.17 335.87,88.31 337.2,86.97 337.2,82.3 340.4,79.11 346.92,79.11 349.48,76.56 350.08,76.56 351.91,74.73 351.91,73.04 353.1,71.85 353.1,63.22 355.4,60.92 355.4,58.63 357.22,56.81 357.22,54.74 356.74,54.26 356.74,50.91 358.43,49.22 358.43,46.34 356.11,44.02 354.26,44.02 352.84,42.6 351.89,42.6 349.66,40.38 346.9,40.38 346.52,39.99 343.93,39.99 343.41,40.52 338.32,40.52 337.81,41.02 326.5,41.02 326.04,40.56 322.78,40.56 322.34,41.01 317,41.01 316.44,41.57 305.94,41.57 305.39,41.01 299.12,41.01 298.36,41.77 295.73,41.77 295.05,41.09 290.4,41.09 290.04,41.45 288.21,41.45 287.76,41.91 287.19,41.91 285.66,43.45 283.98,43.45 283.62,43.8 275.94,43.8 273.92,45.82 271.46,45.82 270.97,45.33 258.18,45.33 255.4,48.11 254.41,48.11 253.27,49.25 250.96,49.25 248.55,51.67 248.55,53.37 246.58,55.34 246.58,56.77 244.52,58.83 244.52,59.62 244.07,60.07 241.26,60.07 240.46,59.27 240.19,59.27 240.06,59.4 v1(240.06,59.73)
  BOTTOM w0.102: C9174.2 336.99,106.23 336.84,106.39 336.64,106.39 336.46,106.21 v1(336.46,106.01) ; U9002.B21 242.5,61.55 241.01,60.06 240.69,60.06 240.36,59.73 v1(240.06,59.73)
PCIE_TXN6_TBT: length 5.9
  BOTTOM w0.076: U8001.T22 340.33,112.18 339.72,112.18 339.54,112.36 339,112.36 338.74,112.1 338.74,111.72 338.49,111.47 338.49,109.73 338.07,109.31 337.7,109.31 C9178.1
PCIE_TXN6_TBT_C: length 214.9
  IN4 w0.076: v1(240.44,58.51) 240.39,58.51 240.1,58.22 240.1,58.09 242.35,55.84 245.19,55.84 248,53.04 248,51.44 253.63,45.81 256.22,45.81 257.25,44.78 267.88,44.78 268.79,43.87 273.1,43.87 273.7,43.27 275.75,43.27 275.96,43.06 279.96,43.06 280.12,42.89 285.43,42.89 286.96,41.37 287.43,41.37 287.98,40.82 289.81,40.82 290.19,40.44 305.68,40.44 306.27,41.02 315.84,41.02 316.43,40.44 322.09,40.44 322.53,40 326.32,40 326.7,40.39 337.29,40.39 338.23,39.45 346.75,39.45 347.12,39.82 347.79,39.82 348.16,39.45 349.52,39.45 351.9,41.83 352.88,41.83 354.52,43.47 356.47,43.47 358.98,45.99 358.98,51.24 358.78,51.44 358.78,57.03 356.89,58.92 356.89,60.7 356.53,61.05 356.05,61.05 354.25,62.85 353.98,63.12 353.65,63.45 353.65,72.08 353.02,72.71 353.02,74.61 352.58,75.05 352.36,75.05 341.59,85.82 339.62,85.82 336.43,89.01 336.43,101.94 337.55,103.06 337.55,108.47 336.49,109.53 336.07,109.53 335.82,109.27 v1(335.82,109.18)
  BOTTOM w0.102: v1(240.44,58.51) 240.32,58.64 240.32,58.73 240.91,59.32 241.27,59.32 242.85,60.91 242.85,61.22 243.15,61.51 243.15,62.08 U9002.D21 ; C9178.2 336.99,109.26 336.79,109.46 336.1,109.46 v1(335.82,109.18)
PCIE_TXN7_TBT: length 4.4
  BOTTOM w0.076: U8001.M22 340.48,114.25 340.27,114.47 339.59,114.47 339.54,114.52 338.91,114.52 338.47,114.08 338.08,113.69 338.08,113.35 337.6,112.87 337.22,112.87
  BOTTOM w0.102: C9182.1 337.22,112.87
PCIE_TXN7_TBT_C: length 222.3
  IN4 w0.076: v1(239.05,56.73) 239.6,56.73 249.13,47.21 250.45,47.21 253.12,44.54 255.68,44.54 256.7,43.52 266.22,43.52 267.15,42.6 270.31,42.6 270.71,42.2 272.5,42.2 273.07,41.63 279.42,41.63 279.7,41.35 282.59,41.35 283.29,40.65 285.48,40.65 286.15,39.98 287.01,39.98 287.45,39.54 289.23,39.54 289.63,39.14 309.08,39.14 309.75,38.47 321.86,38.47 322.18,38.15 332.2,38.15 332.5,38.44 334.04,38.44 335.22,37.26 349.71,37.26 350.42,37.98 350.82,37.98 352.18,39.33 355.23,39.33 356.94,41.04 356.94,42.06 360.43,45.55 360.43,55.56 360.61,55.74 360.61,60.76 359.56,61.81 358.3,61.81 357.66,62.45 357.66,63.33 357.92,63.58 357.92,65.22 355.19,67.95 355.19,73.59 354.27,74.5 354.27,76.11 351.51,78.87 351.21,78.87 342.92,87.16 342.1,87.16 339.76,89.5 339.76,90.39 339.38,90.77 339,90.77 338.09,91.67 338.09,101.57 338.82,102.3 338.82,109.21 338.27,109.76 338.27,111.41 336.82,112.87 v1(335.82,112.87)
  BOTTOM w0.102: U9002.C23 243.48,60.91 243.37,60.8 241.84,59.27 241.84,58.82 239.76,56.73 v1(239.05,56.73) ; C9182.2 v1(335.82,112.87)
PCIE_TXN8_TBT: length 3.8
  BOTTOM w0.076: C9184.1 337.65,115.36 338.11,115.36 v5(338.53,115.78) 338.91,116.17 339.63,116.17 339.93,115.86 340.33,115.86 U8001.H22
PCIE_TXN8_TBT_C: length 224.7
  IN4 w0.076: v1(239.43,55.2) 239.64,55.2 239.81,55.03 239.81,54.4 240.74,53.47 242.28,53.47 242.51,53.24 249.13,46.63 250.97,45.41 253.07,44.02 255.69,42.64 266.56,42.64 266.99,42.2 270.05,42.2 270.44,41.81 272.26,41.81 272.83,41.24 279.16,41.24 279.42,40.97 282.31,40.97 283.03,40.26 285.26,40.26 285.93,39.59 286.8,39.59 287.23,39.16 289.06,39.16 289.8,38.42 293.79,38.42 294.14,38.06 321.68,38.06 322.78,36.96 329.16,36.96 329.86,36.26 330.46,36.26 332.24,36.82 348.3,36.82 348.74,36.37 350.88,36.37 355.57,39.02 356.39,39.84 357.28,40.73 357.5,40.73 357.85,41.08 357.98,41.33 357.99,41.34 357.99,41.36 358.7,43.04 358.94,43.27 359.15,43.49 360.81,45.15 360.81,55.31 360.99,55.49 360.99,61.17 359.91,62.25 359.91,64.52 356.21,68.22 356.21,73.68 354.87,75.02 354.87,76.54 339.69,91.72 339.69,93.75 338.49,94.95 338.49,99.15 339.31,99.98 339.31,103.19 339.72,103.6 339.72,107.7 339.5,107.91 339.5,109.44 338.74,110.2 338.74,111.6 336.78,115.01 336.16,115.62 336.09,115.62 335.82,115.36 v1(335.82,115.28)
  BOTTOM w0.102: v1(239.43,55.2) 239.54,55.08 239.65,55.08 239.86,55.29 239.86,56.02 241.64,57.8 241.64,58.07 242.22,58.65 242.22,59.25 243.65,60.67 243.65,60.76 ; C9184.2 337.12,115.28 337.12,115.45 337.03,115.55 336.8,115.55 336.63,115.71 336.23,115.71 335.82,115.31 v1(335.82,115.28)
PCIE_TXN9_SSD: length 2
  BOTTOM w0.102: C9191.2 324.6,29.75 324.11,29.75 324.01,29.65 CON5100.11
PCIE_TXN9_SSD_C: length 114.6
  IN3 w0.089: v1(328.84,31.97) 328.07,32.73 328.07,33.49 327.82,33.75 323.63,33.75 322.18,32.3 313.26,32.3 312.71,32.86 310.67,32.86 308.58,34.94 305.4,34.94 304.12,36.22 302.34,36.22 301.11,37.45 299.88,37.45 299.35,37.99 298.67,37.99 297.49,39.17 296.54,39.17 296.22,38.85 288.66,38.85 287.92,39.59 277.9,39.59 276.06,41.43 271.42,41.43 269.79,43.06 265.84,43.06 265.36,43.53 264.16,43.53 263.71,43.08 257.16,43.08 255.66,44.58 253.15,44.58 250.81,46.92 249.39,46.92 246.75,49.55 246.75,50.72 242.23,55.25 241.17,55.25 241,55.08 241,54.76 v1(241.13,54.64)
  BOTTOM w0.102: v1(328.84,31.97) 328.5,31.97 328.38,31.84 328.38,30.49 327.74,29.86 325.58,29.86 325.38,29.65 C9191.1 ; v1(241.13,54.64) 241.06,54.7 241.06,55.3 241.35,55.59 243.82,55.59 244.32,56.09 246.1,56.09 247.2,57.19 247.25,57.19 247.56,57.49 U9002.C34
PCIE_TXN10_SSD: length 2.5
  BOTTOM w0.102: C9193.2 324.93,32.32 324.36,32.32 324.03,32.65 CON5100.23
PCIE_TXN10_SSD_C: length 109.1
  IN3 w0.089: v1(239.8,51.46) 239.8,51.73 241.51,53.43 243.16,53.43 245.8,50.79 245.8,49.6 249.21,46.19 250.63,46.19 253.8,43.02 254.29,43.02 254.96,42.34 269.68,42.34 271.29,40.73 275.93,40.73 278.07,38.6 287.9,38.6 288.24,38.25 293.69,38.25 293.83,38.11 297.65,38.11 298.36,37.4 298.99,37.4 299.55,36.84 300.84,36.84 302.1,35.59 303.74,35.59 304.98,34.34 308.33,34.34 310.97,31.7 322.73,31.7 323.09,32.07 326.32,32.07 v1(326.42,31.97)
  BOTTOM w0.102: C9193.1 325.94,32.17 326.22,32.17 v1(326.42,31.97) ; U9002.C35 248.01,57.07 247.57,56.63 247.22,56.63 246.24,55.65 245.42,55.65 244.48,54.71 242.74,54.71 239.8,51.78 v1(239.8,51.46)
PCIE_TXN11_SSD: length 4.9
  BOTTOM w0.102: C9197.1 325.71,34.48 325.33,34.48 325.2,34.36 v1(325.2,33.95) 324.67,34.48 324.46,34.48 324.21,34.73 324.21,35.69 324.11,35.8 323.98,35.8 323.83,35.65 CON5100.35
PCIE_TXN11_SSD_C: length 110.3
  IN3 w0.089: v1(326.22,30.82) 326.52,30.82 326.65,30.95 326.65,31.18 326.51,31.32 323.41,31.32 323.2,31.1 310.72,31.1 308.72,33.11 306.1,33.11 305.45,33.76 304.63,33.76 303.44,34.95 301.64,34.95 300.5,36.1 299.42,36.1 298.7,36.82 298.01,36.82 297.31,37.52 294.89,37.52 294.48,37.11 288.37,37.11 287.48,38 277.84,38 275.81,40.03 270.27,40.03 269.06,41.24 267.35,41.24 266.83,41.76 257.35,41.76 256.71,41.12 253.34,41.12 252.5,41.97 252.5,42.51 251.81,43.2 249.55,43.2 244.57,48.18 244.57,51.15 243.05,52.67 242.38,52.67 242.23,52.51 242.23,52.46 242.22,52.45 242.22,52.22 v1(242.34,52.1)
  BOTTOM w0.089: U9002.B36 247.87,56.37 247.72,56.22 247.38,56.22 247.28,56.12
  BOTTOM w0.102: 247.28,56.12 246.31,55.15 245.99,55.15 244.77,53.93 243.45,53.93 242.27,52.75 242.27,52.17 v1(242.34,52.1) ; C9197.2 326.44,34.45 326.57,34.58 326.74,34.58 326.85,34.47 326.85,31.26 326.42,30.82 v1(326.22,30.82)
PCIE_TXN12_SSD: length 5.2
  BOTTOM w0.102: C9207.1 325.46,37.05 325.15,37.05 325.05,36.95 v1(325.05,36.49) 324.49,37.05 324.26,37.05 324.09,37.23 324.09,38.72 324.03,38.78 323.93,38.78 323.81,38.65 CON5100.47
PCIE_TXN12_SSD_C: length 116.6
  IN3 w0.089: v1(327.54,32.6) 327.95,32.2 327.95,31.83 328.39,31.39 328.39,30.63 327.82,30.07 310.8,30.07 308.45,32.41 305.9,32.41 305.13,33.17 304.37,33.17 303.23,34.32 301.4,34.32 300.77,34.95 299.55,34.95 298.36,36.14 297.68,36.14 296.91,36.91 295.17,36.91 294.77,36.51 287.7,36.51 286.8,37.42 277.6,37.42 276.3,38.71 270.6,38.71 268.67,40.64 262.55,40.64 262.02,41.18 258.18,41.18 257.49,40.49 251.92,40.49 251.59,40.83 251.03,40.83 243.76,48.1 243.76,48.86 242.18,50.45 241.6,50.45 241.48,50.33 241.48,49.78 v1(241.58,49.69)
  BOTTOM w0.089: U9002.D38 248.73,56.54 248.11,55.93 248.02,55.84 247.58,55.84 247.5,55.77
  BOTTOM w0.102: v1(241.58,49.69) 241.52,49.75 241.52,50.21 243.99,52.68 244.42,52.68 247.5,55.77 ; C9207.2 326.19,36.99 326.27,37.07 326.46,37.07 326.6,36.94 326.6,35.74 328,34.35 328,32.76 327.84,32.6 v1(327.54,32.6)
PCIE_TXN13_LAN: length 4.6
  BOTTOM w0.102: U4000.42 26.14,120.31 26.24,120.21 v6(26.24,117.59) 26.24,116.98 C9205.2
PCIE_TXN13_LAN_C: length 323.1
  IN1 w0.076: v1(243.61,50.83) 243.76,50.69 243.92,50.69 244.14,50.91 244.14,51.13 243.65,51.61 242.87,51.61 242.14,50.88 237.03,50.88 234.58,53.33 232.75,53.33 231.26,51.84 231.26,37.34 231.93,36.67 231.93,32.65 227.06,27.78 217.35,27.78 213.51,23.93 207.56,23.93 205.68,25.81 189.55,25.81 189.22,25.48 181.63,25.48 181.36,25.21 179.72,25.21 178.71,26.21 137.89,26.21 137.38,26.72 111.05,26.72 105.4,32.37 105.4,35.59 104.2,36.79 104.2,44.13 103.19,45.14 101.97,45.14 93.8,53.32 91.16,53.32 90.15,54.32 77.85,54.32 73.83,58.35 71.11,58.35 67.3,54.54 63.93,54.54 63.67,54.79 61.43,54.79 60.43,55.79 60.43,58.84 57.58,61.69 57.58,62.83 56.28,64.13 56.28,65.33 53.89,67.72 46.21,67.72 45,68.92 42.63,68.92 38.11,73.45 38.11,78.42 31.49,85.04 31.49,92.28 29.79,93.98 29.79,96.85 28.95,97.69 28.95,114.7 28.52,115.14 28.25,115.14 28.1,114.99 v1(28.1,114.77)
  BOTTOM w0.102: U9002.B38 248.19,55.68 248.19,55.28 247.53,54.62 246.99,54.62 245.9,53.54 245.9,52.68 244.05,50.83 v1(243.61,50.83) ; v1(28.1,114.77) 27.9,114.98 26.6,114.98 26.36,115.21 26.36,115.61 26.19,115.78 C9205.1
PCIE_TXN14_WLAN: length 8.4
  BOTTOM w0.102: C9200.2 354.23,67.53 353.96,67.53 353.78,67.71 TP4102.1 353.22,67.48 351.52,67.48 351.21,67.78 349.41,67.78 348.01,69.18 U4100.39
PCIE_TXN14_WLAN_C: length 176.2
  IN4 w0.076: v1(361.6,67.53) 361.9,67.23 362.28,67.23 362.49,67.02 362.49,66.12 363.01,65.6 363.01,50.78 361.52,49.29 361.52,44.74 359.37,42.58 359.37,39.82 355.44,35.89 351.57,35.89 350.18,34.51 349.05,34.51 348.94,34.62 348.3,34.62 347.81,34.13 347.28,34.13 345.75,35.65 335.24,35.65 334.46,34.88 330.19,34.88 328.84,36.24 322.5,36.24 321.52,37.21 309.95,37.21 309.58,36.84 302.24,36.84 301.87,37.21 289.96,37.21 288.75,38.42 286.95,38.42 286.5,38.86 285.64,38.86 284.95,39.55 282.67,39.55 281.97,40.25 278.9,40.25 278.67,40.48 272.45,40.48 271.84,41.09 268.94,41.09 268.8,41.23 266.74,41.23 266.05,41.92 256.88,41.92 256.22,41.26 250.58,41.26 248.72,43.12 246.41,43.12 242.45,47.08 242.45,47.73 242.85,48.13 v1(242.85,48.42)
  BOTTOM w0.102: v1(242.85,48.42) 243.15,48.42 246.55,51.82 246.55,53.32 247.23,54 247.53,54 248.59,55.06 248.59,55.48 248.83,55.72 248.83,55.92 248.98,56.07 249.09,56.07 249.15,56.02 U9002.C39 ; C9200.1 355.79,67.5 356.2,67.5 357.75,65.95 359.87,65.95 361.24,67.33 361.4,67.33 v1(361.6,67.53)
PCIE_TXN17_SSD: length 3.5
  BOTTOM w0.102: CON5101.47 324.35,15.65 324.5,15.8 324.89,15.8 v1(325.43,15.25) 325.43,15.7 325.53,15.8 325.93,15.8 C9198.2
PCIE_TXN17_SSD_C: length 118
  IN1 w0.076: v1(326.98,14.7) 327.18,14.7 327.36,14.52 327.36,14.44 327.15,14.23 319.42,14.23 317.66,15.99 317.66,19.19 312.71,24.14 312.71,26.13 308.14,30.7 306.85,30.7 303.25,34.29 298.82,34.29 298.35,34.76 295.76,34.76 295.46,35.07 289.27,35.07 288.64,35.69 286.04,35.69 285.62,36.11 282.37,36.11 281.57,36.91 278.64,36.91 276.48,39.07 269.92,39.07 268.3,40.69 263.6,40.69 263.3,40.98 263.3,41.87 261.53,43.65 259.88,43.65 253.24,50.29 245.69,50.29 244.63,49.24 244.63,47.72 245.23,47.12 245.23,46.69 245.04,46.5 244.77,46.5 v1(244.63,46.64)
  BOTTOM w0.102: v1(326.98,14.7) 327.06,14.7 327.49,15.13 327.49,15.65 327.2,15.94 326.75,15.94 326.6,15.78 C9198.1 ; U9002.A42 249.34,54.01 249.21,53.88 249.21,53.72 248.75,53.26 248.75,50.33 244.95,46.54 244.73,46.54 v1(244.63,46.64)
PCIE_TXN18_SSD: length 3.4
  BOTTOM w0.102: C9201.2 325.81,12.8 325.48,12.8 325.38,12.7 v1(325.38,12.31) 324.89,12.8 324.45,12.8 324.3,12.65 CON5101.35
PCIE_TXN18_SSD_C: length 110.4
  IN1 w0.076: v1(245.9,48.54) 245.78,48.67 245.78,48.93 246.09,49.24 247.3,49.24 248.06,48.48 249.65,48.48 252.48,45.65 256.86,45.65 260.29,42.22 261.05,42.22 263.29,39.98 267.99,39.98 269.61,38.36 276.17,38.36 278.33,36.2 281.27,36.2 282.08,35.38 285.31,35.38 285.71,34.98 288.25,34.98 288.88,34.36 295.15,34.36 295.45,34.05 298.05,34.05 299.24,32.86 301.78,32.86 304.66,29.98 307.7,29.98 311.82,25.87 311.82,23.84 316.86,18.8 316.86,15.59 320.05,12.4 321.59,12.4 322.12,12.93 327.13,12.93 327.31,12.75 v1(327.31,12.54)
  BOTTOM w0.102: U9002.C42 250.12,54.69 249.95,54.69 249.59,54.33 249.35,54.33 248.34,53.32 248.34,51.34 245.9,48.9 v1(245.9,48.54) ; v1(327.31,12.54) 327.31,12.69 327.11,12.89 326.88,12.89 C9201.1
PCIE_TXN19_SSD: length 3.5
  BOTTOM w0.102: CON5101.23 324.35,9.65 324.5,9.8 324.77,9.8 v1(325.38,9.18) 325.38,9.57 325.51,9.7 325.86,9.7 C9211.1
PCIE_TXN19_SSD_C: length 109.5
  IN1 w0.076: v1(247.68,46.76) 247.55,46.89 247.55,47.07 247.88,47.4 249.01,47.4 251.31,45.1 256.62,45.1 260.14,41.58 260.9,41.58 263.04,39.44 264.85,39.44 265.79,38.5 268.07,38.5 268.82,37.74 275.99,37.74 278.09,35.65 281.04,35.65 282.28,34.42 287.89,34.42 288.49,33.81 294.91,33.81 295.59,33.14 298.08,33.14 298.99,32.22 301.47,32.22 304.26,29.44 306.85,29.44 308.6,27.69 308.6,26.21 316.14,18.68 316.14,14.18 318.89,11.43 320.94,11.43 322.51,9.87 325.68,9.87 326.1,9.45 327.03,9.45 327.18,9.3 v1(327.18,9.11)
  BOTTOM w0.102: v1(247.68,46.76) 247.68,47.11 249.56,48.99 249.56,53.16 250.28,53.88 250.62,53.88 250.68,53.94 250.68,54.07 U9002.C44 ; v1(327.18,9.11) 327.18,9.26 326.8,9.64 326.67,9.64 C9211.2
PCIE_TXN20_SSD: length 3.5
  BOTTOM w0.102: CON5101.11 324.28,6.65 324.58,6.95 324.85,6.95 v1(325.3,6.49) 325.3,6.82 325.41,6.92 325.86,6.92 326.04,6.74 C9209.1
PCIE_TXN20_SSD_C: length 111.7
  IN1 w0.076: v1(327.57,7.84) 327.49,7.84 326.69,8.64 321.81,8.64 319.49,10.96 318.66,10.96 315.5,14.12 315.5,18.76 310.93,23.33 309.38,23.33 301.13,31.59 299.02,31.59 297.85,32.76 295.43,32.76 294.76,33.43 288.26,33.43 287.65,34.04 279.14,34.04 275.82,37.36 268.65,37.36 267.9,38.11 265.01,38.11 264.13,38.99 262.93,38.99 260.9,41.02 259.96,41.02 256.28,44.71 251.08,44.71 250.57,45.21 247.02,45.21 v1(246.54,44.73)
  BOTTOM w0.102: v1(246.54,44.73) 246.88,44.73 247.66,45.51 247.88,45.51 249.96,47.6 249.96,52.94 250.17,53.15 U9002.A44 ; C9209.2 326.7,6.77 327.03,6.77 327.36,7.1 327.36,7.63 v1(327.57,7.84)
PCIE_TXP3_CARD: length 5.6
  BOTTOM w0.102: U7301.3 31.94,69.96 32.04,69.86 32.9,69.86 33.9,70.87 33.9,71.05 v1(33.36,71.59) 33.78,71.59 33.95,71.77 33.95,72.23 33.76,72.42 C9167.2
PCIE_TXP3_CARD_C: length 273
  IN1 w0.076: v1(39.22,75.15) 39.45,74.92 39.69,74.92 40.04,74.57 40.04,73.07 42,71.11 43.82,71.11 45.14,69.79 46.39,68.54 58.33,68.54 58.68,68.19 65.77,68.19 67.51,66.45 67.51,64.9 68.78,63.63 71.62,63.63 75.98,59.27 77.63,59.27 80.21,56.69 88.41,56.69 88.98,57.27 88.98,57.86 91.42,60.29 94.16,60.29 96.3,58.15 96.3,53.61 102.61,47.3 104.72,47.3 106.2,45.81 106.2,38.04 107.72,36.53 107.72,33.38 112.4,28.69 142.88,28.69 143.39,28.18 206.1,28.18 208.05,26.23 211,26.23 214.94,30.16 226.64,30.16 228.16,31.68 228.16,33.02 229,33.86 229,51.28 228.59,51.69 228.59,53.25 229.36,54.01 229.36,55.13 231.5,57.28 232.1,57.28 v1(232.19,57.37)
  BOTTOM w0.102: U9002.C19 242.13,62.81 240.64,61.32 239.53,61.32 237.62,59.4 235.8,59.4 233.47,57.06 232.49,57.06 v1(232.19,57.37) ; v1(39.22,75.15) 39.1,75.02 35.12,75.02 33.74,73.64 33.74,73.51 C9167.1
PCIE_TXP4_WWAN: length 18.4
  BOTTOM w0.102: C9171.2 336.39,18.14 336.25,18 336.25,17.52 336,17.26 335.41,17.26 334.68,16.53 333.92,16.53 333.53,16.14 333.53,15.12 336.79,11.85 341.69,11.85 342.6,10.94 342.6,9.68 342.75,9.54 CON4201.49
PCIE_TXP4_WWAN_C: length 145.2
  IN4 w0.076: v1(336.25,19.83) 336.01,19.59 336.01,19.38 336.29,19.1 336.64,19.1 336.9,19.36 336.9,20.35 337.21,20.67 337.21,22.73 336.16,23.78 336.16,26.44 335.46,27.14 334.7,27.14 334.07,27.77 334.07,28.41 330.54,31.93 330.04,31.93 328.36,33.61 324.38,33.61 323.12,32.35 314.99,32.35 312.76,34.58 295.61,34.58 295.35,34.84 289.13,34.84 287.84,36.12 285.98,36.12 285.63,36.48 282.22,36.48 281.28,37.42 278.05,37.42 277.26,38.2 258.34,38.2 258.16,38.03 248.5,38.03 248.15,38.38 246.23,38.38 244.39,40.22 242.11,40.22 241.8,40.54 241.8,41.04 240,42.85 240,44.67 239.39,45.28 239.39,46.57 238.02,47.94 233.59,52.38 232.63,52.38 232.39,52.61 232.39,53.81 232.26,53.94 v1(232.19,53.94)
  BOTTOM w0.102: C9171.1 336.37,18.92 336.12,19.16 336.12,19.7 v1(336.25,19.83) ; v1(232.19,53.94) 232.26,53.94 232.44,54.12 232.44,54.46 232.76,54.78 233.12,54.78 236.55,58.21 237.56,58.21 240.04,60.68 240.71,60.68 241.87,61.84 242.17,61.84 242.37,62.04 242.37,62.45 242.53,62.61 242.67,62.61 242.75,62.53 242.75,62.45 U9002.C20
PCIE_TXP5_TBT: length 6.6
  BOTTOM w0.076: U8001.Y23 340.22,110.57 340.29,110.64 340.29,110.74 340.22,110.81 339.9,110.81 339.38,110.29 339.38,108.64 338.65,107.91 338.33,107.6 338.33,106.93 338.31,106.91 338.31,106.9
  BOTTOM w0.102: C9175.1 337.72,106.49 338.09,106.49 338.31,106.71 338.31,106.9
PCIE_TXP5_TBT_C: length 213.7
  IN4 w0.076: v1(239.66,59.22) 240.01,59.22 240.12,59.11 240.53,59.11 241.33,59.91 244,59.91 244.35,59.55 244.35,58.76 246.41,56.7 246.41,55.27 248.38,53.3 248.38,51.6 250.89,49.08 253.21,49.08 254.34,47.94 255.33,47.94 258.11,45.16 271.04,45.16 271.53,45.66 273.85,45.66 275.87,43.64 283.55,43.64 283.91,43.28 285.59,43.28 287.12,41.75 287.69,41.75 288.14,41.29 289.97,41.29 290.34,40.92 295.12,40.92 295.8,41.61 298.29,41.61 299.05,40.85 305.45,40.85 306.01,41.4 316.37,41.4 316.93,40.85 322.27,40.85 322.72,40.4 326.11,40.4 326.57,40.86 337.75,40.86 338.25,40.35 343.34,40.35 343.86,39.83 346.59,39.83 346.97,40.21 349.73,40.21 351.96,42.44 352.91,42.44 354.32,43.86 356.18,43.86 358.6,46.27 358.6,49.29 356.9,50.98 356.9,54.19 357.38,54.68 357.38,56.88 355.57,58.69 355.57,60.99 353.27,63.29 353.27,71.92 352.08,73.11 352.08,74.8 350.15,76.72 349.55,76.72 346.99,79.28 340.47,79.28 337.37,82.37 337.37,87.04 336.04,88.37 336.04,102.1 337.15,103.22 337.15,106.31 336.88,106.58 336.65,106.58 v1(336.46,106.77)
  BOTTOM w0.102: v1(239.66,59.22) 240.14,59.22 240.77,59.86 241.09,59.86 242.3,61.06 U9002.A22 ; v1(336.46,106.77) C9175.2
PCIE_TXP6_TBT: length 5.9
  BOTTOM w0.076: U8001.T23 340.23,112.41 340.29,112.47 340.29,112.55 340.23,112.61 339.76,112.61 339.66,112.51 338.93,112.51 338.59,112.17 338.59,111.79 338.33,111.53 338.33,109.79 338,109.46 337.8,109.46 C9179.1
PCIE_TXP6_TBT_C: length 214.9
  IN4 w0.076: v1(335.82,109.82) 335.95,109.69 336.56,109.69 337.71,108.54 337.71,102.99 336.59,101.88 336.59,89.08 339.69,85.98 341.66,85.98 352.43,75.21 352.65,75.21 353.18,74.68 353.18,72.78 353.82,72.15 353.82,63.52 354.09,63.24 354.37,62.96 356.12,61.22 356.6,61.22 357.05,60.76 357.05,58.99 358.95,57.09 358.95,51.51 359.15,51.31 359.15,45.92 356.53,43.31 354.59,43.31 352.95,41.67 351.97,41.67 349.59,39.28 348.09,39.28 347.72,39.65 347.19,39.65 346.82,39.28 338.16,39.28 337.22,40.22 326.77,40.22 326.38,39.84 322.46,39.84 322.02,40.27 316.36,40.27 315.77,40.86 306.34,40.86 305.75,40.27 290.12,40.27 289.74,40.65 287.91,40.65 287.36,41.2 286.89,41.2 285.36,42.72 280.05,42.72 279.89,42.89 275.9,42.89 275.68,43.11 273.63,43.11 273.03,43.7 268.72,43.7 267.81,44.62 257.18,44.62 256.15,45.65 253.56,45.65 253.51,45.69 247.83,51.37 247.83,52.97 245.12,55.68 242.28,55.68 239.94,58.02 239.94,58.38 v1(239.81,58.51)
  BOTTOM w0.102: v1(239.81,58.51) 240.82,59.53 241.18,59.53 242.65,60.99 242.65,61.3 242.88,61.54 U9002.C21 ; v1(335.82,109.82) 335.97,109.67 336.84,109.67 C9179.2
PCIE_TXP7_TBT: length 4.4
  BOTTOM w0.076: U8001.M23 340.1,114.15 340.01,114.06 339.78,114.06 339.48,114.37 338.97,114.37 338.23,113.63 338.23,113.29 337.22,112.27
  BOTTOM w0.102: 337.22,112.27 337.19,112.24 C9183.1
PCIE_TXP7_TBT_C: length 222.4
  IN4 w0.076: v1(335.82,112.23) 335.82,112.33 336.19,112.7 336.75,112.7 338.11,111.34 338.11,109.69 338.65,109.15 338.65,102.36 337.93,101.64 337.93,91.6 338.93,90.6 339.31,90.6 339.59,90.32 339.59,89.43 342.03,87 342.85,87 351.14,78.7 351.44,78.7 354.11,76.04 354.11,74.43 355.02,73.52 355.02,67.88 357.75,65.15 357.75,63.65 357.5,63.4 357.5,62.38 358.23,61.65 359.49,61.65 360.45,60.7 360.45,55.81 360.27,55.63 360.27,45.62 356.78,42.13 356.78,41.11 355.16,39.5 352.11,39.5 350.76,38.14 350.35,38.14 349.64,37.43 335.29,37.43 334.11,38.61 332.43,38.61 332.13,38.31 322.25,38.31 321.93,38.64 309.82,38.64 309.15,39.31 289.69,39.31 289.3,39.7 287.52,39.7 287.08,40.15 286.22,40.15 285.55,40.82 283.36,40.82 282.66,41.52 279.77,41.52 279.49,41.8 273.14,41.8 272.57,42.37 270.78,42.37 270.38,42.76 267.22,42.76 266.29,43.69 256.77,43.69 255.75,44.71 253.32,44.71 253.31,44.72 253.17,44.72 250.52,47.37 249.2,47.37 239.67,56.9 239.41,56.9 239.05,57.27 v1(239.05,57.37)
  BOTTOM w0.102: v1(335.82,112.23) 335.82,112.26 336.23,112.66 336.4,112.66 336.74,112.33 C9183.2 ; v1(239.05,57.37) 239.48,56.94 239.67,56.94 241.64,58.9 241.64,59.35 243.22,60.94 243.22,61.06 U9002.B23
PCIE_TXP8_TBT: length 3.7
  BOTTOM w0.076: U8001.H23 340.25,116.09 340.32,116.16 340.32,116.25 340.25,116.32 338.85,116.32 338.46,115.92 338.42,115.88 338.04,115.51 337.85,115.51 C9185.1
PCIE_TXP8_TBT_C: length 224.7
  IN4 w0.076: v1(239.43,54.55) 240.67,53.3 242.22,53.3 249.02,46.5 249.95,45.88 250.88,45.27 252.99,43.88 255.65,42.47 266.49,42.47 266.92,42.04 269.98,42.04 270.37,41.65 272.19,41.65 272.76,41.07 279.09,41.07 279.36,40.81 282.25,40.81 282.96,40.1 285.19,40.1 285.87,39.42 286.73,39.42 287.17,38.99 288.99,38.99 289.73,38.25 293.72,38.25 294.08,37.9 321.61,37.9 322.71,36.79 329.09,36.79 329.79,36.1 330.49,36.1 331.4,36.38 332.26,36.65 348.23,36.65 348.67,36.21 350.92,36.21 355.66,38.88 357.35,40.57 357.57,40.57 357.99,40.98 358.11,41.23 358.15,41.27 358.15,41.32 358.84,42.94 359.27,43.37 360.98,45.08 360.98,55.24 361.16,55.42 361.16,61.24 360.08,62.32 360.08,64.59 356.38,68.29 356.38,73.75 355.04,75.09 355.04,76.61 339.86,91.79 339.86,93.82 338.65,95.02 338.65,99.08 339.48,99.91 339.48,103.12 339.88,103.53 339.88,107.77 339.67,107.98 339.67,109.51 338.91,110.27 338.91,111.64 336.91,115.11 336.23,115.79 335.95,115.79 v1(335.82,115.91)
  BOTTOM w0.102: U9002.C24 243.92,60.66 242.42,59.16 242.42,58.57 241.84,57.99 241.84,57.71 240.06,55.93 240.06,55.18 v1(239.43,54.55) ; C9185.2 v1(335.82,115.91)
PCIE_TXP9_SSD: length 2.1
  BOTTOM w0.102: C9192.2 324.69,29.95 324.69,29.95 324.07,29.95 323.87,30.15 CON5100.13
PCIE_TXP9_SSD_C: length 114.6
  IN3 w0.089: v1(328.84,32.6) 328.47,32.6 328.26,32.81 328.26,33.57 327.9,33.94 323.55,33.94 322.1,32.49 313.34,32.49 312.78,33.05 310.75,33.05 308.66,35.13 305.48,35.13 304.2,36.41 302.42,36.41 301.18,37.64 299.96,37.64 299.42,38.18 298.75,38.18 297.57,39.36 296.46,39.36 296.14,39.04 288.74,39.04 288,39.78 277.98,39.78 276.14,41.62 271.5,41.62 269.87,43.25 265.92,43.25 265.44,43.72 264.08,43.72 263.63,43.27 257.24,43.27 255.74,44.77 253.23,44.77 250.89,47.11 249.47,47.11 246.95,49.63 246.95,50.8 242.31,55.44 241.09,55.44 240.8,55.15 v1(240.62,55.15)
  BOTTOM w0.102: U9002.D34 247.7,57.93 247.16,57.39 247.11,57.39 246.02,56.3 244.24,56.3 243.74,55.79 241.26,55.79 v1(240.62,55.15) ; v1(328.84,32.6) 328.17,31.94 328.17,30.58 327.66,30.06 325.5,30.06 C9192.1
PCIE_TXP10_SSD: length 2.6
  BOTTOM w0.102: CON5100.25 323.82,33.15 324.44,32.53 325.08,32.53 C9194.2
PCIE_TXP10_SSD_C: length 109.2
  IN3 w0.089: v1(239.3,51.97) 239.4,51.87 239.68,51.87 241.43,53.62 243.24,53.62 245.99,50.87 245.99,49.67 249.28,46.38 250.71,46.38 253.88,43.21 254.36,43.21 255.04,42.53 269.75,42.53 271.37,40.92 276.01,40.92 277.79,39.14 278.15,38.79 287.98,38.79 288.32,38.44 293.77,38.44 293.91,38.31 297.73,38.31 298.44,37.59 299.07,37.59 299.63,37.04 300.92,37.04 302.18,35.78 303.82,35.78 305.06,34.53 308.4,34.53 311.05,31.89 322.65,31.89 323.02,32.26 326.1,32.26 326.42,32.58 v1(326.42,32.6)
  BOTTOM w0.102: v1(239.3,51.97) 239.71,51.97 242.65,54.92 244.39,54.92 245.33,55.86 246.15,55.86 247.19,56.9 U9002.B35 ; C9194.1 325.73,32.58 325.94,32.37 326.19,32.37 v1(326.42,32.6)
PCIE_TXP11_SSD: length 4.9
  BOTTOM w0.102: C9196.1 325.71,34.69 325.28,34.69 325.2,34.76 v1(325.2,35.22) 324.67,34.69 324.54,34.69 324.42,34.81 324.42,35.78 324.19,36 323.96,36 323.81,36.15 CON5100.37
PCIE_TXP11_SSD_C: length 110.3
  IN3 w0.089: v1(241.84,52.61) 242.05,52.61 242.31,52.86 243.13,52.86 244.76,51.23 244.76,48.26 249.63,43.39 251.88,43.39 252.69,42.59 252.69,42.05 253.42,41.32 256.63,41.32 257.27,41.95 266.91,41.95 267.43,41.43 269.14,41.43 270.35,40.22 275.88,40.22 277.92,38.19 287.56,38.19 288.45,37.3 294.4,37.3 294.81,37.71 297.39,37.71 298.09,37.01 298.77,37.01 299.5,36.29 300.58,36.29 301.72,35.14 303.51,35.14 304.71,33.95 305.53,33.95 306.18,33.3 308.8,33.3 310.8,31.29 323.12,31.29 323.34,31.51 326.59,31.51 326.84,31.26 326.84,31.04 v1(327.06,30.82)
  BOTTOM w0.089: 247.14,56.26 247.29,56.42 247.64,56.42 247.95,56.72 U9002.C36
  BOTTOM w0.102: v1(241.84,52.61) 243.36,54.13 244.68,54.13 245.9,55.35 246.22,55.35 247.14,56.26 ; v1(327.06,30.82) 327.06,34.56 326.83,34.79 326.62,34.79 C9196.2
PCIE_TXP12_SSD: length 5.1
  BOTTOM w0.102: CON5100.49 323.79,39.15 323.96,38.98 324.12,38.98 324.29,38.81 324.29,37.31 324.35,37.25 324.54,37.25 v1(325.05,37.76) 325.05,37.35 325.15,37.25 325.46,37.25 C9206.1
PCIE_TXP12_SSD_C: length 116.6
  IN3 w0.089: v1(241.07,50.19) 241.52,50.64 242.25,50.64 243.95,48.94 243.95,48.18 251.11,41.02 251.67,41.02 252,40.68 257.42,40.68 258.1,41.37 262.1,41.37 262.63,40.83 268.75,40.83 270.68,38.9 276.38,38.9 277.67,37.61 286.87,37.61 287.78,36.71 294.69,36.71 295.09,37.1 296.99,37.1 297.76,36.33 298.44,36.33 299.63,35.14 300.85,35.14 301.48,34.51 303.31,34.51 304.45,33.36 305.21,33.36 305.98,32.6 308.53,32.6 310.88,30.26 327.74,30.26 328.2,30.71 328.2,31.31 v1(327.54,31.97)
  BOTTOM w0.089: U9002.E37 248.93,57.02 248.16,56.25 248.16,56.25 247.94,56.03 247.48,56.03 247.36,55.91
  BOTTOM w0.102: C9206.2 326.19,37.33 326.24,37.28 326.55,37.28 326.8,37.02 326.8,35.83 328.2,34.43 328.2,32.63 v1(327.54,31.97) ; 247.36,55.91 244.33,52.89 243.91,52.89 241.21,50.19 v1(241.07,50.19)
PCIE_TXP13_LAN: length 4.6
  BOTTOM w0.102: U4000.41 26.54,120.31 26.44,120.21 26.44,116.95 C9204.2
PCIE_TXP13_LAN_C: length 323.1
  IN1 w0.076: v1(244.12,50.32) 244.12,50.66 244.3,50.84 244.3,51.2 243.72,51.78 242.81,51.78 242.07,51.04 237.1,51.04 234.64,53.49 232.68,53.49 231.1,51.91 231.1,37.27 231.77,36.6 231.77,32.72 226.99,27.94 217.29,27.94 213.44,24.09 207.63,24.09 205.75,25.97 189.48,25.97 189.15,25.64 181.56,25.64 181.29,25.38 179.79,25.38 178.78,26.38 137.95,26.38 137.45,26.89 111.11,26.89 105.57,32.43 105.57,35.66 104.36,36.86 104.36,44.2 103.26,45.3 102.04,45.3 93.86,53.48 91.23,53.48 90.22,54.49 77.92,54.49 73.9,58.51 71.05,58.51 67.24,54.7 63.99,54.7 63.74,54.95 61.5,54.95 60.6,55.86 60.6,58.9 57.74,61.76 57.74,62.9 56.45,64.2 56.45,65.39 53.96,67.88 46.28,67.88 45.07,69.09 42.7,69.09 38.27,73.51 38.27,78.49 31.66,85.11 31.66,92.35 29.95,94.05 29.95,96.92 29.12,97.76 29.12,114.77 28.58,115.3 28.33,115.3 v1(28.1,115.53)
  BOTTOM w0.089: U9002.C38 248.57,56.02 248.57,55.74 248.39,55.56 248.39,55.34
  BOTTOM w0.102: v1(28.1,115.53) 27.74,115.18 26.68,115.18 26.57,115.3 26.57,115.52 C9204.1 ; 248.39,55.34 248.39,55.2 247.61,54.42 247.07,54.42 246.1,53.45 246.1,52.6 244.13,50.62 244.12,50.62 v1(244.12,50.32)
PCIE_TXP14_WLAN: length 8.4
  BOTTOM w0.102: U4100.40 348.22,68.68 349.32,67.58 351.13,67.58 351.43,67.27 353.27,67.27 TP4103.1 353.78,67.17 353.93,67.32 354.31,67.32 354.61,67.03 C9202.2
PCIE_TXP14_WLAN_C: length 176.3
  IN4 w0.076: v1(243.36,47.91) 243.17,48.1 243.05,48.1 242.61,47.66 242.61,47.15 246.48,43.28 248.79,43.28 250.65,41.43 256.15,41.43 256.81,42.09 266.11,42.09 266.81,41.4 268.87,41.4 269.01,41.25 271.91,41.25 272.52,40.64 278.74,40.64 278.97,40.41 282.04,40.41 282.74,39.71 285.02,39.71 285.71,39.03 286.57,39.03 287.01,38.58 288.82,38.58 290.02,37.38 301.94,37.38 302.31,37.01 309.51,37.01 309.88,37.38 321.59,37.38 322.57,36.4 328.9,36.4 330.26,35.04 334.39,35.04 335.17,35.82 345.82,35.82 347.34,34.29 347.74,34.29 348.24,34.79 349.01,34.79 349.12,34.67 350.12,34.67 351.5,36.06 355.37,36.06 359.2,39.89 359.2,42.65 361.36,44.81 361.36,49.36 362.85,50.85 362.85,65.53 362.32,66.05 362.32,66.95 362.21,67.06 361.9,67.06 v1(361.6,66.77)
  BOTTOM w0.102: v1(361.6,66.77) 361.6,67 361.47,67.13 361.33,67.13 359.95,65.75 357.66,65.75 356.11,67.3 355.79,67.3 C9202.1 ; v1(243.36,47.91) 243.21,48.06 243.21,48.19 246.76,51.74 246.76,53.24 247.31,53.79 247.62,53.79 248.8,54.97 248.8,55.4 249.05,55.65 249.2,55.65 249.45,55.9 U9002.D39
PCIE_TXP17_SSD: length 3.6
  BOTTOM w0.102: C9199.2 325.8,16 325.48,16 325.41,16.08 v1(325.41,16.52) 324.88,16 324.5,16 324.35,16.15 CON5101.49
PCIE_TXP17_SSD_C: length 118
  IN1 w0.076: v1(245.14,46.13) 245.14,46.37 245.4,46.62 245.4,47.19 244.8,47.78 244.8,49.17 245.76,50.13 253.17,50.13 259.81,43.49 261.46,43.49 263.14,41.81 263.14,40.92 263.53,40.53 268.23,40.53 269.86,38.9 276.41,38.9 278.57,36.74 281.5,36.74 282.3,35.94 285.55,35.94 285.97,35.52 288.58,35.52 289.2,34.9 295.39,34.9 295.7,34.6 298.28,34.6 298.75,34.13 303.18,34.13 306.78,30.53 308.07,30.53 312.54,26.06 312.54,24.08 317.49,19.12 317.49,15.92 319.36,14.06 327.21,14.06 327.53,14.37 327.53,14.53 v1(327.69,14.7)
  BOTTOM w0.102: v1(245.14,46.13) 245.14,46.43 248.95,50.24 248.95,53.17 249.86,54.08 U9002.B42 ; C9199.1 326.8,16.14 327.29,16.14 327.69,15.74 v1(327.69,14.7)
PCIE_TXP18_SSD: length 3.5
  BOTTOM w0.102: C9203.2 325.77,13 325.63,13 325.38,13.25 v1(325.38,13.58) 324.8,13 324.43,13 324.29,13.15 CON5101.37
PCIE_TXP18_SSD_C: length 110.4
  IN1 w0.076: v1(245.39,49.05) 245.66,49.05 246.02,49.41 247.37,49.41 248.13,48.64 249.71,48.64 252.55,45.81 256.93,45.81 260.36,42.38 261.12,42.38 263.35,40.15 268.06,40.15 269.68,38.52 276.24,38.52 278.4,36.36 281.34,36.36 282.15,35.55 285.38,35.55 285.78,35.14 288.32,35.14 288.94,34.52 295.22,34.52 295.52,34.22 298.12,34.22 299.31,33.02 301.85,33.02 304.73,30.15 307.77,30.15 311.98,25.94 311.98,23.91 317.02,18.87 317.02,15.66 320.12,12.56 321.52,12.56 322.05,13.1 327.11,13.1 v1(327.31,13.3)
  BOTTOM w0.102: C9203.1 326.72,13.1 327.11,13.1 v1(327.31,13.3) ; U9002.D42 250.43,54.89 249.87,54.89 249.51,54.53 249.26,54.53 248.14,53.41 248.14,51.42 245.77,49.05 v1(245.39,49.05)
PCIE_TXP19_SSD: length 3.5
  BOTTOM w0.102: C9210.1 325.72,9.9 325.51,9.9 325.38,10.03 v1(325.38,10.45) 324.93,10 324.5,10 324.35,10.15 CON5101.25
PCIE_TXP19_SSD_C: length 109.5
  IN1 w0.076: v1(327.18,9.87) 326.93,9.62 326.17,9.62 325.75,10.04 322.57,10.04 321.01,11.6 318.95,11.6 316.3,14.25 316.3,18.75 308.77,26.28 308.77,27.76 306.92,29.6 304.33,29.6 301.54,32.39 299.06,32.39 298.14,33.3 295.66,33.3 294.98,33.97 288.56,33.97 287.95,34.58 282.35,34.58 281.11,35.82 278.15,35.82 276.06,37.91 268.89,37.91 268.14,38.66 265.86,38.66 264.92,39.6 263.11,39.6 260.97,41.75 260.2,41.75 256.69,45.26 251.38,45.26 249.08,47.56 247.81,47.56 247.52,47.27 v1(247.17,47.27)
  BOTTOM w0.102: C9210.2 326.93,9.84 327.16,9.84 v1(327.18,9.87) ; v1(247.17,47.27) 247.55,47.27 249.36,49.08 249.36,53.25 250.7,54.59 U9002.D43
PCIE_TXP20_SSD: length 3.5
  BOTTOM w0.102: C9208.1 325.84,7.13 325.41,7.13 325.3,7.23 v1(325.3,7.76) 324.69,7.15 CON5101.13
PCIE_TXP20_SSD_C: length 111.7
  IN1 w0.076: v1(247.04,44.22) 246.93,44.34 246.93,44.89 247.09,45.05 250.5,45.05 251.01,44.54 256.21,44.54 259.89,40.86 260.83,40.86 262.87,38.83 264.07,38.83 264.94,37.95 267.83,37.95 268.58,37.2 275.75,37.2 279.08,33.87 287.58,33.87 288.19,33.26 294.69,33.26 295.36,32.59 297.78,32.59 298.95,31.42 301.06,31.42 309.32,23.17 310.86,23.17 315.33,18.69 315.33,14.06 318.59,10.8 319.42,10.8 321.74,8.47 326.62,8.47 326.93,8.16 v1(326.93,7.84)
  BOTTOM w0.102: v1(247.04,44.22) 247.04,44.61 247.74,45.3 247.96,45.3 250.17,47.51 250.17,52.86 250.45,53.14 250.45,53.51 U9002.B44 ; v1(326.93,7.84) 327.16,7.61 327.16,7.19 326.95,6.97 326.85,6.97 C9208.2
PCIE_WAKE#: length 3.5
  BOTTOM w0.114: U7301.32 30.74,71.85 v1(31.49,72.6) 32.01,73.12 R7328.1 R7308.2
PCIECOMP_N: length 6.6
  BOTTOM w0.102: U9002.B12 239.25,64.47 239.12,64.47 238.89,64.24 238.89,63.05 238.56,62.72 237.88,62.72
  BOTTOM w0.114: v1(234.8,62.85) 234.83,62.83 234.83,62.82 R9188.1 235.84,62.72 237.88,62.72
PCIECOMP_P: length 6
  BOTTOM w0.114: R9188.2 236.18,61.72 v1(236.28,61.81) 236.94,62.47 238.61,62.47 239.12,62.98 239.12,64.06 U9002.A13
PD_ADP_DIS1: length 225.8
  TOP w0.076: v3(269.54,28.57) 269.27,28.57
  TOP w0.114: v1(268.99,28.67) 269.09,28.57 269.27,28.57
  IN1 w0.076: v1(361.98,101.56) 362.24,101.82 362.24,104.41 361.34,105.3 360.87,105.77 360.87,107.38 360.72,107.53 360.72,107.54 358.3,109.96 358.3,113.04 358.57,113.31 358.57,116.66 357.77,117.46 357.77,122.77 356.72,123.81 356.72,125.31 355.2,126.84 346.91,126.84 341.54,132.21 341.54,135.97 341.75,136.18 341.75,137.04 v1(338.74,140.04)
  IN3 w0.076: v3(269.54,28.57) 269.86,28.25 271.9,28.25 271.94,28.21
  IN3 w0.089: v1(361.98,101.56) 363.23,100.31 363.23,84.5 363.02,84.29 363.02,83.38 361.4,81.76 361.4,69.83 364.3,66.93 364.3,63.12 363.93,62.75 363.93,48.09 358.43,42.59 358.43,39.07 355.99,36.64 352.52,36.64 349.22,33.34 349.22,31.27 348.65,30.7 348.37,30.7 348.13,30.93 348.13,31.45 347.76,31.82 346.37,31.82 343.91,29.36 336.14,29.36 335.44,28.67 332.34,28.67 331.33,27.66 331.33,27.15 329.88,25.69 320.78,25.69 319.76,24.68 308.12,24.68 303.25,29.55 294.99,29.55 294.29,28.85 288.78,28.85 287.88,27.95 285.3,27.95 284.58,27.22 278.08,27.22 277.15,28.16 275.75,28.16 275.16,27.57 272.57,27.57 271.94,28.21
  BOTTOM w0.114: PQ10004.5 338.41,138.7 338.88,139.16 PR10008.2 338.88,139.91 v1(338.74,140.04) ; U6001.H7 v3(269.54,28.57)
PD_ADP_DIS2: length 203.5
  TOP w0.076: v3(271.49,25.32) 271.49,25.33 271.18,25.64 270.42,25.64 v1(270.16,25.9)
  IN1 w0.076: v1(325.91,29.3) 326.07,29.15 326.07,25.9 v1(325.41,25.24)
  IN2 w0.089: v1(325.91,29.3) 325.71,29.5 325.45,29.5 322.7,32.25 322.7,45.75 324.52,47.56 324.9,47.56 325.25,47.92 325.25,48.96 325.79,49.49 325.79,50.55 324.45,51.89 324.45,53.64 323.73,54.36 323.05,54.36 322.75,54.66 321.94,54.66 317.96,58.63 317.96,59.55 316.72,60.8 316.16,60.8 315.98,60.97 315.98,64.76 315.55,65.19 315.55,70.76 317.83,73.04 318.73,73.04 322.61,76.93 322.61,78.45 327.88,83.72 329.05,83.72 332.26,86.93 332.26,88.62 333.03,89.38 333.03,92.7 333.41,93.08 333.8,93.08 334.59,93.87 334.59,118.34 333.48,119.44 333.48,132.98 332.9,133.57 332.9,143.47 v1(332.01,144.36)
  IN3 w0.089: v3(271.49,25.32) 272.12,25.32 272.83,24.61 274.49,24.61 274.86,24.98 277.27,24.98 278.93,26.64 284.82,26.64 285.54,27.36 288.12,27.36 289.02,28.26 294.6,28.26 295.3,28.96 303.01,28.96 308.03,23.95 311.47,23.95 314.03,21.38 317.11,21.38 317.48,21.75 318.63,21.75 321.39,24.52 324.69,24.52 v1(325.41,25.24)
  BOTTOM w0.114: U6001.D10 v3(271.49,25.32) ; PQ10005.5 332.7,142.99 332.26,143.43 PR10009.2 332.26,144.12 v1(332.01,144.36)
PD_I2C_SCL3: length 9.1
  TOP w0.114: R6011.1 277.34,27.09 276.44,27.09 276.13,27.4 275.7,27.4 275.52,27.22 R6031.1 275.14,27.01 274.8,27.36 v1(273.72,27.36) 272.19,27.36 272.08,27.24 270.82,27.24 v3(270.19,26.62)
  BOTTOM w0.114: U6001.F8 v3(270.19,26.62)
PD_I2C_SDA3: length 9.3
  TOP w0.114: v3(270.84,26.62) 271.21,26.99 271.96,26.99 272.09,26.86 v1(272.45,26.86) 274.63,26.86 275.24,26.25 R6028.1 275.52,25.97 275.66,25.83 276.31,25.83 276.84,25.31 277.25,25.31 277.35,25.41 277.58,25.64 277.58,26.05 277.77,26.24 R6000.1
  BOTTOM w0.114: U6001.F9 v3(270.84,26.62)
PECI: length 325
  IN1 w0.127: v1(83.47,59.53) 83.47,59.91 82.84,60.54 82.84,62.85 84.21,64.23 84.21,67.67 86.32,69.78 86.32,70.29 91.04,75.02 91.78,75.02 93.52,76.76 94.09,76.76 96.09,78.75 99.53,78.75 101.89,81.11 101.89,82.6 104.57,85.28 104.57,89.39 105.82,90.65 105.82,91.13 107.32,92.63 107.32,93.91 108.46,95.05 108.46,98.1 109.01,98.64 109.7,98.64 117.61,106.56 117.61,110.52 122.56,115.47 122.56,115.59 125.61,118.64 132.02,118.64 134.81,121.43 135.04,121.43 135.8,122.19 135.8,125.2 v1(135.47,125.53)
  IN3 w0.127: v1(267.98,35.27) 267.62,35.27 266.59,36.3 266.59,36.81 266.3,37.1 259.28,37.1 258.67,36.48 254.7,36.48 254.35,36.13 253.68,36.13 252.96,36.85 250.47,36.85 249.08,35.45 245.63,35.45 242.07,31.9 238.9,31.9 233.09,26.09 215.01,26.09 212.5,23.59 206.28,23.59 205.49,22.8 196.88,22.8 196.24,22.16 194.78,22.16 194.14,22.8 190.55,22.8 189.91,22.16 181.61,22.16 179.97,20.51 176.54,20.51 175.55,19.52 175.55,19.21 175.24,18.91 110.25,18.91 104.26,24.9 101.88,24.9 v1(100.21,26.57)
  BOTTOM w0.127: v1(135.47,125.53) R9017.2 136.31,124.65 136.87,124.08 U9001.BT34 ; v1(83.47,59.53) 82.46,59.53 82.02,59.1 82.02,58.06 84.99,55.09 87.07,55.09 95.32,46.84 95.32,42.37 100.22,37.47 100.22,32.52 101,31.74 101,27.35 v1(100.21,26.57) ; v1(267.98,35.27) 267.75,35.09 R6026.2
PEDET1#: length 22.2
  BOTTOM w0.114: CON5100.69 322.49,44.15 322.47,44.16 321.72,44.16 320.96,44.92 320.96,45.48 318.65,47.79 317.35,47.79 315.88,46.32 313.37,46.32 312.91,46.78 312.33,46.78 311.33,45.78 311.02,45.78 310.72,45.47 310.72,44.84 310.29,44.41 310.29,43.53 v1(310.16,43.4) 310.16,43.16 310.3,43.02 R5111.2 310.3,41.87 310.16,41.73 R5108.1 Q5101.2
PEDET4#: length 8.8
  BOTTOM w0.114: 326.29,20.43 325.57,21.15 CON5101.69 ; 326.29,20.43 R5103.2 326.63,20.41 v1(327.11,19.93) 327.07,19.89 Q5102.2 ; 326.29,20.43 R5100.1
PEG_COMP: length 9.2
  BOTTOM w0.254: 175.67,99.83 175.39,100.12 175.39,100.98 U9001.G2
  BOTTOM w0.381: R9037.2 173.69,94.04 v1(174.7,95.05) 176.74,97.09 176.74,98.8 175.7,99.83 175.67,99.83
PEG_RXN0: length 68.6
  TOP w0.095: v1(176.47,105.89) 177.97,105.89 178.25,105.61 178.55,105.61 178.73,105.79 179.2,106.25 179.35,106.25 179.55,106.05 179.55,105.89 179.13,105.47 178.91,105.25 178.91,104.49 179.16,104.24 179.77,104.24 180.2,104.68 180.55,104.68 181.07,104.15 181.07,103.67 180.79,103.39 179.09,103.39 178.86,103.17 178.86,102.78 179.11,102.53 180.54,102.53 180.69,102.37 180.69,102.15 180.56,102.02 179.2,102.02 178.86,101.68 178.86,100.95 179.23,100.58 180.71,100.58 180.82,100.47 180.82,100.18 180.71,100.07 179.07,100.07 178.86,99.86 178.86,99.42 179.07,99.21 180.71,99.21 180.82,99.1 180.82,98.81 180.71,98.7 179.07,98.7 178.86,98.49 178.86,98.06 179.08,97.84 181.28,97.84 181.76,98.31 181.76,99.18 181.87,99.29 182.18,99.29 182.39,99.5 182.39,99.94 182.18,100.15 181.87,100.15 181.76,100.26 181.76,100.55 181.87,100.66 182.18,100.66 182.39,100.88 182.39,101.31 182.18,101.53 181.87,101.53 181.76,101.64 181.76,102.2 182.12,102.57 184.69,102.57 185.28,103.15 186.01,103.15 186.15,103.01 186.15,102.19 186.02,102.06 185.25,102.06 185.01,101.82 185.01,101.43 185.25,101.2 186.95,101.2 187.29,100.85 187.29,99.96 187.53,99.72 188.84,99.72 188.97,99.59 188.97,99.22 188.84,99.09 187.02,99.09 186.79,98.85 186.79,98.41 187,98.2 189.98,98.2 190.36,98.58 194.13,98.58 195.04,99.49 195.04,101.9 195.66,102.52 196.69,102.52 196.95,102.77 196.95,103.26 197.21,103.53 198.29,103.53 198.85,104.09 198.85,104.83 C2141.1
  BOTTOM w0.114: v1(176.47,105.89) 176.47,105.95 U9001.E10
PEG_RXN0_C: length 7.7
  TOP w0.095: C2141.2 198.77,105.75 198.77,105.92 199.09,106.24 200.06,106.24 201.84,108.02 202.62,108.02 203.04,108.45 203.68,108.45 v1(204.09,108.86)
  BOTTOM w0.102: U2000.AJ14 v1(204.09,108.86)
PEG_RXN1: length 65.5
  TOP w0.095: v1(191.04,105.34) 191.22,105.52 191.22,105.86 191.57,106.21 192.17,106.21 192.44,105.93 192.44,101.06 192.52,100.98 193.45,100.98 193.76,100.67 193.76,100.24 193.48,99.96 190.02,99.96 189.9,99.84 189.9,99.55 190.01,99.43 193.78,99.43 194.24,99.89 194.24,102.26 195.6,103.61 195.6,104.09 195.97,104.46 197.33,104.46 197.41,104.54 197.41,104.84 197.31,104.94 196.14,104.94 195.79,105.29 195.79,105.83 196.16,106.21 196.63,106.21 C2145.1
  IN4 w0.076: v1(191.04,105.34) 191.21,105.51 191.21,105.81 191.14,105.88 190.79,105.88 190.53,105.63 190.53,104.61 190.82,104.32 192.18,104.32 192.98,103.52 192.98,102.58 192.77,102.36 192.77,101.82 192.98,101.61 192.98,99.56 192.16,98.73 187.32,98.73 185.68,97.1 184.34,97.1 184.02,97.42 184.02,97.81 183.86,97.97 182.91,97.97 182.53,97.59 181.98,97.59 181.64,97.93 181.64,98.18 181.87,98.41 181.87,98.59 181.73,98.73 181.55,98.73 181.32,98.5 181.07,98.5 180.76,98.81 180.76,99.06 181,99.3 181,99.48 180.86,99.62 180.68,99.62 180.44,99.38 180.19,99.38 178.86,100.71 178.86,101.45 179.03,101.62 179.33,101.62 179.41,101.7 179.41,102.01 179.33,102.08 179.03,102.08 178.86,102.25 178.86,103.69 179.09,103.92 179.09,104.24 178.86,104.48 178.86,105.13 178.27,105.72 177.68,105.72 177.27,106.12 177.27,106.52 v1(177.12,106.68)
  BOTTOM w0.114: v1(177.12,106.68) 177.12,106.74 U9001.E11
PEG_RXN1_C: length 10.9
  TOP w0.095: v1(205.78,109.7) 205.78,109.65 205.58,109.45 205.34,109.45 205.24,109.56 202.33,109.56 199.98,107.21 198.46,107.21 198.09,106.83 198.09,106.42 197.87,106.2 197.65,106.2 C2145.2
  BOTTOM w0.102: v1(205.78,109.7) 206.18,109.3 U2000.AG14
PEG_RXN2: length 65.4
  TOP w0.095: v1(191.68,106.74) 191.88,106.94 192.56,106.94 192.81,107.19 192.81,107.42 192.95,107.56 193.16,107.56 193.31,107.42 193.31,106.94 192.86,106.49 192.86,101.87 193.09,101.63 193.48,101.63 193.72,101.87 193.72,106.01 193.85,106.15 194.09,106.15 194.23,106.01 194.23,103.7 194.47,103.46 194.85,103.46 195.09,103.7 195.09,106.38 194.96,106.51 194.96,106.9 195.1,107.03 195.35,107.03 C2136.1
  IN4 w0.076: v1(191.68,106.74) 191.3,107.11 191.12,107.11 189.97,105.96 189.97,104.39 190.59,103.77 191.95,103.77 192.44,103.29 192.44,102.83 192.22,102.62 192.22,101.59 192.44,101.38 192.44,99.79 191.97,99.32 191.12,99.32 190.95,99.49 190.95,99.67 190.82,99.8 190.62,99.8 190.49,99.67 190.49,99.49 190.32,99.32 189.88,99.32 189.71,99.49 189.71,99.67 189.58,99.8 189.38,99.8 189.25,99.67 189.25,99.49 189.08,99.32 186.98,99.32 186.77,99.52 186.77,99.67 186.64,99.8 186.44,99.8 186.31,99.67 186.31,99.49 186.14,99.32 185.6,99.32 185.46,99.18 185.46,98.74 185.24,98.52 182.95,98.52 181.68,99.78 181.68,100.02 181.54,100.17 180.18,100.17 179.95,100.39 179.95,100.73 180.18,100.95 181.34,100.95 181.47,101.08 181.47,101.28 181.34,101.41 180.18,101.41 179.95,101.64 179.95,101.98 180.18,102.2 181.31,102.2 181.44,102.33 181.44,102.53 181.31,102.66 179.67,102.66 179.44,102.88 179.44,103.22 179.67,103.44 180.68,103.44 180.8,103.57 180.8,103.94 180.68,104.07 180.28,104.07 179.41,104.94 179.41,105.56 178.79,106.18 178.79,106.85 178.12,107.52 177.1,107.52 176.89,107.73 176.73,107.73 v1(176.47,107.46)
  BOTTOM w0.114: U9001.E12 176.47,107.53 v1(176.47,107.46)
PEG_RXN2_C: length 11
  TOP w0.095: v1(204.92,110.51) 204.32,109.91 202.09,109.91 199.83,107.65 197.64,107.65 196.91,106.93 196.28,106.93 C2136.2
  BOTTOM w0.102: v1(204.92,110.51) 204.92,110.49 U2000.AJ15
PEG_RXN3: length 65.1
  TOP w0.095: v1(177.12,108.25) 177.12,107.43 177.38,107.16 177.78,107.16 178.08,107.47 178.32,107.47 178.62,107.16 179.1,107.16 179.29,107.36 179.29,107.96 179.43,108.1 179.66,108.1 179.8,107.96 179.8,107.13 180.01,106.92 180.54,106.92 181.5,107.89 181.69,107.89 181.86,107.72 181.86,107.53 180.64,106.3 180.64,105.98 180.9,105.72 181.28,105.72 182.08,106.51 185.33,106.51 185.46,106.38 185.46,106.14 185.33,106.01 182.64,106.01 182.4,105.77 182.4,105.38 182.64,105.14 185.57,105.14 185.7,105.01 185.7,104.77 185.57,104.63 184.31,104.63 184.08,104.4 184.08,104.01 184.31,103.77 186.15,103.77 186.67,104.29 187.82,104.29 188.82,105.29 188.82,106.01 188.95,106.15 189.24,106.15 189.33,106.07 189.33,104.94 187.93,103.55 187.93,101.28 188.55,100.66 191.58,100.66 191.81,100.9 191.81,101.29 191.58,101.53 189.09,101.53 188.95,101.66 188.95,101.9 189.09,102.03 191.58,102.03 191.81,102.27 191.81,102.66 191.58,102.9 189.13,102.9 189,103.03 189,103.27 189.13,103.41 191.58,103.41 191.81,103.64 191.81,104.03 191.58,104.27 190.6,104.27 190.32,104.56 190.32,106.32 190.61,106.61 190.61,107.91 190.87,108.17 194.08,108.17 C2137.1
  BOTTOM w0.114: U9001.E13 177.12,108.32 v1(177.12,108.25)
PEG_RXN3_C: length 11.2
  TOP w0.095: C2137.2 194.82,107.99 195.02,108.19 196.9,108.19 198.06,109.35 198.53,109.35 198.62,109.25 198.62,108.98 198.84,108.76 199.38,108.76 199.64,109.02 199.64,109.23 199.74,109.34 200.37,109.34 201.85,110.82 203.01,110.82 v1(203.28,110.55)
  BOTTOM w0.102: U2000.AK16 v1(203.28,110.55)
PEG_RXN4: length 66.2
  TOP w0.095: C2114.1 195.78,109.27 194.57,109.27 194.38,109.45 194.38,109.75 194.28,109.85 193.97,109.85 193.87,109.75 193.87,108.99 193.67,108.78 193.21,108.78 193.01,108.99 193.01,109.75 192.91,109.85 192.62,109.85 192.5,109.73 192.5,109.43 192.34,109.27 191.92,109.27 v1(191.68,109.02)
  IN4 w0.076: v1(191.68,109.02) 191.68,109.1 191.55,109.23 190.93,109.23 190.67,108.97 190.67,107.44 189.43,106.19 189.43,105.01 189.21,104.8 189.21,103.73 189.32,103.62 189.95,103.62 190.23,103.35 190.23,103.04 190.02,102.83 189.36,102.83 189.26,102.74 189.26,102.43 189.32,102.38 190.68,102.38 190.87,102.57 190.87,103 191.09,103.22 191.47,103.22 191.66,103.02 191.66,101.93 191.32,101.59 185.68,101.59 185.49,101.78 185.49,102.71 185.41,102.8 185.09,102.8 184.98,102.69 184.98,101.66 184.78,101.46 183.52,101.46 183.39,101.34 183.39,101.04 183.47,100.97 184.88,100.97 185.04,101.13 191.69,101.13 191.89,100.93 191.89,100.54 191.69,100.34 188.76,100.34 188.69,100.28 188.69,100.08 188.47,99.86 187.56,99.86 187.32,100.1 187.32,100.28 187.25,100.34 185.8,100.34 184.52,99.06 183.17,99.06 182.37,99.87 182.37,101.11 181.98,101.5 181.98,103.25 181.35,103.89 181.35,104.54 181.14,104.75 180.51,104.75 179.95,105.31 179.95,105.79 179.53,106.21 179.53,106.99 179.15,107.37 179.15,108.05 177.98,109.23 176.66,109.23 v1(176.47,109.04)
  BOTTOM w0.114: U9001.E14 176.59,109.43 176.47,109.31 v1(176.47,109.04)
PEG_RXN4_C: length 10.2
  TOP w0.095: C2114.2 196.73,109.28 197.01,109.28 197.31,109.58 197.31,110.17 197.71,110.57 199.68,110.57 199.93,110.33 200.46,110.33 201.59,111.45 202.69,111.45 203.05,111.81 203.51,111.81 203.61,111.71 203.77,111.71 v1(204.13,111.35)
  BOTTOM w0.102: v1(204.13,111.35) 204.13,111.4 U2000.AJ17
PEG_RXN5: length 65.1
  TOP w0.095: C2071.1 195.8,111.09 195.61,111.09 195.17,110.65 190.84,110.65 190.62,110.87 190.62,111.86 190.05,112.44 188.02,112.44 187.78,112.19 187.78,111.79 188.02,111.55 189.64,111.55 189.73,111.46 189.73,111.15 189.64,111.06 188.02,111.06 187.78,110.82 187.78,110.42 188.02,110.17 189.9,110.17 190.02,110.05 190.02,109.82 189.9,109.69 187.91,109.69 187.66,109.45 187.66,109.05 187.91,108.8 189.69,108.8 189.81,108.68 189.81,108.45 189.69,108.32 188.02,108.32 187.78,108.07 187.78,107.68 188.02,107.43 189.6,107.43 189.73,107.3 189.73,107.08 189.6,106.95 188.04,106.95 187.85,106.76 187.85,105.55 187.55,105.25 186.6,105.25 186.29,105.55 186.29,107.07 186.04,107.31 183.24,107.31 183.12,107.44 183.12,107.67 183.24,107.8 186.04,107.8 186.29,108.04 186.29,108.44 186.04,108.69 181.9,108.69 181.77,108.81 181.77,109.04 181.9,109.17 186.07,109.17 186.32,109.41 186.32,109.81 186.07,110.06 181.12,110.06 180.88,109.82 180.88,109.31 180.5,108.93 179.36,108.93 179.05,109.24 179.05,110.38 178.49,110.94 177.39,110.94 177.12,110.67 v1(177.12,109.82)
  BOTTOM w0.114: v1(177.12,109.82) 177.12,109.89 U9001.E15
PEG_RXN5_C: length 11.3
  TOP w0.095: v1(205.78,112.2) 205.78,112.11 205.61,111.94 205.35,111.94 204.45,112.84 202.14,112.84 201.61,112.31 200.92,112.31 199.98,111.37 197.36,111.37 197.02,111.04 196.74,111.04 C2071.2
  BOTTOM w0.102: v1(205.78,112.2) U2000.AG17
PEG_RXN6: length 64.8
  TOP w0.095: C2102.1 194.48,111.93 193.98,111.93 193.76,111.71 193.76,111.38 193.64,111.26 193.37,111.26 193.28,111.35 193.28,112.12 193.07,112.33 192.62,112.33 192.39,112.09 192.39,111.79 192.28,111.69 191.93,111.69 v1(191.68,111.95)
  IN4 w0.076: v1(176.47,111.4) 176.33,111.4 176.12,111.19 176.12,111.1 175.87,110.85 173.9,110.85 173.77,110.72 173.77,110.52 174.33,109.96 174.54,109.96 174.95,110.37 176.27,110.37 176.35,110.45 176.35,110.78 176.56,111 176.95,111 177.13,110.82 177.13,110.45 177.21,110.37 177.39,110.37 177.73,110.71 178.01,110.71 178.35,110.37 178.56,110.37 178.72,110.53 179.27,110.53 179.44,110.35 179.44,109.93 178.94,109.42 178.94,109.28 179.14,109.07 179.51,109.07 180.11,108.46 180.11,108.1 179.87,107.85 179.87,107.66 179.95,107.58 181.8,107.58 182.03,107.35 182.03,106.98 181.85,106.8 180.71,106.8 180.68,106.77 180.68,105.95 180.75,105.87 181.06,105.87 181.13,105.95 181.13,106.18 181.29,106.34 182.18,106.34 182.46,106.06 185.58,106.06 185.81,105.84 185.81,105.5 185.58,105.27 182.61,105.27 182.53,105.2 182.53,104.89 182.61,104.82 183.01,104.82 183.16,104.67 183.16,104.47 183.24,104.4 183.5,104.4 183.62,104.51 183.62,104.67 183.77,104.82 186.24,104.82 186.35,104.7 187.68,104.7 188.04,104.34 188.04,102.96 187.84,102.76 187.41,102.76 187.26,102.92 187.26,103.76 187.1,103.91 186.02,103.91 185.91,104.03 184.67,104.03 184.61,103.97 184.61,103.68 184.72,103.57 185.83,103.57 185.93,103.47 186.26,103.47 186.47,103.27 186.47,102.96 186.21,102.71 186.21,102.43 186.31,102.34 188.08,102.34 188.5,102.76 188.5,104.45 188.18,104.76 188.18,105.1 188.43,105.35 188.65,105.35 188.72,105.42 188.72,105.74 188.64,105.82 188.48,105.82 188.33,105.97 188.33,106.46 188.5,106.62 188.85,106.62 189.38,107.15 189.38,107.73 189.57,107.93 189.75,107.93 189.96,108.13 189.96,109.28 190.49,109.81 190.49,110.07 190.33,110.24 190.33,110.63 190.49,110.8 190.49,111.43 190.79,111.73 191.46,111.73 v1(191.68,111.95)
  BOTTOM w0.114: U9001.E16 176.79,111.07 v1(176.47,111.4)

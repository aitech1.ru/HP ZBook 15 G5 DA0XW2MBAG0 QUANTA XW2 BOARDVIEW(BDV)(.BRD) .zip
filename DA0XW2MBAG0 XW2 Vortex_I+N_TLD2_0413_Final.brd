# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB30_RX4-: length 291.4
  IN3 w0.089: v1(31.35,79.82) 31.35,79.87 31.5,80.02 32.03,80.02 32.23,79.83 32.23,78.39 31.72,77.88 31.72,73.91 35.5,70.13 35.89,70.13 36.39,69.63 36.39,67.39 39.93,63.85 41.62,63.85 47.84,57.62 49.67,57.62 53.23,54.07 59.07,54.07 59.9,53.24 64.1,53.24 65.21,52.14 79.46,52.14 79.8,51.79 90.08,51.79 90.33,51.54 94.68,51.54 101.38,44.84 101.38,39.75 105.4,35.73 105.4,33.61 106.84,32.17 107.91,32.17 117.33,22.75 153.41,22.75 154.51,23.85 170.29,23.85 170.6,24.16 179.36,24.16 180.17,24.97 186.64,24.97 187.22,25.55 189.96,25.55 190.5,26.09 202.79,26.09 205.01,28.32 229.45,28.32 235.81,34.68 235.81,37.73 236.82,38.75 236.82,55.91 238.09,57.18 238.09,58.36 242.45,62.71 242.45,64.49 242.95,64.99 242.95,66.66 v1(242.93,66.68)
  BOTTOM w0.102: U9002.K16 243.19,66.42 v1(242.93,66.68) ; v1(31.35,79.82) 31.66,80.13 31.76,80.13 32.42,80.79 32.42,89.33 31.1,90.64 30.42,90.64 C616.1
USB30_RX4-_C: length 13.7
  BOTTOM w0.102: CON7002.5 12.75,85.46 12.65,85.57 12.32,85.57 11.67,86.22 11.67,87.16 12.53,88.03 13.04,88.03 13.67,88.66 13.67,89.17 14.21,89.7 15.02,89.7 15.18,89.86 U7000.10 U7000.1 16.89,89.86 17.05,89.7 17.8,89.7 18.46,90.36 20.01,90.36 R9527.2
USB30_RXN3-_C: length 3.7
  BOTTOM w0.102: U601.7 24.89,107.95 24.98,107.85 25.07,107.85 25.38,108.17 25.66,108.17 v1(26.19,108.7) 26.19,108.32 26.35,108.17 26.92,108.17 27,108.24 C615.2
USB30_RXN3-_R: length 4.6
  BOTTOM w0.102: R9525.1 20,108.76 20.11,108.76 v1(20.63,109.29) 21.16,108.76 21.61,108.76 21.9,108.47 21.9,108.05 22.1,107.85 22.2,107.85 22.3,107.95 U601.5
USB30_RXN4-_C: length 4.2
  BOTTOM w0.102: U600.7 27.43,89.66 27.52,89.57 27.6,89.57 27.69,89.66 27.69,90.16 28.07,90.54 28.4,90.54 28.48,90.62 v1(28.48,91.05) 29.06,90.46 29.32,90.46 29.41,90.56 C616.2
USB30_RXN4-_R: length 5.4
  BOTTOM w0.102: R9527.1 21.68,90.34 22.05,90.34 22.18,90.46 v1(22.18,90.87) 22.71,90.34 23.48,90.34 24.26,89.57 24.74,89.57 24.84,89.66 U600.5
USB30_RXP3+_C: length 3.8
  BOTTOM w0.102: C612.2 27,107.87 26.91,107.96 26.35,107.96 26.19,107.81 v1(26.19,107.43) 25.66,107.96 25.47,107.96 25.15,107.65 24.99,107.65 24.89,107.55 U601.8
USB30_RXP3+_R: length 4.6
  BOTTOM w0.102: U601.4 22.3,107.55 22.2,107.65 22.01,107.65 21.7,107.96 21.7,108.39 21.53,108.56 21.17,108.56 v1(20.63,108.02) 20.09,108.56 19.96,108.56 R9526.1
USB30_RXP4+_C: length 4.2
  BOTTOM w0.102: C613.2 29.41,90.1 29.25,90.26 28.96,90.26 v1(28.48,89.78) 28.48,90.26 28.4,90.34 28.16,90.34 27.9,90.08 27.9,89.58 27.68,89.36 27.51,89.36 27.42,89.26 U600.8
USB30_RXP4+_R: length 5.4
  BOTTOM w0.102: U600.4 24.84,89.26 24.74,89.36 24.17,89.36 23.4,90.13 22.71,90.13 v1(22.18,89.6) 22.18,90.01 22.05,90.13 21.58,90.13 R9528.1
USB30_TX1+: length 203.8
  TOP w0.102: v1(363,67.54) 362.76,67.3 362.49,67.3 362.36,67.43 362.36,68.32 361.81,68.87 360.03,68.87 359.01,67.86 354.54,67.86 353.98,68.42 353.98,68.82 v1(354.51,69.36) 354.08,69.36 353.98,69.46 353.98,69.93 C602.1
  IN4 w0.076: v1(363,67.54) 363.3,67.24 363.52,67.24 364.14,66.62 364.14,62.98 363.63,62.47 363.63,50.52 362.44,49.33 362.44,44.74 359.99,42.29 359.99,38.23 357,35.24 353.85,35.24 351.77,33.16 349.94,33.16 349.59,32.82 347.11,32.82 346.63,33.3 346.63,33.89 345.51,35.02 335.74,35.02 334.98,34.25 329.93,34.25 328.66,35.52 322.23,35.52 321.88,35.17 319.83,35.17 318.77,36.22 301.59,36.22 301.23,36.59 289.69,36.59 288.5,37.78 286.69,37.78 286.25,38.22 285.4,38.22 284.99,38.62 282.7,38.62 281.71,39.61 278.66,39.61 278.41,39.85 272.05,39.85 271.44,40.46 268.67,40.46 268.52,40.61 262.66,40.61 262.29,40.98 256.81,40.98 256.47,40.64 249.5,40.64 248.81,41.33 247.31,41.33 241.67,46.97 241.67,48.8 242.06,49.18 242.06,49.93 239.49,52.5 237.17,52.5 234.61,55.06 234.61,58.77 233.97,59.42 233.97,60.44 234.62,61.09 237.8,61.09 238.88,62.17 238.88,66.44 239.46,67.02 v1(239.46,67.96)
  BOTTOM w0.102: v1(239.46,67.96) U9002.F7
USB30_TX1-: length 203.8
  TOP w0.102: v1(363,66.78) 363,66.92 362.82,67.1 362.41,67.1 362.16,67.34 362.16,68.24 361.73,68.67 360.11,68.67 359.1,67.65 354.46,67.65 353.78,68.33 353.78,68.82 v1(353.24,69.36) 353.68,69.36 353.78,69.46 353.78,69.88 C610.1
  IN4 w0.076: v1(363,66.78) 363.3,67.07 363.45,67.07 363.98,66.55 363.98,63.05 363.47,62.54 363.47,50.59 362.27,49.4 362.27,44.81 359.82,42.36 359.82,38.3 356.93,35.41 353.79,35.41 351.7,33.33 349.87,33.33 349.53,32.98 347.17,32.98 346.79,33.36 346.79,33.96 345.57,35.18 335.68,35.18 334.91,34.42 330,34.42 328.73,35.69 322.16,35.69 321.81,35.33 319.9,35.33 318.84,36.39 301.66,36.39 301.29,36.76 289.76,36.76 288.57,37.95 286.76,37.95 286.32,38.38 285.47,38.38 285.06,38.79 282.77,38.79 281.78,39.78 278.72,39.78 278.48,40.02 272.12,40.02 271.51,40.63 268.74,40.63 268.59,40.77 262.73,40.77 262.36,41.14 256.74,41.14 256.41,40.81 249.57,40.81 248.88,41.49 247.38,41.49 241.84,47.04 241.84,48.73 242.22,49.11 242.22,50 239.55,52.67 237.24,52.67 234.78,55.13 234.78,58.84 234.13,59.49 234.13,60.37 234.69,60.92 237.87,60.92 239.05,62.1 239.05,66.37 239.63,66.95 239.63,67.6 239.85,67.82 239.96,67.82 v1(240.06,67.72)
  BOTTOM w0.102: v1(240.06,67.72) 240.06,67.55 239.85,67.35 U9002.F9
USB30_TX3+: length 300.5
  IN3 w0.089: v1(25.51,102.68) 25.71,102.48 25.71,102.16 25.9,101.97 26.5,101.97 26.7,101.77 26.7,93.96 32.45,88.22 32.45,82.43 36.29,78.59 36.29,76.62 35.78,76.12 35.78,74.51 38.16,72.13 38.16,68.11 39.75,66.51 43.2,66.51 44.15,65.56 45.53,65.56 48.29,62.8 48.29,62.45 48.8,61.94 52.74,61.94 54.76,59.92 56.53,59.92 58.89,57.56 60.44,57.56 60.77,57.89 67.25,57.89 71.26,53.89 73.66,53.89 73.97,54.2 90.29,54.2 91.17,53.32 95.38,53.32 104.39,44.31 104.39,39.69 108.02,36.05 108.02,34.86 115.48,27.4 136.29,27.4 137.9,25.78 149.56,25.78 150.96,27.18 168.49,27.18 169.17,27.86 186.78,27.86 186.99,28.07 200.92,28.07 202.93,30.08 227.28,30.08 228.4,31.19 228.4,33.14 230.35,35.09 230.35,57.23 233.79,60.67 237.59,60.67 238.33,61.41 238.33,62.52 238.88,63.07 238.88,64.24 239.7,65.06 240.45,65.06 240.66,65.27 240.98,65.27 241.21,65.5 241.21,66.07 v1(241.33,66.2)
  BOTTOM w0.102: v1(241.33,66.2) 241.18,66.34 U9002.G12 ; v1(25.51,102.68) 25.77,102.94 25.77,103.17 26.28,103.68 26.28,103.9 26.21,103.97 C1121.1
USB30_TX3+_C_R: length 15.4
  IN1 w0.076: CON7000.9 13.34,110.73 14.56,110.73 15.73,109.56 15.73,106.57 15.33,106.16 14.45,106.16 14.09,106.52 14.09,106.86 v1(13.85,107.1)
  BOTTOM w0.102: C607.2 18.41,105.53 18.11,105.53 17.33,106.3 17.16,106.3 17.02,106.15 U7001.5 U7001.6 15.51,106.15 15.4,106.26 v6(14.84,106.26) 14.4,106.26 14.05,106.61 14.05,106.9 v1(13.85,107.1)
USB30_TX3-: length 300.5
  IN3 w0.089: v1(240.69,66.04) 240.92,66.04 241.01,65.95 241.01,65.58 240.9,65.46 240.58,65.46 240.37,65.25 239.62,65.25 238.69,64.32 238.69,63.14 238.14,62.6 238.14,61.49 237.51,60.86 233.71,60.86 230.16,57.31 230.16,35.17 228.21,33.22 228.21,31.27 227.21,30.27 202.85,30.27 200.84,28.26 186.91,28.26 186.7,28.05 169.09,28.05 168.41,27.37 150.88,27.37 149.49,25.97 137.98,25.97 136.37,27.59 115.56,27.59 108.21,34.94 108.21,36.13 104.58,39.77 104.58,44.39 95.46,53.51 91.25,53.51 90.36,54.39 73.89,54.39 73.58,54.08 71.34,54.08 67.33,58.09 60.69,58.09 60.36,57.75 58.97,57.75 56.61,60.11 54.84,60.11 52.82,62.13 48.88,62.13 48.48,62.53 48.48,62.88 45.61,65.75 44.23,65.75 43.28,66.7 39.83,66.7 38.35,68.19 38.35,72.21 35.97,74.59 35.97,76.04 36.48,76.54 36.48,78.67 32.64,82.51 32.64,88.3 26.89,94.04 26.89,101.85 26.58,102.16 25.98,102.16 25.9,102.24 25.9,102.77 25.99,102.86 26.17,102.86 v1(26.32,102.71)
  BOTTOM w0.102: v1(240.69,66.04) 240.45,66.29 U9002.F11 ; C1122.1 26.57,103.97 26.48,103.88 26.48,103.6 25.97,103.09 25.97,102.98 26.24,102.71 v1(26.32,102.71)
USB30_TX3-_C_R: length 15.4
  IN1 w0.076: v1(14.48,107.1) 14.26,106.87 14.26,106.59 14.52,106.33 15.26,106.33 15.56,106.64 15.56,109.5 14.49,110.57 12.77,110.57 12.58,110.38 12.58,109.49 CON7000.8
  BOTTOM w0.102: C605.2 18.41,105.73 18.19,105.73 17.42,106.5 17.17,106.5 17.02,106.65 U7001.4 U7001.7 15.48,106.65 15.3,106.47 14.48,106.47 14.26,106.69 14.26,106.87 v1(14.48,107.1)
USB30_TX4+: length 280
  IN3 w0.089: v1(31.02,87.57) 31.23,87.78 31.53,87.78 31.84,87.47 31.84,81.95 34.77,79.02 34.77,74.69 37.56,71.89 37.56,67.88 39.68,65.76 41.55,65.76 43.72,63.59 45.48,63.59 48.2,60.87 52.1,60.87 55.28,57.7 57.1,57.7 60.22,54.58 68.48,54.58 69.76,53.3 74.22,53.3 74.53,53.62 90.02,53.62 90.9,52.73 95.14,52.73 103.54,44.33 103.54,39.66 107.31,35.89 107.31,34.29 107.9,33.7 108.18,33.7 117.35,24.53 152.99,24.53 154.24,25.78 169.61,25.78 170.15,26.32 186.13,26.32 187.3,27.48 202.52,27.48 204.53,29.49 227.53,29.49 231.29,33.26 231.29,53.93 232.06,54.7 233.22,54.7 234.89,56.38 234.89,58.15 235.95,59.21 237.22,59.21 239,60.99 239,62.51 239.55,63.06 v1(239.55,63.15)
  BOTTOM w0.102: v1(239.55,63.15) 239.69,63.15 240.28,63.74 240.28,63.92 240.37,64.01 U9002.C14 ; v1(31.02,87.57) 30.89,87.7 30.33,87.7 30.14,87.5 C1119.1
USB30_TX4+_C_R: length 14.8
  IN1 w0.076: CON7002.9 12.75,92.21 12.8,92.16 14.45,92.16 15.54,91.07 15.54,88.47 15.15,88.08 14.64,88.08 v1(14.38,87.82)
  BOTTOM w0.102: v1(14.38,87.82) 14.59,88.03 15.09,88.03 15.25,87.86 U7000.6 U7000.5 16.92,87.86 17.08,88.03 18.08,88.03 19.07,87.04 20.04,87.04 C608.2
USB30_TX4-: length 280
  IN3 w0.089: v1(239.55,63.78) 239.16,63.39 239.16,62.94 238.81,62.6 238.81,61.07 237.14,59.4 235.87,59.4 234.7,58.23 234.7,56.45 233.14,54.89 231.98,54.89 231.1,54.01 231.1,33.34 227.45,29.68 204.45,29.68 202.44,27.68 187.22,27.68 186.05,26.51 170.07,26.51 169.53,25.97 154.16,25.97 152.91,24.72 117.43,24.72 108.26,33.89 107.98,33.89 107.5,34.37 107.5,35.97 103.73,39.74 103.73,44.41 95.22,52.92 90.98,52.92 90.1,53.81 74.45,53.81 74.14,53.49 69.83,53.49 68.56,54.77 60.3,54.77 57.18,57.89 55.36,57.89 52.18,61.06 48.28,61.06 45.56,63.78 43.8,63.78 41.63,65.95 39.76,65.95 37.75,67.96 37.75,71.97 34.96,74.77 34.96,79.1 32.03,82.03 32.03,87.55 31.61,87.97 31.25,87.97 v1(31.02,88.2)
  BOTTOM w0.102: U9002.B14 240.13,64.15 240.13,64.06 240.07,64.01 240.07,63.82 239.83,63.58 239.69,63.58 239.55,63.72 v1(239.55,63.78) ; v1(31.02,88.2) 30.72,87.9 30.26,87.9 30.14,88.02 C1120.1
USB30_TX4-_C_R: length 14.7
  IN1 w0.076: v1(14.38,88.46) 14.6,88.24 15.08,88.24 15.37,88.54 15.37,91 14.38,91.99 12.8,91.99 12.75,91.94 CON7002.8
  BOTTOM w0.102: v1(14.38,88.46) 14.61,88.23 15.12,88.23 15.25,88.36 U7000.7 U7000.4 16.89,88.36 17.02,88.23 v6(17.53,88.23) 18.17,88.23 19.16,87.24 20.04,87.24 C609.2
USB30_TXN1-_C: length 8
  TOP w0.102: CON7001.8 357.21,72.61 357.08,72.48 356.62,72.48 355.87,73.23 355.68,73.23 355.53,73.38 U7002.2 U7002.9 354.13,73.38 353.98,73.23 353.71,73.23 353.4,72.91 353.4,72.56 353.75,72.2 353.75,72.1 353.65,72 v1(353.22,72) 353.75,71.46 353.75,71.16 353.69,71.09 C610.2
USB30_TXN3-_C: length 4.8
  BOTTOM w0.102: C1122.2 26.63,105 26.63,105.4 26.78,105.55 v1(27.16,105.55) 26.63,106.09 26.63,106.44 26.42,106.64 25.1,106.64 24.99,106.75 U601.10
USB30_TXN3-_R: length 4.6
  BOTTOM w0.102: U601.2 22.3,106.75 22.2,106.65 22.01,106.65 21.65,106.29 21.65,105.86 21.52,105.73 21.27,105.73 v1(20.73,106.26) 20.2,105.73 20.01,105.73 C605.1
USB30_TXN4-_C: length 3.7
  BOTTOM w0.102: C1120.2 29.36,88.03 29.28,87.95 29.09,87.95 v1(28.53,88.51) 28.53,88.1 28.38,87.95 28.07,87.95 27.66,88.37 27.49,88.37 27.39,88.46 U600.10
USB30_TXN4-_R: length 5.3
  BOTTOM w0.102: C609.1 21.63,87.24 21.9,87.24 v1(22.43,87.77) 22.97,87.24 23.42,87.24 24.54,88.37 24.74,88.37 24.84,88.46 U600.2
USB30_TXP1+_C: length 8
  TOP w0.102: CON7001.9 357.21,72.15 357.08,72.28 356.53,72.28 355.78,73.03 355.68,73.03 355.53,72.88 U7002.1 U7002.10 354.13,72.88 353.98,73.03 353.8,73.03 353.6,72.83 353.6,72.64 353.96,72.29 353.96,72.13 354.11,71.97 v1(354.49,71.97) 353.96,71.44 353.96,71.16 354.02,71.09 C602.2
USB30_TXP3+_C: length 4.8
  BOTTOM w0.102: C1121.2 26.24,104.75 26.42,104.93 26.42,105.4 26.27,105.55 v1(25.89,105.55) 26.42,106.09 26.42,106.36 26.34,106.44 25.17,106.44 25.08,106.35 U601.11
USB30_TXP3+_R: length 4.6
  BOTTOM w0.102: C607.1 20.01,105.53 20.2,105.53 v1(20.73,104.99) 21.27,105.53 21.61,105.53 21.85,105.77 21.85,106.21 22.1,106.45 22.2,106.45 22.3,106.35 U601.1
USB30_TXP4+_C: length 3.6
  BOTTOM w0.102: U600.11 27.4,88.06 27.5,88.16 27.57,88.16 27.99,87.75 28.38,87.75 28.53,87.59 v1(28.53,87.24) 29.04,87.75 29.29,87.75 29.36,87.68 C1119.2
USB30_TXP4+_R: length 5.3
  BOTTOM w0.102: U600.1 24.84,88.06 24.74,88.16 24.63,88.16 23.5,87.04 22.97,87.04 v1(22.43,86.5) 21.9,87.04 21.63,87.04 C608.1
USB_C_INT#: length 8.4
  BOTTOM w0.114: U6001.J11 272.13,28.58 273.02,28.58 273.61,29.17 274.51,29.17 R6018.2 275.27,30.09 275.5,30.32 276.43,30.32 276.87,30.75 277.26,30.75 277.35,30.66 D6001.2 278.63,30.66 v1(278.92,30.95)
USB_CHARGER_STATUS#: length 350.4
  TOP w0.114: v1(25.05,104.87) v1(24.28,104.09) U7005.9 ; v1(264.19,27.78) 264.14,27.75 R6062.2
  IN3 w0.089: v1(25.05,104.87) 25.05,104.48 22.05,101.49 22.05,84.88 24.84,82.09 24.84,77.67 15.2,68.03 15.2,59.59 26.1,48.68 32.09,48.68 34.36,46.41 54.26,46.41 55.05,47.2 59.73,47.2 60.7,46.23 66.49,46.23 68.75,48.48 73.18,48.48 74.58,49.89 89.37,49.89 89.48,49.77 90.51,49.77 93.94,46.35 93.94,45.75 99.11,40.57 99.11,22.96 101.76,20.31 102.78,20.31 103.31,19.77 104.54,19.77 106.78,17.53 142.11,17.53 143.92,15.72 174.63,15.72 175.96,17.06 179,17.06 182.53,20.59 202.64,20.59 207.71,15.52 212.52,15.52 215.32,18.33 217.02,18.33 222.59,23.89 233.86,23.89 239.54,29.57 250.61,29.57 251.78,30.74 256.76,30.74 257.69,29.81 261.53,29.81 262.87,28.46 263.51,28.46 v1(264.19,27.78)
  BOTTOM w0.114: v1(264.19,27.78) 264.32,27.91 265.65,27.91 U6001.G2
USBP1+: length 178.6
  IN1 w0.076: v1(352.47,74.5) 352.15,74.18 351.87,74.18 351.61,73.92 351.61,73.15 352.22,72.54 352.22,68.1 352.67,67.64 352.67,62.45 350.91,60.69 350.91,56.71 349.57,55.37 349.57,54.58 347,52 347,49.37 346.74,49.11 345.29,49.11 342.64,46.46 342.64,34.93 339.71,32.01 338.93,32.01 337.15,30.23 335.48,30.23 334.94,29.69 331.75,29.69 329.88,31.56 325.81,31.56 325.53,31.84 314.72,31.84 310.36,36.2 306.83,36.2 304.92,38.1 301.91,38.1 301.61,38.41 294.46,38.41 293.8,39.07 287.57,39.07 285.81,40.83 280.47,40.83 278.72,42.59 277.23,42.59 274.99,44.82 274.05,44.82 273.39,45.48 268.84,45.48 265.25,49.07 265.25,49.31 264.13,50.42 262.38,50.42 259.57,53.23 259.57,53.94 257.97,55.54 257.97,57.22 257.55,57.64 257.55,59.31 252.22,64.65 251.83,64.65 248.53,67.95 246.86,67.95 246.56,68.24 245.73,68.24 245.59,68.11 245.49,68.11 244.91,67.53 241.84,67.53 241.21,68.16 241.21,68.78 239.03,70.96 237.84,70.96 v1(237.01,71.78)
  BOTTOM w0.102: v1(237.01,71.78) 237.84,70.96 238.09,70.96 238.41,70.64 238.58,70.64 U9002.J2 ; L7002.4 353.33,74.59 353.65,74.27 353.65,74.07 353.55,73.97 353,73.97 v1(352.47,74.5)
USBP1+_C: length 7.9
  BOTTOM w0.102: CON7001.3 358.71,75.79 358.48,75.56 358.25,75.56 357.57,76.24 356.99,76.24 355.97,77.26 355.75,77.26 C7012.1 355.6,77.55 355.26,77.89 353.93,77.89 353.63,77.58 353.63,77.33 353.33,77.03 L7002.3
USBP1-: length 178.6
  IN1 w0.076: v1(237.01,71.07) 237.49,71.07 237.77,70.79 238.96,70.79 241.04,68.71 241.04,68.09 241.77,67.36 244.98,67.36 245.56,67.94 245.66,67.94 245.8,68.08 246.5,68.08 246.79,67.78 248.46,67.78 251.77,64.48 252.15,64.48 257.38,59.24 257.38,57.57 257.8,57.15 257.8,55.47 259.4,53.87 259.4,53.16 262.31,50.26 264.07,50.26 265.08,49.24 265.08,49.01 268.77,45.32 273.32,45.32 273.98,44.66 274.93,44.66 277.16,42.42 278.65,42.42 280.4,40.67 285.74,40.67 287.5,38.9 293.73,38.9 294.39,38.24 301.54,38.24 301.84,37.94 304.85,37.94 306.76,36.03 310.29,36.03 314.65,31.68 325.46,31.68 325.74,31.4 329.81,31.4 331.68,29.53 335.01,29.53 335.55,30.06 337.22,30.06 339,31.84 339.78,31.84 342.81,34.86 342.81,46.4 345.36,48.95 346.81,48.95 347.16,49.3 347.16,51.93 349.74,54.51 349.74,55.31 351.07,56.64 351.07,60.62 352.84,62.38 352.84,67.71 352.38,68.17 352.38,72.61 351.77,73.22 351.77,73.85 351.94,74.02 352.22,74.02 v1(352.47,73.76)
  BOTTOM w0.102: v1(352.47,73.76) 353.63,73.76 353.85,73.98 353.85,74.32 354.13,74.59 L7002.1 ; U9002.J3 238.56,70.2 238.01,70.75 237.75,70.75 237.43,71.07 v1(237.01,71.07)
USBP1-_C: length 7.9
  BOTTOM w0.102: CON7001.2 358.71,74.81 357.48,76.04 356.9,76.04 355.89,77.05 355.3,77.05 355.15,77.2 C7012.2 354.87,77.69 354.02,77.69 353.83,77.5 353.83,77.33 354.13,77.03 L7002.2
USBP2+: length 189.8
  IN4 w0.076: v1(244.58,67.89) 244.27,67.89 244.08,67.71 243.28,67.71 242.78,68.21 242.78,68.87 241.59,70.07 238.67,70.07 238.33,69.74 236.17,69.74 235.79,70.12 233.53,70.12 232.75,69.33 232.75,64.55 230.79,62.6 230.79,52.92 231.25,52.47 231.25,37.84 231.62,37.47 234.16,37.47 237.63,34 242.85,34 244.94,36.1 249.8,36.1 250.58,36.87 252.74,36.87 253.37,36.24 254.64,36.24 255.36,36.96 258.9,36.96 259.19,37.25 276.6,37.25 278.03,35.82 281.17,35.82 281.44,35.55 285.24,35.55 285.62,35.17 287.48,35.17 288.75,33.9 294.93,33.9 295.53,33.3 298.42,33.3 298.53,33.19 312.77,33.19 314.11,31.85 317.56,31.85 317.96,31.45 329.74,31.45 331.79,29.39 331.79,27.59 332.5,26.89 334.31,26.89 335.77,25.43 335.77,23.43 336.3,22.9 336.3,21.78 335.77,21.25 335.77,20.51 335.11,19.85 335.11,18.98 335.5,18.58 335.5,12.98 334.02,11.5 334.02,3.9 332.71,2.59 331.16,2.59 330.97,2.78 330.97,3.04 v1(330.74,3.27)
  BOTTOM w0.102: v1(330.74,3.27) 330.99,3.52 330.99,3.65 330.72,3.92 330.72,4.55 R4217.2 ; U9002.N15 v1(244.58,67.89)
USBP2+_C: length 4.5
  BOTTOM w0.102: CON4201.7 332.25,7.71 332.4,7.57 332.4,7.24 332.1,6.95 331.27,6.95 331.02,6.7 331.02,6.47 330.72,6.17 330.72,5.54 R4217.1
USBP2-: length 189.8
  IN4 w0.076: v1(331.5,3.27) 331.31,3.27 331.13,3.09 331.13,2.85 331.23,2.76 332.65,2.76 333.85,3.96 333.85,11.56 335.34,13.05 335.34,18.51 334.94,18.91 334.94,19.92 335.6,20.58 335.6,21.32 336.14,21.85 336.14,22.83 335.6,23.36 335.6,25.36 334.24,26.72 332.43,26.72 331.63,27.52 331.63,29.32 329.67,31.28 317.89,31.28 317.49,31.69 314.04,31.69 312.71,33.02 298.46,33.02 298.35,33.14 295.46,33.14 294.86,33.73 288.69,33.73 287.42,35 285.55,35 285.17,35.38 281.37,35.38 281.1,35.65 277.96,35.65 276.53,37.09 259.26,37.09 258.96,36.79 255.43,36.79 254.71,36.07 253.3,36.07 252.67,36.71 250.65,36.71 249.87,35.93 245.01,35.93 242.92,33.83 237.56,33.83 234.09,37.3 231.55,37.3 231.08,37.77 231.08,52.4 230.63,52.85 230.63,62.66 232.58,64.62 232.58,69.4 233.47,70.28 235.86,70.28 236.24,69.9 238.27,69.9 238.6,70.23 241.65,70.23 242.94,68.94 242.94,68.27 243.35,67.87 244.01,67.87 244.2,68.06 244.2,68.25 v1(244.06,68.4)
  BOTTOM w0.102: v1(244.06,68.4) 243.71,68.04 U9002.N13 ; R4224.2 331.52,4.55 331.52,3.92 331.2,3.6 331.2,3.47 331.4,3.27 v1(331.5,3.27)
USBP2-_C: length 4.5
  BOTTOM w0.102: CON4201.9 332.75,7.71 332.6,7.57 332.6,7.16 332.19,6.75 331.35,6.75 331.22,6.62 331.22,6.47 331.52,6.17 331.52,5.54 R4224.1
USBP4+: length 300.9
  TOP w0.102: U7005.3 23.78,98.45 23.48,98.15 23.48,97.67 23.25,97.44 23.25,96.8 23.4,96.65 23.73,96.65 23.78,96.7 v1(23.78,96.99)
  IN3 w0.089: v1(23.78,96.99) 24.11,96.67 24.3,96.67 24.66,96.31 24.66,95.42 25.31,94.77 25.31,92.92 29.5,88.74 29.5,86.6 31.42,84.68 31.42,81.74 33.14,80.02 33.14,75.19 37.17,71.16 37.17,67.71 40.08,64.8 41.77,64.8 43.51,63.05 45.29,63.05 47.86,60.48 48.62,60.48 51.8,57.3 56.94,57.3 60.18,54.07 67.99,54.07 69.15,52.91 74.57,52.91 74.72,53.06 80.54,53.06 81.01,52.59 90.48,52.59 90.74,52.34 94.98,52.34 103.06,44.25 103.06,39.32 106.17,36.21 106.17,34.03 107.18,33.02 108.22,33.02 117.33,23.91 153.38,23.91 154.44,24.98 177.1,24.98 177.87,25.74 186.11,25.74 187.46,27.09 202.69,27.09 204.69,29.1 228.32,29.1 234.73,35.51 234.73,37.94 235.93,39.14 235.93,57.36 241.64,63.06 241.64,65.55 241.75,65.66 241.75,67.39 241.15,67.99 241.15,68.77 241.37,68.99 241.59,68.99 v1(241.84,69.24)
  BOTTOM w0.102: U9002.L9 241.7,69.24 v1(241.84,69.24)
USBP4+_C: length 11.5
  TOP w0.102: v1(14.48,109.18) 14.28,108.98 14.28,108.04 14.58,107.75 15.88,107.75 16.06,107.92 16.06,108.03 15.94,108.15 C7010.2 15.94,108.66 16.08,108.8 16.8,108.8 16.97,108.98 v1(16.97,109.31) 17.21,109.08 L7000.3
  BOTTOM w0.102: CON7000.3 11.25,106.93 12.64,108.32 14.03,108.32 14.33,108.63 14.33,109.03 v1(14.48,109.18)
USBP4+_CHA: length 9.4
  TOP w0.102: L7000.4 20.08,109.08 20.17,108.98 20.67,108.98 20.95,108.7 20.95,106.05 v6(21.24,105.75) 22.56,104.43 23,104.43 23.63,103.81 23.63,102.93 23.78,102.78 U7005.10
USBP4-: length 300.9
  TOP w0.102: U7005.2 23.28,97.75 23.04,97.52 23.04,96.71 23.31,96.45 23.57,96.45 v1(23.78,96.23)
  IN3 w0.089: v1(23.78,96.23) 24.03,96.48 24.22,96.48 24.47,96.23 24.47,95.34 25.12,94.69 25.12,92.84 29.31,88.66 29.31,86.52 31.23,84.6 31.23,81.66 32.95,79.94 32.95,75.11 36.98,71.08 36.98,67.63 40,64.61 41.69,64.61 43.43,62.86 45.21,62.86 47.78,60.29 48.55,60.29 51.72,57.11 56.86,57.11 60.1,53.88 67.91,53.88 69.07,52.72 74.65,52.72 74.8,52.87 80.46,52.87 80.93,52.4 90.4,52.4 90.66,52.15 94.9,52.15 102.87,44.17 102.87,39.24 105.98,36.13 105.98,33.95 107.1,32.83 108.14,32.83 117.25,23.72 153.45,23.72 154.52,24.79 177.18,24.79 177.95,25.55 186.19,25.55 187.54,26.9 202.77,26.9 204.77,28.91 228.4,28.91 234.92,35.43 234.92,37.86 236.13,39.06 236.13,57.28 241.83,62.98 241.83,65.48 241.94,65.58 241.94,67.47 241.34,68.06 241.34,68.69 241.45,68.8 241.64,68.8 v1(241.84,68.61)
  BOTTOM w0.102: U9002.M10 242.1,68.87 v1(241.84,68.61)
USBP4-_C: length 11.5
  TOP w0.102: v1(13.85,109.16) 14.08,108.93 14.08,107.96 14.49,107.54 15.97,107.54 16.26,107.84 16.26,108.03 16.39,108.15 C7010.1 16.53,108.6 16.77,108.6 16.87,108.5 16.87,108.14 v1(16.97,108.04) 17.02,108.04 17.26,108.28 L7000.2
  BOTTOM w0.102: v1(13.85,109.16) 14.13,108.88 14.13,108.71 13.94,108.52 12.56,108.52 11.45,107.42 11.24,107.42 11.13,107.53 11.13,108.2 CON7000.2
USBP4-_CHA: length 9.4
  TOP w0.102: U7005.11 23.28,102.78 23.43,102.93 23.43,103.72 22.92,104.23 22.48,104.23 v6(22.01,104.7) 20.75,105.96 20.75,108.62 20.59,108.78 20.35,108.78 20.23,108.65 20.23,108.38 20.12,108.28 L7000.1
USBP5+: length 250.8
  TOP w0.102: L7001.1 20.65,86.94 20.95,87.24 23.55,87.24 29.22,81.57 35.83,81.57 36.05,81.79 36.05,82.01 v1(36.38,82.34)
  IN3 w0.089: v1(236.63,73.12) 236.01,73.12 235.11,72.21 231.92,72.21 230.11,70.41 228.89,70.41 228.71,70.58 226.85,70.58 226.04,71.39 220.58,71.39 218.33,73.64 218.33,75.25 216.91,76.67 210.5,76.67 209.7,77.47 174.57,77.47 167.6,70.5 118.24,70.5 114.19,66.45 101.19,66.45 97.93,63.19 96.67,63.19 96.2,62.72 95.68,62.72 93.69,60.73 90.98,60.73 87.73,57.49 81.97,57.49 81.12,58.33 75.27,58.33 72.68,60.92 63.4,60.92 62.37,61.95 57.93,61.95 54.13,65.75 49.49,65.75 45.8,69.43 42.49,69.43 41.69,70.23 41.69,70.96 40.29,72.35 40.29,73.12 39.85,73.56 39.85,78.15 36.1,81.89 36.1,82.06 v1(36.38,82.34)
  BOTTOM w0.102: U9002.L2 239.17,71.53 239.17,71.99 238.42,72.75 237.81,72.75 237.45,73.12 v1(236.63,73.12)
USBP5+_C: length 10.4
  TOP w0.102: CON7002.3 10.98,88.09 10.98,88.54 11.16,88.72 11.46,88.72 12.48,87.7 13.21,87.7 13.77,87.14 14.48,87.14 v1(15.02,86.6) 15.02,86.99 15.17,87.14 15.53,87.14 C7011.2 15.68,86.68 16.16,86.2 16.92,86.2 17.67,86.94 L7001.2
USBP5-: length 250.7
  TOP w0.102: L7001.4 20.65,87.74 20.95,87.44 23.64,87.44 29.3,81.78 35.74,81.78 35.85,81.88 35.85,82.03 v1(35.59,82.29)
  IN3 w0.089: v1(35.59,82.29) 35.91,81.97 35.91,81.82 39.66,78.07 39.66,73.48 40.1,73.04 40.1,72.27 41.5,70.88 41.5,70.15 42.41,69.24 45.72,69.24 49.41,65.56 54.06,65.56 57.85,61.76 62.29,61.76 63.32,60.73 72.6,60.73 75.19,58.14 81.05,58.14 81.89,57.3 87.81,57.3 91.06,60.54 93.77,60.54 95.76,62.53 96.28,62.53 96.75,63 98.01,63 101.27,66.26 114.27,66.26 118.32,70.31 167.68,70.31 174.65,77.28 209.62,77.28 210.42,76.48 216.83,76.48 218.14,75.17 218.14,73.57 220.51,71.2 225.96,71.2 226.77,70.39 228.64,70.39 228.81,70.22 230.19,70.22 231.99,72.02 235.19,72.02 236.09,72.93 236.21,72.93 236.63,72.51 236.63,72.33 v1(236.56,72.25)
  BOTTOM w0.102: v1(236.56,72.25) 236.56,72.46 237,72.91 237.36,72.91 237.73,72.55 238.33,72.55 238.86,72.02 U9002.M1
USBP5-_C: length 10.4
  TOP w0.102: CON7002.2 11.25,89.21 12.56,87.9 13.3,87.9 13.85,87.35 14.5,87.35 14.8,87.65 14.8,87.66 v1(15.02,87.87) 15.02,87.5 15.17,87.35 15.93,87.35 16.13,87.15 C7011.1 16.13,86.51 16.25,86.4 16.84,86.4 18.18,87.74 L7001.3
USBP7+: length 219.5
  IN3 w0.089: v1(238.23,72.04) 238.45,71.81 238.7,71.81 239.05,71.46 239.05,71.07 238.68,70.7 237.73,70.7 237.47,70.45 235.98,70.45 235.59,70.84 233.17,70.84 231.53,69.2 228.71,69.2 228.1,69.81 226.53,69.81 225.72,70.62 220.26,70.62 217.56,73.32 217.56,74.87 216.54,75.88 210.15,75.88 209.35,76.68 174.88,76.68 167.91,69.71 118.55,69.71 114.52,65.68 101.83,65.68 98.24,62.09 97.26,62.09 97,61.83 97,61.53 95.4,59.93 91.32,59.93 88.1,56.71 78.29,56.71 78.09,56.5 76.54,56.5 76.24,56.8 76.24,56.95 v1(75.98,57.22)
  BOTTOM w0.102: L3004.1 49.58,45.82 49.29,45.53 49.29,45.32 50.71,43.91 v6(54.62,43.91) 60.74,43.91 61.88,45.05 71.37,45.05 77.3,50.98 77.3,53.73 76.21,54.82 76.21,56.99 v1(75.98,57.22) ; U9002.L3 239.4,71.1 239.1,71.1 238.66,71.53 238.66,71.61 v1(238.23,72.04)
USBP7+_C: length 6.4
  BOTTOM w0.102: CON3000.31 50.43,53.23 49.28,52.08 v6(49.28,49.21) 49.28,48.66 49.58,48.36 L3004.2
USBP7-: length 219.5
  IN3 w0.089: v1(238.23,71.4) 238.23,71.51 238.34,71.62 238.62,71.62 238.86,71.39 238.86,71.15 238.6,70.89 237.65,70.89 237.39,70.64 236.06,70.64 235.67,71.03 233.09,71.03 231.45,69.39 228.78,69.39 228.18,70 226.61,70 225.79,70.81 220.34,70.81 217.75,73.4 217.75,74.95 216.62,76.08 210.23,76.08 209.43,76.88 174.8,76.88 167.83,69.9 118.47,69.9 114.44,65.87 101.75,65.87 98.16,62.28 97.18,62.28 96.81,61.9 96.81,61.61 95.32,60.12 91.24,60.12 88.02,56.9 78.22,56.9 78.01,56.69 76.67,56.69 76.43,56.93 76.43,57.03 v1(76.61,57.22)
  BOTTOM w0.102: L3004.4 48.78,45.84 49.09,45.53 49.09,45.24 50.62,43.7 60.82,43.7 61.97,44.85 71.46,44.85 77.5,50.89 77.5,53.81 76.41,54.9 76.41,57.01 v1(76.61,57.22) ; U9002.L4 239.74,70.68 239.49,70.68 239.27,70.89 239.01,70.89 238.5,71.4 v1(238.23,71.4)
USBP7-_C: length 6.3
  BOTTOM w0.102: L3004.3 48.78,48.33 49.08,48.63 v6(49.08,51.53) 49.08,52.17 49.93,53.02 CON3000.32
USBP8+: length 143.2
  IN4 w0.076: v1(239.4,69.29) 239.14,69.29 238.89,69.05 234.63,69.05 233.38,67.8 233.38,64.3 231.34,62.25 231.34,53.27 231.81,52.8 231.81,39.8 232.09,39.51 234.17,39.51 234.3,39.38 242.63,39.38 243.82,38.19 245.29,38.19 246.13,37.35 247.22,37.35 247.43,37.56 258.57,37.56 258.82,37.81 276.98,37.81 278.3,36.49 281.32,36.49 281.72,36.1 285.47,36.1 285.84,35.72 287.7,35.72 288.97,34.46 295.18,34.46 295.43,34.2 307.02,34.2 307.34,33.88 v1(307.34,33.82)
  BOTTOM w0.102: v1(307.34,33.82) 307.09,33.57 307.09,28.17 297.34,18.42 v6(297.34,17.87) 297.34,11.05 297.13,10.84 296.29,10.84 R7202.2 ; U9002.G5 239.16,69.05 v1(239.4,69.29)
USBP8+_C: length 10.2
  IN1 w0.076: v1(292.89,11.14) 292.21,11.83 291.93,11.83 290.9,10.8 290.9,7.84 291.16,7.58 v1(291.24,7.58)
  BOTTOM w0.102: CON7200.5 291.2,7.63 v1(291.24,7.58) ; R7202.1 295.3,10.84 295.04,11.09 294.75,11.09 294.48,10.82 ESD7200.3 293.21,10.82 v1(292.89,11.14)
USBP8-: length 143.1
  IN4 w0.076: v1(306.71,33.82) 306.71,33.85 306.52,34.04 295.37,34.04 295.11,34.29 288.9,34.29 287.63,35.56 285.77,35.56 285.4,35.93 281.65,35.93 281.26,36.32 278.23,36.32 276.91,37.64 258.89,37.64 258.64,37.39 247.5,37.39 247.29,37.19 246.06,37.19 245.23,38.03 243.75,38.03 242.56,39.22 234.23,39.22 234.1,39.35 232.02,39.35 231.64,39.73 231.64,52.73 231.17,53.2 231.17,62.32 233.22,64.37 233.22,67.87 234.56,69.22 238.83,69.22 238.92,69.31 238.92,69.52 v1(238.84,69.6)
  BOTTOM w0.102: R7201.2 296.45,11.9 296.55,11.8 296.55,11.17 296.67,11.05 297.04,11.05 297.14,11.14 297.14,18.51 306.89,28.26 306.89,33.64 v1(306.71,33.82) ; v1(238.84,69.6) 238.67,69.6 U9002.G4
USBP8-_C: length 10.2
  IN1 w0.076: v1(290.61,7.58) 290.74,7.71 290.74,10.87 291.86,11.99 292.47,11.99 v1(292.89,12.41)
  BOTTOM w0.102: v1(290.61,7.58) 290.7,7.68 CON7200.6 ; v1(292.89,12.41) 293.21,12.72 ESD7200.1 294.48,12.72 R7201.1
USBP9+: length 121.1
  TOP w0.102: R7306.2 283.65,15.31 283.65,16.45 282.86,17.24 282.86,21.64 284.13,22.91 284.13,25.62 284.44,25.92 284.44,27.01 279.84,31.6 v1(279.84,34.58)
  IN4 w0.076: v1(279.84,34.58) 279.84,34.93 279.67,35.1 277.4,35.1 276.68,35.83 270.92,35.83 270.68,36.07 255.58,36.07 254.79,35.28 245.13,35.28 243.14,33.29 237.09,33.29 234.22,36.16 231.7,36.16 230.52,37.33 230.52,52.09 230.08,52.54 230.08,62.91 232.02,64.85 232.02,69.63 233.35,70.96 236.38,70.96 236.68,70.65 238.1,70.65 239.29,71.85 240.77,71.85 241.1,71.51 241.1,71.12 v1(241.25,70.97)
  BOTTOM w0.102: v1(241.25,70.97) 241.25,70.41 U9002.N8
USBP9+_R: length 3.2
  TOP w0.102: v1(283.37,13.27) 283.65,13.55 283.65,13.67 R7306.1
  BOTTOM w0.102: v1(283.37,13.27) 283.63,13.01 283.63,12.73 283.41,12.51 U7300.9
USBP9-: length 121.1
  TOP w0.102: v1(280.47,34.63) 280.47,34.58 280.04,34.15 280.04,31.69 284.64,27.09 284.64,25.84 284.33,25.53 284.33,22.82 283.06,21.55 283.06,17.32 283.85,16.53 283.85,15.26 R7305.2
  IN4 w0.076: v1(240.62,71) 240.7,71 240.94,71.24 240.94,71.44 240.7,71.68 239.36,71.68 238.17,70.49 236.62,70.49 236.31,70.79 233.42,70.79 232.19,69.56 232.19,64.78 230.24,62.84 230.24,52.61 230.69,52.16 230.69,37.4 231.77,36.32 234.29,36.32 237.16,33.45 243.07,33.45 245.07,35.45 254.73,35.45 255.51,36.24 270.75,36.24 270.99,35.99 276.75,35.99 277.47,35.27 279.74,35.27 280.37,34.63 v1(280.47,34.63)
  BOTTOM w0.102: U9002.M6 240.95,70.34 240.85,70.24 240.71,70.24 240.62,70.34 v1(240.62,71)
USBP9-_R: length 3.2
  TOP w0.102: R7305.1 283.85,13.72 283.85,13.55 v1(284.13,13.27)
  BOTTOM w0.102: U7300.8 284.06,12.33 283.84,12.55 283.84,12.98 v1(284.13,13.27)
USBP11+: length 211.9
  IN4 w0.076: v1(243.16,70.2) 243.16,69.61 243.7,69.06 247.08,69.06 252.21,63.93 252.7,63.93 254.43,62.21 254.43,60.55 256.32,58.66 256.32,56.27 258.97,53.62 260.54,53.62 261.08,53.08 261.08,52.3 262.09,51.28 263.5,51.28 263.83,51.61 264.38,51.61 265.09,50.9 275.41,50.9 276.99,49.33 282.59,49.33 283.45,48.47 287.11,48.47 288.2,47.37 290.24,47.37 290.6,47.02 296.03,47.02 296.6,47.59 298.46,47.59 298.98,48.11 302.28,48.11 302.41,48.24 305.85,48.24 306.27,47.82 306.27,46.67 308.02,44.92 315.25,44.92 316.03,44.13 318.47,44.13 319.12,43.49 330.55,43.49 331.06,43.99 335.38,43.99 335.77,44.39 341.64,44.39 342.04,44.79 344.33,44.79 344.46,44.92 350.79,44.92 351.83,45.97 352.72,45.97 354.11,47.36 354.11,55.97 353.6,56.48 353.09,56.48 352.2,57.37 352.2,57.62 350.68,59.15 350.68,62.59 350.44,62.83 350.44,66.25 349.79,66.89 349.79,72.15 348.39,73.55 348.39,74.71 347.32,75.78 346.66,75.78 345.35,77.09 339.44,77.09 334.77,81.77 334.77,85.73 333.48,87.01 332.98,87.01 v1(332.77,87.21)
  BOTTOM w0.102: U8500.A6 342.76,97.76 342.76,99.13 342.78,99.15 342.78,102.13 342.44,102.48 337.04,102.48 336.2,101.64 v6(336.2,100.65) 336.2,97.45 335.39,96.64 334.36,96.64 332.65,94.92 332.65,91.88 333.58,90.94 333.58,89.01 333.22,88.64 333.22,87.34 333.07,87.19 332.79,87.19 v1(332.77,87.21) ; v1(243.16,70.2) 242.92,69.96 U9002.P9
USBP11+_BOT: length 46.9
  TOP w0.102: CON7100.A6 361.53,131.71 arc(361.43,131.73) 361.35,131.78 361.29,131.84 arc(361.21,131.9) 361.11,131.92 359.09,131.92 arc(358.99,131.9) 358.91,131.84 358.88,131.81 arc(358.83,131.73) 358.81,131.63 D7109.2 358.81,131.52 358.47,131.52 358.3,131.35 358.3,131.11 arc(358.28,131.01) 358.22,130.93 358.05,130.76 arc(357.98,130.71) 357.9,130.69 v1(357.8,130.69)
  IN4 w0.076: v3(347.61,98.67) 347.61,98.53 347.77,98.37 347.79,98.37 347.99,98.57 348.64,98.57 350.22,100.15 350.22,101.37 354.06,105.2 354.06,112.18 355.45,113.58 355.45,118.06 356.83,119.43 356.83,128.96 358.51,130.65 358.51,131.05 358.4,131.16 358.18,131.16 357.8,130.79 v1(357.8,130.69)
  BOTTOM w0.102: v3(347.61,98.67) 347.38,98.44 346.89,98.44 346.42,97.97 346.42,97.82 345.68,97.09 U8500.B1
USBP11+_TOP: length 48.9
  TOP w0.102: v3(362.88,132.19) 362.9,132.21 CON7100.B6
  IN4 w0.076: v1(348.14,102.2) 347.97,102.2 347.82,102.05 347.82,101.79 348.1,101.51 349.07,101.51 351.4,103.85 351.4,105.59 353.5,107.69 353.5,117.37 356.06,119.94 356.06,130.89 v1(357.8,132.63)
  BOTTOM w0.102: U8500.A1 345.43,97.76 346.32,98.64 346.35,98.64 347.38,99.67 347.38,100.8 347.9,101.33 347.9,101.96 v1(348.14,102.2) ; v1(357.8,132.63) 358.05,132.37 arc(358.14,132.32) 358.23,132.3 358.44,132.3 arc(358.53,132.32) 358.62,132.37 D7104.2 359.13,132.25 arc(359.21,132.19) 359.31,132.17 360.2,132.17 arc(360.38,132.14) 360.52,132.04 arc(360.57,132.01) 360.63,132 362.69,132 arc(362.82,132.05) v3(362.88,132.19)
USBP11-: length 211.8
  IN4 w0.076: v1(243.79,70.13) 243.64,70.13 243.32,69.81 243.32,69.68 243.77,69.23 247.15,69.23 252.28,64.1 252.77,64.1 254.59,62.28 254.59,60.62 256.48,58.73 256.48,56.34 259.04,53.79 260.61,53.79 261.25,53.15 261.25,52.36 262.16,51.45 263.43,51.45 263.76,51.78 264.45,51.78 265.16,51.07 275.48,51.07 277.06,49.49 282.66,49.49 283.52,48.63 287.17,48.63 288.27,47.54 290.31,47.54 290.66,47.18 295.96,47.18 296.53,47.75 298.39,47.75 298.91,48.27 302.22,48.27 302.34,48.4 305.92,48.4 306.43,47.89 306.43,46.74 308.09,45.09 315.31,45.09 316.1,44.3 318.54,44.3 319.19,43.65 330.49,43.65 330.99,44.16 335.31,44.16 335.71,44.55 341.57,44.55 341.97,44.96 344.26,44.96 344.39,45.09 350.72,45.09 351.76,46.13 352.65,46.13 353.94,47.42 353.94,55.9 353.53,56.31 353.02,56.31 352.04,57.3 352.04,57.55 350.51,59.08 350.51,62.52 350.27,62.76 350.27,66.18 349.62,66.82 349.62,72.08 348.23,73.48 348.23,74.64 347.25,75.62 346.59,75.62 345.28,76.93 339.37,76.93 334.6,81.7 334.6,85.66 333.41,86.84 332.9,86.84 332.77,86.72 v1(332.77,86.45)
  BOTTOM w0.102: U8500.A7 342.58,97.74 342.58,102.05 342.35,102.28 337.12,102.28 336.4,101.56 336.4,97.36 335.47,96.43 334.45,96.43 332.85,94.83 332.85,91.96 333.79,91.02 333.79,88.92 333.42,88.56 333.42,87.26 332.77,86.6 v1(332.77,86.45) ; U9002.R10 243.36,69.46 243.49,69.46 243.79,69.76 v1(243.79,70.13)
USBP11-_BOT: length 47
  TOP w0.102: v1(357.8,131.33) 357.88,131.33 arc(357.98,131.34) 358.06,131.4 358.73,132.07 arc(358.79,132.15) 358.81,132.25 D7107.2 359.05,132.19 arc(359.13,132.14) 359.23,132.12 361.32,132.12 arc(361.38,132.13) 361.43,132.17 arc(361.48,132.2) 361.54,132.21 CON7100.A7
  IN4 w0.076: v3(347.61,98.08) 347.72,98.2 347.86,98.2 348.06,98.4 348.71,98.4 350.39,100.08 350.39,101.3 354.22,105.14 354.22,112.11 355.62,113.51 355.62,117.99 356.99,119.36 356.99,128.89 358.68,130.58 358.68,131.12 358.47,131.33 v1(357.8,131.33)
  BOTTOM w0.102: v3(347.61,98.08) 347.45,98.24 346.97,98.24 346.62,97.89 346.62,97.78 345.74,96.89 U8500.C1
USBP11-_TOP: length 48.9
  TOP w0.102: CON7100.B7 362.94,131.71 v3(362.88,131.65)
  IN4 w0.076: v1(347.45,102.2) 347.66,102 347.66,101.72 348.03,101.35 349.14,101.35 351.57,103.78 351.57,105.52 353.66,107.62 353.66,117.3 356.23,119.87 356.23,130.82 357.4,131.99 v1(357.8,131.99)
  BOTTOM w0.102: U8500.A2 345.01,97.59 347.17,99.75 347.17,100.89 347.7,101.41 347.7,101.95 v1(347.45,102.2) ; v1(357.8,131.99) 357.85,132.04 arc(357.91,132.08) 357.97,132.09 358.26,132.09 arc(358.35,132.08) 358.44,132.02 D7105.2 359.05,131.89 arc(359.13,131.95) 359.23,131.97 360.2,131.97 arc(360.3,131.95) 360.38,131.9 arc(360.49,131.82) 360.63,131.79 362.69,131.79 362.74,131.79 arc(362.84,131.75) v3(362.88,131.65)
USBP13+: length 198.7
  IN1 w0.076: v1(337.73,88.56) 337.48,88.32 337.48,88.07 339.57,85.98 344.4,85.98 350.43,79.95 350.43,76.29 351.03,75.68 351.03,68.23 351.9,67.36 351.9,62.22 350.53,60.85 350.53,58.38 349.56,57.42 349.56,56.78 349.19,56.41 349.19,54.74 344.62,50.16 344.62,49.16 338.74,43.28 338.74,38.47 334.48,34.2 323.65,34.2 323.12,33.67 314.83,33.67 310.69,37.81 307.27,37.81 305.54,39.54 295.09,39.54 294.3,40.32 288.11,40.32 286.35,42.09 280.89,42.09 278.96,44.02 278.02,44.02 275.15,46.89 271.46,46.89 266.45,51.91 265.41,51.91 264.3,53.01 263.98,53.01 262.92,54.07 262.46,54.07 260.34,56.18 260.34,57.03 259.71,57.66 259.71,60.2 258.99,60.92 258.99,61.76 251.45,69.3 251.45,70.63 251.04,71.05 248.69,71.05 247.61,69.97 246.77,69.97 246.08,70.65 242.81,70.65 242.51,70.96 242.45,70.96 241.85,71.55 239.74,71.55 238.79,72.5 238.79,73.05 v1(238.66,73.18)
  BOTTOM w0.102: v1(337.73,88.56) 337.55,88.74 337.19,88.74 336.87,89.06 336.87,90.55 336.33,91.09 336.33,92.05 338.68,94.4 339.56,94.4 340.07,94.91 340.26,94.91 U8500.F11 ; v1(238.66,73.18) 239.04,72.8 239.04,72.55 239.66,71.93 U9002.N2
USBP13+_BOT: length 37.6
  TOP w0.102: v1(357.66,115.43) 358.01,115.43 358.09,115.35 arc(358.2,115.28) 358.33,115.25 358.45,115.25 arc(358.55,115.24) 358.63,115.18 358.73,115.07 arc(358.79,114.99) 358.81,114.9 D7125.2 359.15,115.1 arc(359.23,115.16) 359.33,115.18 359.44,115.18 arc(359.61,115.21) 359.76,115.31 359.77,115.32 arc(359.78,115.33) 359.8,115.33 360.72,115.33 arc(360.78,115.32) 360.83,115.28 arc(360.87,115.25) 360.91,115.23 arc(360.96,115.2) 361.01,115.19 arc(361.04,115.19) 361.07,115.18 361.31,115.18 arc(361.38,115.17) 361.45,115.13 arc(361.51,115.08) 361.59,115.07 CON7101.A6
  IN4 w0.076: v1(357.66,115.43) 357.66,115.48 357.33,115.81 357.18,115.81 356.8,115.43 356.8,113.16 356.19,112.55 356.19,105.26 351.95,101.02 351.95,99.91 347.83,95.8 346.46,95.8 345.95,95.29 345.95,92.48 346.35,92.08 346.48,92.08 346.87,92.47 v1(346.87,92.55)
  BOTTOM w0.102: U8500.K1 345.58,92.94 345.76,92.94 346.35,92.34 346.67,92.34 v1(346.87,92.55)
USBP13+_TOP: length 33.7
  TOP w0.102: v3(362.88,115.55) 362.9,115.57 CON7101.B6
  IN4 w0.076: v1(347.12,94.96) 347.24,94.85 348.13,94.85 356.9,103.62 356.9,108.8 357.21,109.11 357.21,113.71 v1(357.66,114.16)
  BOTTOM w0.102: v1(357.66,114.16) 357.92,114.16 arc(358,114.18) 358.08,114.23 arc(358.13,114.3) 358.15,114.39 358.15,114.87 arc(358.18,115.05) 358.29,115.2 358.81,115.72 D7120.2 358.95,115.65 arc(359.11,115.55) 359.3,115.51 360.84,115.51 arc(360.96,115.48) 361.07,115.41 361.15,115.34 arc(361.18,115.31) 361.22,115.31 362.36,115.31 arc(362.62,115.36) 362.83,115.5 v3(362.88,115.55) ; v1(347.12,94.96) 346.92,94.76 346.54,94.76 346.22,94.44 345.58,94.44 U8500.G1
USBP13-: length 198.7
  IN1 w0.076: v1(337.73,89.24) 337.32,88.84 337.32,88 339.5,85.82 344.33,85.82 350.26,79.89 350.26,76.22 350.87,75.61 350.87,68.16 351.73,67.29 351.73,62.29 350.36,60.91 350.36,58.45 349.4,57.49 349.4,56.85 349.03,56.48 349.03,54.8 344.46,50.23 344.46,49.23 338.58,43.35 338.58,38.53 334.41,34.37 323.58,34.37 323.05,33.83 314.9,33.83 310.76,37.98 307.33,37.98 305.61,39.7 295.15,39.7 294.37,40.49 288.18,40.49 286.42,42.25 280.96,42.25 279.03,44.18 278.09,44.18 275.22,47.06 271.53,47.06 266.52,52.07 265.47,52.07 264.37,53.18 264.04,53.18 262.99,54.23 262.53,54.23 260.51,56.25 260.51,57.09 259.87,57.73 259.87,60.27 259.15,60.99 259.15,61.83 251.62,69.36 251.62,70.7 251.11,71.21 248.62,71.21 247.54,70.13 246.84,70.13 246.15,70.82 242.88,70.82 242.57,71.12 242.52,71.12 241.92,71.72 239.81,71.72 238.96,72.57 238.96,72.95 239.19,73.18 v1(239.3,73.18)
  BOTTOM w0.102: v1(337.73,89.24) 337.42,88.94 337.28,88.94 337.07,89.15 337.07,90.64 336.53,91.18 336.53,91.96 338.77,94.2 339.64,94.2 340.16,94.71 340.31,94.71 U8500.G11 ; 240.02,71.48 240.02,71.86 239.3,72.58 v1(239.3,73.18)
USBP13-_BOT: length 37.7
  TOP w0.102: CON7101.A7 361.66,115.57 arc(361.54,115.55) 361.44,115.48 arc(361.34,115.41) 361.23,115.39 361.07,115.39 arc(361.06,115.39) 361.05,115.39 arc(361.03,115.4) 361.01,115.4 arc(360.99,115.41) 360.98,115.43 arc(360.86,115.51) 360.72,115.53 359.8,115.53 arc(359.7,115.51) 359.62,115.46 359.62,115.46 arc(359.54,115.4) 359.44,115.38 359.2,115.38 arc(359.11,115.4) 359.02,115.46 D7123.2 358.67,115.53 arc(358.58,115.48) 358.49,115.46 358.33,115.46 arc(358.28,115.47) 358.24,115.49 v1(357.66,116.07)
  IN4 w0.076: v1(346.87,91.91) 346.28,91.91 345.79,92.41 345.79,95.36 346.39,95.96 347.77,95.96 351.78,99.98 351.78,101.09 356.03,105.33 356.03,112.62 356.64,113.23 356.64,115.5 357.11,115.98 357.58,115.98 v1(357.66,116.07)
  BOTTOM w0.102: U8500.L1 345.58,92.74 345.71,92.74 346.28,92.17 346.62,92.17 v1(346.87,91.91)
USBP13-_TOP: length 33.7
  TOP w0.102: v3(362.88,115.01) 362.94,115.07 CON7101.B7
  IN4 w0.076: v1(347.12,94.32) 347.12,94.41 347.39,94.68 348.19,94.68 357.07,103.55 357.07,108.73 357.37,109.04 357.37,113.37 357.52,113.53 v1(357.66,113.53)
  BOTTOM w0.102: v1(347.12,94.32) 347.12,94.38 346.92,94.58 346.62,94.58 346.3,94.26 345.61,94.26 U8500.H1 ; v1(357.66,113.53) 358.22,114.09 arc(358.32,114.23) 358.35,114.39 358.35,114.87 arc(358.37,114.97) 358.43,115.06 358.45,115.08 arc(358.59,115.14) 358.74,115.08 358.76,115.05 arc(358.8,115.01) 358.81,114.95 D7121.2 359.08,115.16 arc(359.24,115.27) 359.44,115.31 360.84,115.31 arc(360.89,115.3) 360.93,115.27 361.06,115.14 arc(361.1,115.11) 361.15,115.1 362.66,115.1 arc(362.78,115.08) v3(362.88,115.01)
USBP14+: length 161.5
  IN4 w0.076: v1(238.48,67.62) 238.48,67.73 238.67,67.91 238.84,67.91 238.91,67.84 238.91,67.37 238.03,66.49 238.03,65.65 237.2,64.82 236.59,64.82 236.09,64.31 236.09,63.41 235.59,62.91 234.89,62.91 232.49,60.51 232.49,58.73 233.42,57.81 233.42,54.68 233.93,54.18 233.93,53.49 239.09,48.33 239.85,48.33 240.05,48.13 240.05,45.44 241.12,44.38 241.12,42.87 242.79,41.2 245.07,41.2 246.76,39.52 256.99,39.52 257.28,39.8 261.89,39.8 262.17,39.52 267.97,39.52 268.24,39.25 269.89,39.25 270.38,38.75 277.77,38.75 278.43,38.09 281.46,38.09 282.07,37.48 284.48,37.48 284.88,37.08 285.82,37.08 286.22,36.68 288.06,36.68 289.34,35.4 295.58,35.4 295.85,35.13 314.06,35.13 314.52,34.67 318.05,34.67 318.26,34.46 318.26,34.34 318.12,34.2 v1(317.99,34.2)
  BOTTOM w0.102: v1(317.99,34.2) 318.17,34.38 318.17,34.71 318.6,35.14 318.6,35.96 318.29,36.26 318.29,38.86 322.15,42.71 323.7,42.71 324.03,43.05 324.03,46 324.61,46.57 326.99,46.57 328.16,45.4 329.01,45.4 330.08,46.47 330.08,47.61 330.5,48.04 332.45,48.04 332.9,48.49 332.9,50.01 334.27,51.38 334.27,52.34 334.93,53 334.93,54.09 TP4107.1 334.88,54.65 334.93,54.7 334.93,55.23 335.65,55.96 335.65,56.35 337.29,57.99 337.29,58.49 337.14,58.63 L4100.4 L4100.3 337.14,59.71 337.29,59.86 337.29,60.27 337.95,60.92 337.95,62.39 337.45,62.89 336.76,62.89 336.54,63.11 336.54,63.3 336.39,63.44 U4100.70 ; U9002.F6 238.83,68.15 238.48,67.8 v1(238.48,67.62)
USBP14-: length 161.4
  IN4 w0.076: v1(318.62,34.2) 318.42,34.41 318.42,34.53 318.12,34.84 314.59,34.84 314.13,35.3 295.92,35.3 295.65,35.56 289.41,35.56 288.13,36.84 286.29,36.84 285.89,37.25 284.95,37.25 284.55,37.64 282.14,37.64 281.53,38.25 278.5,38.25 277.84,38.91 270.45,38.91 269.96,39.41 268.31,39.41 268.03,39.68 262.24,39.68 261.96,39.97 257.21,39.97 256.92,39.68 246.83,39.68 245.14,41.37 242.86,41.37 241.28,42.94 241.28,44.44 240.21,45.51 240.21,48.2 239.92,48.49 239.16,48.49 234.09,53.56 234.09,54.24 233.59,54.75 233.59,57.88 232.66,58.8 232.66,60.44 234.96,62.74 235.66,62.74 236.25,63.34 236.25,64.25 236.66,64.66 237.27,64.66 238.2,65.59 238.2,66.42 239.07,67.3 239.07,67.91 238.53,68.45 v1(238.53,68.53)
  BOTTOM w0.102: v1(318.62,34.2) 318.37,34.46 318.37,34.63 318.8,35.06 318.8,36.04 318.5,36.34 318.5,38.78 322.23,42.51 323.78,42.51 324.24,42.97 324.24,45.91 324.69,46.37 326.9,46.37 328.07,45.2 329.1,45.2 330.28,46.39 330.28,47.53 330.59,47.84 332.54,47.84 333.1,48.4 333.1,49.93 334.47,51.3 334.47,52.25 335.13,52.91 335.13,54.14 TP4106.1 335.21,54.65 335.13,54.73 335.13,55.15 335.86,55.87 335.86,56.26 337.5,57.9 337.5,58.51 337.64,58.66 L4100.1 L4100.2 337.64,59.71 337.5,59.86 337.5,60.19 338.15,60.84 338.15,62.47 337.53,63.09 336.84,63.09 336.74,63.19 336.74,63.3 336.89,63.44 U4100.69 ; v1(238.53,68.53) 238.53,68.51 U9002.E5
USIM_DETECT: length 57.6
  TOP w0.114: R4204.1 C4200.1 v1(304.83,13.81)
  IN3 w0.089: v1(347.05,17.39) 346.44,18 344.08,18 343.92,18.16 341.32,18.16 340.01,16.85 339.25,16.85 339.05,17.06 333.38,17.06 333.07,16.75 329.2,16.75 328.35,15.9 328.31,15.9 328.3,15.89 325.46,15.89 323.86,14.29 320.97,14.29 320.13,13.44 316.36,13.44 315.32,12.41 306.69,12.41 305.28,13.81 v1(304.83,13.81)
  BOTTOM w0.114: v1(347.05,17.39) 347,17.34 CON4201.66 ; CON4200.1 309.24,15.37 310.06,14.54 310.06,13.78 308.77,12.49 306.15,12.49 v1(304.83,13.81)
VADPBL: length 286.2
  TOP w0.152: v1(258.78,5.88) 258.22,6.44 257.59,6.44 257.46,6.57 257.46,8.47 256.75,9.18 PD11007.2
  IN1 w0.152: v4(342.55,145.76) 343.19,145.12 348.23,145.12 348.49,145.38 349.54,145.38 349.82,145.09 349.82,140.46 349.33,139.97 347.16,139.97 346.41,139.22 344.09,139.22 342.4,137.53 342.4,135.92 342.18,135.7 342.18,132.48 347.17,127.48 355.47,127.48 357.03,125.93 357.03,125.92 357.22,125.73 357.37,125.58 357.37,124.8 359.44,122.73 359.44,119.98 359.95,119.47 359.95,118.96 359.57,118.58 359.57,115.91 360.2,115.28 360.97,115.28 361.32,114.93 361.32,113.99 361.11,113.78 360.86,113.78 360.2,113.12 360.2,111.98 359.1,110.87 359.1,110.29 360.59,108.8 361.67,107.72 361.67,106.1 361.91,105.87 363.25,104.52 v1(363.25,102.96)
  IN2 w0.152: v1(297.72,8.09) 298.02,8.09 302.05,4.07 315.96,4.07 316.35,4.45 319.73,4.45 320.12,4.07 320.33,4.07 321.96,2.43 337.78,2.43 338.99,3.64 339.07,3.64 347.09,3.64 347.15,3.58 351.63,3.58 356.8,8.75 356.8,19.12 355.66,20.27 355.66,20.47 355.66,23.64 354.26,25.04 354.26,27.52 354.26,27.72 357.72,31.18 357.92,31.18 359.5,31.18 361.12,32.8 361.12,38.06 361.12,38.26 363.65,40.8 363.65,63.02 363.91,63.28 363.91,64.61 362.28,66.24 362.28,68.76 361,70.03 361,85.3 360.99,85.31 360.99,85.51 362.53,87.04 362.53,102.24 v1(363.25,102.96)
  IN3 w0.152: v1(297.72,8.09) 297.5,7.88 296.65,7.88 295.4,6.63 277.55,6.63 275.33,8.85 272.59,8.85 272.28,8.54 261.72,8.54 260.74,7.56 260.48,7.56 258.81,5.88 v1(258.78,5.88)
  vias: v1(340.77,146.78) v4(338.74,145.76) v4(339.5,145.76) v4(340.27,145.76) v4(341.03,145.76) v4(341.79,145.76)
VCORE_CS1: length 33.2
  TOP w0.254: v1(143.03,159.73) PR20002.1
  IN3 w0.203: v1(127.93,143.23) 128.48,142.67 130.73,142.67 133.76,145.7 133.76,148.22 133.56,148.43 133.56,151.5 139.26,157.2 139.26,159.91 140.02,160.67 142.09,160.67 v1(143.03,159.73)
  BOTTOM w0.203: PU19000.5 127.89,145.39 128.56,144.72 128.56,143.5 128.58,143.47 PR19013.1 128.31,142.86 128.12,143.05 128.11,143.05 v1(127.93,143.23)
VCORE_CS2: length 39.7
  TOP w0.254: PR20020.1 v1(150.53,159.73)
  IN3 w0.203: v1(150.53,159.73) 149.3,160.96 139.9,160.96 138.97,160.03 138.97,157.37 132.73,151.13 132.73,147.36 133.41,146.68 133.41,145.76 130.61,142.97 129.69,142.97 v1(129.17,143.48)
  BOTTOM w0.203: PU19000.4 128.29,145.45 129.04,144.69 v1(129.04,144.24) 129.19,144.24 129.83,143.6 PR19015.2 129.21,143.44 v1(129.17,143.48)
VCORE_CS3: length 46.7
  TOP w0.254: v1(158.4,159.73) PR20032.1
  IN3 w0.203: v1(158.4,159.73) 156.88,161.25 139.78,161.25 138.68,160.15 138.68,157.56 132.44,151.32 132.44,147.24 133.12,146.56 133.12,145.88 130.72,143.48 v1(130.44,143.48)
  BOTTOM w0.203: v1(130.44,143.48) 130.48,143.44 PR19018.1 131.1,143.74 130.3,144.53 129.69,144.53 128.69,145.53 PU19000.3
VCORE_CS4: length 58.3
  TOP w0.254: v1(166.53,159.73) PR20047.1
  IN2 w0.203: v1(166.53,159.73) 166.04,159.24 163.86,159.24 163.4,159.69 161.29,159.69 160.83,159.24 158.27,159.24 158.03,159.48 156.61,159.48 156.37,159.24 155.86,159.24 155.49,159.6 153.45,159.6 153.08,159.24 148.7,159.24 148.21,159.73 145.99,159.73 145.19,158.93 144.14,158.93 138.96,153.75 136.68,153.75 135.99,153.06 130.55,153.06 129.95,152.47 129.95,149.34 130.71,148.59 131.44,148.59 133.89,146.14 133.89,144.11 133.51,143.73 v1(133,143.73)
  BOTTOM w0.203: PU19000.2 129.09,145.59 129.83,144.85 130.44,144.85 131.84,143.44 PR19020.2 132.49,143.44 132.78,143.73 v1(133,143.73)
VCORE_CS_SUM: length 13.6
  IN1 w0.203: v1(123.15,148.66) 123.15,147.36 v1(127.93,142.58)
  BOTTOM w0.203: v1(123.15,148.66) 123.23,148.74 PU19000.18 ; v1(127.93,142.58) 128.1,142.41 PR19013.2 128.94,142.41 129.52,142.99 PR19015.1 PR19018.2 PR19020.1
VCORE_PE: length 321.5
  TOP w0.114: v3(266.29,27.92) 265.21,27.92 264.92,28.2 261.9,28.2 261.15,28.95 260.66,28.95 260.5,28.79 257.97,28.79 257.38,29.38 256.24,29.38 256.24,29.37 253.91,29.37 252.54,28.01 251.75,28.01 249.53,30.22 235.47,30.22 v1(234.55,31.14)
  IN2 w0.127: v1(133.05,155.31) 133.2,155.31 133.43,155.08 138.39,155.08 142.07,158.76 142.07,160.01 142.84,160.78 173.99,160.78 176.01,158.76 182.23,158.76 183.57,157.42 186.21,157.42 188.86,154.78 188.86,151.42 189.14,151.14 189.14,150.55 188.68,150.09 188.68,148.06 189.44,147.29 189.44,133.11 190.07,132.48 190.07,128.82 191.6,127.29 191.6,122.84 191,122.24 190.52,122.24 189.29,121.01 189.29,102.23 187.29,100.23 187.29,98.87 184.53,96.11 182.68,96.11 182.42,95.84 181.74,95.84 179.18,93.28 179.18,89.36 181.09,87.45 181.09,69.63 185.08,65.64 185.08,48.81 183.83,47.56 183.83,34.86 v1(184.44,34.25) ; v1(234.55,31.14) 233.33,31.14 231.02,28.82 222.01,28.82 217.41,24.22 214.87,24.22 214.12,23.47 206.18,23.47 205.82,23.1 201.23,23.1 200.24,24.09 190.73,24.09 189.21,22.58 180.68,22.58 180.14,22.04 178.04,22.04 177.89,22.19 173.26,22.19 172.75,22.7 v1(171.86,22.7)
  IN4 w0.127: v1(171.86,22.7) 171.23,23.33 171.23,24.45 176,29.22 179.81,29.22 181.87,31.28 183.47,31.28 184,31.81 184.54,31.81 185.17,32.44 185.17,33.52 v1(184.44,34.25)
  BOTTOM w0.114: v1(133.05,155.31) 134.47,153.89 135.39,153.89 135.68,153.6 PR19057.1 ; U6001.G3 v3(266.29,27.92)
VCORE_PWM1: length 20
  TOP w0.254: v1(144.56,159.73) PR20001.1
  IN1 w0.203: v1(144.56,159.73) 143.29,158.46 142.09,158.46 134.53,150.89 134.53,150.89 134.53,150.53 134.53,150.53 134.53,149.87 v1(134.09,149.44)
  BOTTOM w0.203: PU19000.43 132.04,148.74 132.75,149.44 v1(134.09,149.44)
VCORE_PWM2: length 29.5
  TOP w0.254: PR20016.1 v1(152.05,159.73)
  IN1 w0.203: v1(134.09,150.08) 133.57,150.6 133.57,151.94 134.14,152.52 135.74,152.52 141.84,158.61 141.84,159.55 142.45,160.16 151.62,160.16 v1(152.05,159.73)
  BOTTOM w0.203: v1(134.09,150.08) 132.93,150.08 131.99,149.13 PU19000.42
VCORE_PWM3: length 36.1
  TOP w0.254: v1(159.93,159.73) PR20031.1
  IN1 w0.203: v1(159.93,159.73) 159.21,160.44 142.33,160.44 141.48,159.59 141.48,158.76 135.62,152.9 133.99,152.9 133.1,152.01 133.1,150.97 v1(131.83,149.7)
  BOTTOM w0.203: v1(131.83,149.7) 131.67,149.53 PU19000.41
VCORE_PWM4: length 45.2
  TOP w0.254: PR20045.1 v1(168.05,159.73)
  IN1 w0.203: v1(168.05,159.73) 167.06,160.72 140.64,160.72 139.91,159.99 139.91,157.75 135.36,153.2 133.74,153.2 132.82,152.29 132.82,151.37 v1(131.83,150.38)
  BOTTOM w0.203: PU19000.40 131.38,149.93 v1(131.83,150.38)

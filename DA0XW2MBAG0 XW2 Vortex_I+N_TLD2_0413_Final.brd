# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBTB_CA2HD_1_RX_P: length 23.9
  TOP w0.102: C8032.1 346.16,125.35 arc(346.18,125.37) 346.19,125.39 arc(346.2,125.4) 346.2,125.41 arc(346.21,125.42) 346.21,125.43 arc(346.21,125.43) 346.21,125.43 arc(346.22,125.45) 346.23,125.47 arc(346.23,125.5) 346.23,125.53 arc(346.25,125.63) 346.31,125.72 346.4,125.81 arc(346.57,125.92) 346.76,125.96 355.87,125.96 arc(356.14,125.91) 356.37,125.75 357.56,124.56 arc(357.71,124.33) 357.77,124.06 v6(357.77,120.16) 357.77,118.39 arc(357.79,118.27) 357.86,118.17 357.92,118.1 arc(358.01,118.04) 358.11,118.02 358.24,118.02 arc(358.38,118.05) 358.49,118.13 D7126.2 358.92,118.13 arc(359.06,118.03) 359.23,118 359.3,118 arc(359.45,118.03) 359.58,118.11 R17934.1 359.87,118.06 arc(360.02,117.96) 360.2,117.92 360.27,117.92 arc(360.47,117.88) 360.63,117.77 360.85,117.55 arc(360.95,117.49) 361.07,117.46 361.19,117.46 arc(361.25,117.47) 361.31,117.49 arc(361.4,117.55) 361.51,117.57 CON7101.A11
TBTB_CA2HD_2_RX_N: length 33.1
  TOP w0.102: v3(362.88,113.54) 362.91,113.57 CON7101.B10
  BOTTOM w0.102: v3(362.88,113.54) 362.71,113.37 362.54,113.37 arc(362.34,113.33) 362.18,113.22 361.57,112.61 arc(361.47,112.55) 361.35,112.52 360.66,112.52 arc(360.46,112.56) 360.3,112.67 R17937.1 359.97,112.79 arc(359.8,112.68) 359.61,112.64 359.39,112.64 arc(359.19,112.68) 359.03,112.79 D7127.2 358.69,112.89 arc(358.52,112.78) 358.33,112.74 357.75,112.74 arc(357.55,112.78) 357.39,112.89 357.18,113.1 arc(357.07,113.26) 357.03,113.46 357.03,126.12 arc(356.99,126.31) 356.88,126.48 v6(356.32,127.04) 355.91,127.45 arc(355.74,127.56) 355.55,127.6 352.79,127.6 arc(352.6,127.56) 352.44,127.45 350.24,125.26 arc(350.08,125.15) 349.88,125.11 347.22,125.11 arc(347.08,125.08) 346.95,125 arc(346.87,124.88) 346.84,124.73 346.84,124.54 346.79,124.49 arc(346.7,124.43) C8043.1
TBTB_CA2HD_2_RX_P: length 33.1
  TOP w0.102: v3(362.88,113.01) 362.94,113.07 CON7101.B11
  BOTTOM w0.102: v3(362.88,113.01) 362.78,113.11 arc(362.71,113.15) 362.63,113.17 362.54,113.17 arc(362.42,113.15) 362.32,113.08 361.71,112.47 arc(361.55,112.36) 361.35,112.32 360.36,112.32 arc(360.21,112.29) R17936.1 arc(360.01,112.37) 359.84,112.44 359.36,112.44 arc(359.07,112.38) 358.83,112.21 D7129.2 358.81,112.41 arc(358.77,112.5) 358.68,112.54 357.75,112.54 arc(357.48,112.59) 357.24,112.75 357.03,112.96 arc(356.88,113.19) 356.83,113.46 356.83,126.12 arc(356.8,126.24) 356.74,126.33 355.76,127.31 arc(355.67,127.37) 355.55,127.4 v6(354.69,127.4) 352.79,127.4 arc(352.68,127.37) 352.58,127.31 350.39,125.11 arc(350.16,124.96) 349.88,124.91 347.22,124.91 arc(347.15,124.89) 347.1,124.86 arc(347.06,124.8) 347.05,124.73 347.05,124.73 arc(347.14,124.5) 347.37,124.41 C8041.1
TBTB_CC1: length 55.7
  TOP w0.381: v3(341.71,93.46) 341.56,93.31 341.13,93.31 339.25,91.43 v1(339.25,91.23)
  IN2 w0.686: v1(359.95,110.07) 360.24,109.86 364.74,109.86 365.16,110.28 365.16,111.06 363.63,112.59 363.63,115.03 364.37,115.76 v1(364.67,115.76) ; v1(359.95,111.09) 359.22,111.09 358.69,110.56 358.69,109.66 356.71,107.68 356.71,103.45 355.06,101.8 355.06,99.7 354.35,98.99 354.35,96.56 352.66,94.88 352.66,90.85 351.2,89.38 347.95,89.38 347.74,89.17 341.57,89.17 339.52,91.23 v1(339.25,91.23)
  BOTTOM w0.254: U8500.K9 341.71,93.37 v3(341.71,93.46)
  BOTTOM w0.508: C8508.2 339.07,91.4 v1(339.25,91.23)
TBTB_CC2: length 45.5
  TOP w0.381: v1(339.25,92.22) 339.25,92.39 340.46,93.6 v1(340.51,93.6) 340.72,93.82 v3(341.33,93.82)
  IN2 w0.686: 359.82,115.15 359.32,115.15 358.93,114.77 358.93,113.12 358.6,112.79 358.6,111.57 358.18,111.14 v1(357.92,111.14) ; v1(357.92,110.33) 357.92,109.98 355.94,108 355.94,103.77 354.29,102.12 354.29,100.02 353.57,99.31 353.57,96.89 351.89,95.2 351.89,91.21 350.83,90.16 347.63,90.16 347.42,89.94 341.9,89.94 339.62,92.22 v1(339.25,92.22)
  BOTTOM w0.254: v3(341.33,93.82) 341.26,93.75 341.26,93.42 U8500.K10
  BOTTOM w0.508: v1(339.25,92.22) 339.05,92.42 C8511.2
  vias: v1(360.08,114.82) v1(360.71,114.85)
TBTB_DPSRC_AUX_N: length 33.7
  TOP w0.102: R8681.1 338.45,95.85 339.08,96.48 v1(339.17,96.48) 339.17,96.61 339.33,96.76 339.52,96.76 340.37,95.92 340.37,95.77 340.29,95.69 R8573.2 ; v3(352.58,114.42) 352.4,114.42 C8047.1
  IN4 w0.076: v3(352.58,114.42) 352.42,114.58 352.22,114.58 350.61,112.97 350.61,107.97 350.22,107.58 347.97,107.58 346.78,106.39 343.06,106.39 341.41,104.74 341.41,98.01 340.13,96.73 339.41,96.73 v1(339.17,96.48)
  BOTTOM w0.102: U8500.E11 340.43,95.77 340.38,95.82 340.13,95.82 339.37,96.59 339.27,96.59 v1(339.17,96.48)
TBTB_DPSRC_AUX_P: length 33.6
  TOP w0.102: v3(352.58,114.95) 352.3,114.67 352.17,114.67 C8046.1 ; R8683.1 338.47,96.71 338.77,96.71 v1(339.17,97.12) 339.33,96.97 339.6,96.97 340.57,96 340.57,95.9 R8572.2
  IN4 w0.076: v3(352.58,114.95) 352.38,114.75 352.15,114.75 350.45,113.04 350.45,108.04 350.15,107.75 347.9,107.75 346.71,106.56 342.99,106.56 341.24,104.81 341.24,98.08 340.06,96.89 339.4,96.89 v1(339.17,97.12)
  BOTTOM w0.102: v1(339.17,97.12) 339.17,97.03 340.2,96 340.35,96 U8500.D11
TBTB_HD2CA_1_TX_N: length 31
  TOP w0.102: v3(362.87,117.11) 362.91,117.07 CON7101.B3
  BOTTOM w0.102: C8038.1 345.65,124.29 arc(345.42,124.39) 345.32,124.63 345.32,125.13 arc(345.35,125.3) 345.45,125.44 arc(345.76,125.65) 346.12,125.72 349.61,125.72 arc(349.81,125.76) 349.97,125.88 350.44,126.34 v6(351.47,127.37) 352.27,128.18 arc(352.62,128.41) 353.03,128.49 355.68,128.49 arc(355.87,128.45) 356.03,128.34 357.49,126.88 arc(357.6,126.72) 357.64,126.53 357.64,118.31 arc(357.68,118.12) 357.79,117.95 357.91,117.83 arc(358.03,117.75) 358.17,117.72 358.33,117.72 arc(358.52,117.68) 358.69,117.57 D7124.2 358.95,117.43 arc(358.97,117.54) 359.03,117.64 359.05,117.66 arc(359.17,117.74) 359.32,117.77 360.98,117.77 arc(361.1,117.75) 361.2,117.68 361.36,117.52 arc(361.59,117.37) 361.86,117.31 362.67,117.31 v3(362.87,117.11)
TBTB_HD2CA_1_TX_P: length 31
  TOP w0.102: v3(362.87,117.64) 362.94,117.57 CON7101.B2
  BOTTOM w0.102: C8036.1 345.05,124.38 arc(345.1,124.45) 345.12,124.54 345.12,125.13 arc(345.16,125.38) 345.3,125.58 arc(345.68,125.83) 346.12,125.92 349.61,125.92 arc(349.72,125.95) 349.82,126.01 v6(350.29,126.49) 352.13,128.32 arc(352.54,128.59) 353.03,128.69 355.68,128.69 arc(355.95,128.64) 356.18,128.48 357.63,127.03 arc(357.79,126.8) 357.84,126.53 357.84,118.31 arc(357.87,118.19) 357.93,118.09 358.05,117.97 arc(358.11,117.93) 358.17,117.92 358.33,117.92 arc(358.34,117.92) 358.34,117.92 arc(358.53,117.96) 358.69,118.07 D7122.2 358.95,118.3 arc(358.97,118.17) 359.04,118.07 arc(359.15,118) 359.27,117.97 360.98,117.97 arc(361.18,117.93) 361.34,117.82 361.5,117.66 arc(361.67,117.55) 361.86,117.52 362.74,117.52 v3(362.87,117.64)
TBTB_HD2CA_2_TX_N: length 25.8
  TOP w0.102: CON7101.A3 361.43,113.57 arc(361.35,113.55) 361.29,113.51 arc(361.22,113.47) 361.14,113.45 360.74,113.45 arc(360.55,113.41) 360.39,113.3 359.84,112.76 arc(359.78,112.71) 359.71,112.66 arc(359.6,112.63) 359.49,112.61 359.26,112.61 arc(359.06,112.65) 358.9,112.76 D7131.2 358.59,112.69 arc(358.42,112.58) 358.23,112.54 357.82,112.54 arc(357.63,112.58) 357.46,112.69 357.1,113.05 arc(356.99,113.21) 356.95,113.41 356.95,113.41 v6(356.95,117.72) 356.95,123.6 arc(356.9,123.88) 356.74,124.11 355.91,124.94 arc(355.68,125.09) 355.41,125.15 349.36,125.15 arc(349.2,125.12) 349.06,125.02 348.95,124.91 arc(348.89,124.87) 348.82,124.86 348.65,124.86 arc(348.57,124.88) 348.51,124.92 arc(348.46,124.99) 348.44,125.08 C8045.1
TBTB_HD2CA_2_TX_P: length 25.8
  TOP w0.102: C8044.1 348.59,124.55 348.62,124.58 arc(348.7,124.63) 348.8,124.65 348.82,124.65 arc(348.97,124.68) 349.09,124.76 349.16,124.83 349.21,124.88 arc(349.28,124.93) 349.36,124.94 355.41,124.94 arc(355.6,124.91) 355.77,124.8 356.6,123.96 arc(356.71,123.8) 356.75,123.6 v6(356.75,114.26) 356.75,113.41 arc(356.8,113.14) 356.96,112.9 357.32,112.54 arc(357.55,112.39) 357.82,112.33 358.2,112.33 arc(358.4,112.29) 358.56,112.18 D7133.2 359.08,112.26 arc(359.24,112.37) 359.44,112.41 359.54,112.41 arc(359.67,112.43) 359.8,112.48 arc(359.9,112.54) 359.99,112.62 360.53,113.16 arc(360.63,113.22) 360.74,113.25 361.09,113.25 arc(361.21,113.22) 361.31,113.16 arc(361.41,113.09) 361.52,113.07 CON7101.A2
TBTB_HPD: length 32.4
  IN4 w0.076: v3(351.47,112.13) 351.47,111.75 352.03,111.19 352.03,107.6 350.94,106.51 349.24,106.51 348.52,105.79 345.03,105.79 344.08,104.84 344.08,103.6 342.42,101.94 342.42,98.2 339.44,95.21 v1(339.12,95.21)
  BOTTOM w0.076: U8001.T1 350.48,112.41 350.55,112.49 351.11,112.49 v3(351.47,112.13) ; 339.18,95.27 339.25,95.34 340.69,95.34 U8500.E10
  BOTTOM w0.114: 339.18,95.27 v1(339.12,95.21) 338.72,95.21 R8556.1 337.73,95.33 337.73,96.04 R8511.2
TBTB_I2C_INT#: length 31.2
  TOP w0.114: v3(348.73,113.93) 348.81,113.93 349.61,113.12 350.17,113.12 350.63,112.66 351.64,112.66 351.95,112.36 352.13,112.36 v1(352.38,112.1) 352.41,112.08 R8009.2
  IN3 w0.089: v3(344.48,94.62) 345.12,95.26 345.12,96.21 346.77,97.86 346.77,98.73 349.21,101.16 350.33,101.16 350.66,101.49 350.66,105.48 351.4,106.22 351.4,108.36 350.6,109.16 350.6,113.45 349.79,114.26 349.04,114.26 348.73,113.95 v3(348.73,113.93)
  BOTTOM w0.076: U8500.G2 344.91,94.61 344.49,94.61 v3(344.48,94.62)
  BOTTOM w0.114: U8001.M5 v3(348.73,113.93)
TBTB_RX1_N: length 3.2
  TOP w0.102: C8034.2 346.73,124.31 arc(346.64,124.3) 346.56,124.25 346.55,124.23 arc(346.52,124.19) 346.51,124.14 346.51,124.02 arc(346.47,123.83) 346.36,123.67 346.05,123.35 arc(345.89,123.24) 345.69,123.2 345,123.2 arc(344.92,123.19) 344.85,123.14 arc(344.82,123.1) 344.81,123.05 arc(344.9,122.88) R8057.1
TBTB_RX1_P: length 3.2
  TOP w0.102: C8032.2 346.13,124.31 arc(346.19,124.3) 346.23,124.27 346.27,124.23 arc(346.3,124.19) 346.31,124.14 346.31,124.02 arc(346.29,123.91) 346.22,123.81 345.91,123.5 arc(345.81,123.43) 345.69,123.41 345,123.41 arc(344.84,123.38) 344.7,123.28 arc(344.63,123.18) 344.61,123.05 arc(344.52,122.88) R8056.1
TBTB_RX1N_R: length 4
  TOP w0.102: v3(344.75,121.66) 344.75,122.02 arc(344.77,122.12) 344.83,122.2 345.01,122.39 arc(345.05,122.41) R8057.2
  BOTTOM w0.076: U8001.B13 344.88,119.03 arc(344.9,119.07) 344.91,119.12 344.91,119.52 344.63,119.8 344.63,121.36 arc(344.66,121.52) v3(344.75,121.66)
TBTB_RX1P_R: length 4
  TOP w0.102: v3(344.23,121.66) 344.47,121.9 arc(344.53,121.98) 344.55,122.08 344.55,122.1 arc(344.53,122.19) 344.47,122.28 R8056.2
  BOTTOM w0.076: v3(344.23,121.66) 344.28,121.6 arc(344.43,121.38) 344.48,121.12 344.48,119.2 arc(344.51,119.12) 344.59,119.09 arc(344.67,119.12) 344.7,119.2 U8001.A13
TBTB_RX2_N: length 1.1
  BOTTOM w0.102: C8043.2 346.86,123.36 arc(346.92,123.26) 346.95,123.15 346.95,123.15 arc(346.86,122.95) R8061.1
TBTB_RX2_P: length 1.1
  BOTTOM w0.102: C8041.2 347.17,123.25 arc(347.15,123.22) 347.15,123.19 347.15,123.15 arc(347.23,122.95) R8060.1
TBTB_RX2N_R: length 4.3
  BOTTOM w0.076: U8001.A7 347.46,119.2 arc(347.35,119.09) 347.24,119.2 347.24,119.81 347.24,119.81 347.24,119.97 arc(347.27,120.15) 347.38,120.31 347.47,120.4 arc(347.49,120.44) 347.5,120.49 347.5,121.65 arc(347.48,121.75) 347.43,121.83 347.27,121.99 arc(347.25,122.01) 347.22,122.01 347.22,122.01 arc(347.04,122.09) 346.97,122.26 346.97,122.34 arc(346.95,122.4) 346.89,122.42 R8061.2
TBTB_RX2P_R: length 4.4
  BOTTOM w0.076: U8001.B7 347.64,119.04 arc(347.67,119.08) 347.68,119.13 347.68,119.44 arc(347.67,119.49) 347.64,119.53 347.39,119.79 347.39,119.95 347.39,119.97 arc(347.42,120.1) 347.49,120.21 347.58,120.29 arc(347.64,120.38) 347.66,120.49 347.66,121.65 arc(347.63,121.81) 347.54,121.94 347.38,122.1 arc(347.31,122.15) 347.22,122.16 arc(347.15,122.19) 347.12,122.26 arc(347.14,122.33) 347.17,122.38 347.18,122.39 arc(347.24,122.41) 347.31,122.42 R8060.2
TBTB_SBU1: length 29.4
  TOP w0.114: v1(346.74,96.48) 346.84,96.59 347,96.59 347.38,96.59 v1(347.38,96.59)
  IN3 w0.089: v1(347.38,96.59) 347.61,96.59 351.02,100 351.02,104.82 352.51,106.31 352.51,110.16 355.31,112.96 359.35,112.96 v1(360.71,111.6)
  BOTTOM w0.114: v1(347.38,96.59) 347.57,96.59 347.77,96.79 R8531.1 ; v1(360.71,111.6) 360.71,111.09 360.95,110.85 D7130.2 361.09,110.45 361.32,110.23 R7178.2
TBTB_SBU1_L: length 12.2
  TOP w0.114: v1(364.67,114.98) 364.27,114.57 CON7101.B8
  IN4 w0.089: v1(364.67,114.98) 363.94,114.24 363.94,112.38 365.03,111.29 365.03,110.48 364.34,109.79 363.15,109.79 v1(361.35,111.6)
  BOTTOM w0.114: v1(361.35,111.6) 361.73,111.22 R7178.1
TBTB_SBU1_R: length 2.6
  BOTTOM w0.076: R8531.2 346.36,96.59 346.36,96 345.95,95.59 U8500.E1
TBTB_SBU2: length 31.5
  TOP w0.114: v1(360.42,115.98) 360.38,115.94 R7177.2 ; v1(347.63,95.34) 348.06,95.77 v1(348.11,95.77)
  IN3 w0.089: v1(347.63,95.34) 346.99,95.98 346.99,96.75 347.23,96.99 347.76,96.99 350.84,100.07 350.84,104.9 351.9,105.96 351.9,109.81 355.23,113.14 358.34,113.14 358.58,113.39 358.58,114.55 360.02,115.98 v1(360.42,115.98)
  BOTTOM w0.114: v1(360.42,115.98) 360.36,115.93 D7132.2 ; v1(347.63,95.34) 347.77,95.48 R8532.1
TBTB_SBU2_L: length 2.4
  TOP w0.114: CON7101.A8 361.52,116.07 361.4,116.2 360.79,116.2 360.59,116.4 359.7,116.4 R7177.1
TBTB_SBU2_R: length 1.9
  BOTTOM w0.076: R8532.2 346.62,95.98 345.73,95.09 U8500.F1
TBTB_TX1_N: length 0.9
  BOTTOM w0.102: C8038.2 345.48,123.6 arc(345.46,123.56) 345.45,123.51 arc(345.46,123.44) 345.5,123.37 R8059.1
TBTB_TX1_P: length 0.9
  BOTTOM w0.102: R8058.1 345.19,123.37 arc(345.23,123.44) 345.24,123.51 arc(345.23,123.56) 345.21,123.6 C8036.2
TBTB_TX1N_R: length 4.3
  BOTTOM w0.076: U8001.B11 345.82,119.05 arc(345.84,119.09) 345.85,119.14 345.85,119.39 arc(345.84,119.44) 345.82,119.48 345.59,119.71 arc(345.56,119.75) 345.55,119.8 345.55,120.57 arc(345.56,120.6) 345.57,120.63 345.7,120.75 arc(345.76,120.84) 345.78,120.95 345.78,121.76 arc(345.74,121.92) 345.65,122.06 arc(345.54,122.23) 345.5,122.43 345.5,122.47 arc(345.56,122.63) R8059.2
TBTB_TX1P_R: length 4.3
  BOTTOM w0.076: U8001.A11 345.62,119.2 arc(345.59,119.12) 345.51,119.09 arc(345.43,119.12) 345.4,119.2 345.4,120.61 arc(345.41,120.66) 345.44,120.7 345.59,120.86 arc(345.61,120.9) 345.62,120.95 345.62,121.75 arc(345.6,121.86) 345.54,121.95 arc(345.4,122.17) 345.35,122.43 345.35,122.47 345.22,122.6 arc(345.1,122.67) R8058.2
TBTB_TX2_N: length 3.3
  TOP w0.102: R8063.1 346.21,122.87 arc(346.32,122.92) 346.36,123.03 arc(346.39,123.18) 346.47,123.3 346.62,123.44 arc(346.8,123.57) 347.01,123.61 347.21,123.81 arc(347.28,123.91) 347.3,124.02 347.3,124.39 arc(347.34,124.59) 347.45,124.75 347.6,124.9 arc(347.66,124.94) 347.73,124.96 arc(347.81,124.97) 347.87,125.01 C8045.2
TBTB_TX2_P: length 3.2
  TOP w0.102: C8044.2 347.99,124.62 arc(347.98,124.67) 347.95,124.71 347.95,124.72 arc(347.91,124.75) 347.86,124.76 347.81,124.76 347.81,124.75 arc(347.78,124.75) 347.74,124.75 347.59,124.61 arc(347.53,124.51) 347.5,124.39 347.5,124.02 arc(347.47,123.83) 347.36,123.67 347.15,123.46 arc(347.09,123.42) 347.02,123.41 arc(346.88,123.38) 346.76,123.3 346.62,123.16 arc(346.58,123.1) 346.56,123.03 arc(346.58,122.97) 346.61,122.92 arc(346.66,122.88) 346.72,122.87 R8062.1
TBTB_TX2N_R: length 3.9
  TOP w0.102: R8063.2 346.31,122.22 arc(346.37,122.13) 346.39,122.04 346.39,121.96 arc(346.37,121.86) 346.31,121.78 v3(346.12,121.58)
  BOTTOM w0.076: U8001.B9 346.36,119.03 arc(346.33,119.07) 346.32,119.12 346.32,121.32 arc(346.31,121.37) 346.28,121.41 v3(346.12,121.58)
TBTB_TX2P_R: length 4
  TOP w0.102: R8062.2 346.66,122.22 arc(346.61,122.13) 346.59,122.04 346.59,121.72 arc(346.61,121.64) v3(346.65,121.58)
  BOTTOM w0.076: v3(346.65,121.58) 346.51,121.44 arc(346.48,121.4) 346.47,121.35 v5(346.47,120.74) 346.47,119.79 arc(346.48,119.75) 346.51,119.71 346.7,119.51 arc(346.73,119.47) 346.74,119.42 346.74,119.19 arc(346.71,119.12) 346.64,119.09 arc(346.57,119.12) 346.54,119.19 U8001.A9
TBTB_VBUS_L: length 56.6
  TOP w0.254: v3(360.69,116.75) 360.86,116.58 v3(361.19,116.58) 361.2,116.57 CON7101.A9 362.87,116.57 v3(362.87,116.58) 362.88,116.57 CON7101.B4 ; v3(360.41,114.19) 360.46,114.14 v3(360.96,114.14) 361.03,114.07 CON7101.A4 362.84,114.07 v3(362.87,114.04) 362.91,114.07 CON7101.B9
  IN3 w0.508: v1(344.62,91.77) 344.62,92.46 345.85,93.69 347.38,93.69 348.23,94.54 348.23,95.88 351.82,99.48 351.82,102.37 353.22,103.76 353.22,109.82 355.97,112.57 357.19,112.57 v1(357.92,111.85)
  IN4 w0.508: v1(333.66,135.6) 335.52,133.75 342.17,133.75 v1(342.93,132.98) ; v3(360.41,114.19) 360.41,113.71 358.55,111.85 v1(357.92,111.85)
  BOTTOM w0.254: U8500.L3 344.43,91.97 v1(344.62,91.77)
  BOTTOM w0.508: v1(360.71,119.04) 360.04,119.72 R7100.2 ; PR10003.2 334.16,135.1 v1(333.66,135.6) PR10001.2 334.16,136.35 334.3,136.49 PQ10003.1 333.46,137.5 333.37,137.6 PC25009.2 PR26015.2
  vias: v1(343.57,132.98) v1(343.9,133.85) v1(344.2,133.19) v1(344.33,132.55) v1(344.68,133.77) v1(345.14,134.56) v1(353.4,123.41) v1(353.4,122.77) v1(353.4,122.14) v1(364.95,117.08) v3(364.52,113.32) v3(364.55,116.65) v3(365.06,113.32)
THER_ALERT#: length 7
  BOTTOM w0.114: R2095.2 218.8,93.21 218.8,97.16 219.16,97.52 219.16,98.92 U2000.M2
THERM#: length 321
  IN2 w0.089: v1(173.01,25.49) 172.17,24.65 170.07,24.65 169.93,24.52 153.16,24.52 153.04,24.4 106.29,24.4 104.2,26.49 104.2,29.06 102.39,30.87 102.39,40.6 95.97,47.02 95.97,49.06 93.64,51.4 90.84,51.4 90.26,51.98 90.26,51.98 88.52,53.72 86.99,53.72 86.2,54.52 77.91,54.52 76.18,52.79 69.76,52.79 68.28,54.27 59.8,54.27 59.47,53.94 52.28,53.94 51.26,54.95 42.63,54.95 40.78,53.11 37.57,53.11 34.4,56.27 34.4,67.22 31.83,69.79 31.83,75.68 21.75,85.76 21.75,89.75 21.19,90.31 21.19,97.3 v1(19.21,99.28)
  IN4 w0.076: v1(188.85,96.08) 188.65,96.08 188.25,95.67 188.25,88.23 187.23,87.21 187.23,81.78 185.53,80.08 185.53,50.24 185.64,50.13 185.64,32.66 184.62,31.63 184.07,31.63 183.54,31.1 181.94,31.1 179.79,28.95 176.18,28.95 173.01,25.77 v1(173.01,25.49)
  BOTTOM w0.114: v1(19.21,99.28) 19.21,98.76 R6301.2 ; v1(188.85,96.08) 188.66,95.89 188.49,95.89 188.09,95.49 186.18,95.49 185.24,96.43 184,96.43 182.45,97.98 179.45,97.98 178.82,97.36 178.82,96 174.3,91.48 171.81,91.48 170.47,90.14 R6401.2 170.85,89.72 171.06,89.93 U6401.4
THERM_SCI#: length 378.3
  IN2 w0.089: v1(324.78,48.44) 325.06,48.72 325.06,49.02 325.61,49.57 325.61,50.47 324.27,51.81 324.27,53.57 323.66,54.18 322.98,54.18 322.68,54.48 321.86,54.48 317.79,58.56 317.79,59.47 316.64,60.62 316.09,60.62 315.8,60.9 315.8,64.68 315.37,65.11 315.37,70.83 317.76,73.22 318.57,73.22 322.08,76.72 v1(322.08,77.69) ; v1(181.39,96.87) 181.39,97.09 181.85,97.55 182.89,97.55 183.34,97.09 184.11,97.09 184.99,97.98 184.99,98.65 186.46,100.12 186.46,103.92 187.78,105.24 187.78,123.91 v1(189.03,125.16) ; v1(176.03,19.39) 176.49,19.85 177.78,19.85 178.01,19.62 178.01,19.22 178.11,19.12 180.39,19.12 181.73,20.45 191.18,20.45 191.83,21.1 198.93,21.1 199.12,20.91 205.4,20.91 205.88,20.43 214.41,20.43 215.91,21.93 218.28,21.93 223.05,26.7 232.06,26.7 234.19,28.82 236.54,28.82 237.85,30.13 244.71,30.13 247.1,32.52 247.1,33.06 246.92,33.24 246.92,34.1 247.2,34.38 248.34,34.38 250.11,36.15 250.11,36.55 253.5,39.94 253.74,39.94 255.68,39.94 257.12,41.37 257.12,43.86 261.47,48.21 261.47,51.78 265,55.31 v1(265.65,55.31)
  IN4 w0.076: v1(265.65,55.31) 265.79,55.17 271.29,55.17 272.24,54.22 276.25,54.22 277.61,52.87 277.94,52.87 278.13,52.68 279.62,52.68 279.99,52.31 280.39,52.31 287.41,52.31 288.2,51.53 290.55,51.53 291.59,50.48 292.67,50.48 292.87,50.28 293.68,50.28 295.31,51.91 298.94,51.91 299.42,51.42 301.66,51.42 302.13,50.95 305.64,50.95 307.13,49.46 307.13,49.32 307.44,49.01 308.59,49.01 309.43,49.85 317.13,49.85 317.58,49.39 319.21,49.39 319.51,49.09 319.51,48.3 319.28,48.07 319.28,46.14 319.06,45.91 319.06,45.18 319.57,44.67 323.15,44.67 324.78,46.31 v1(324.78,48.44) ; v1(192.44,94.07) 192.84,93.66 192.84,88.56 190.51,86.23 190.51,79.24 188.73,77.46 188.73,69.69 188.06,69.02 188.06,62.09 189.8,60.34 189.8,44.77 189.05,44.01 189.05,30.89 185.05,26.89 182.48,26.89 181.63,26.04 178.67,26.04 177.52,24.88 177.52,22.55 176.03,21.06 v1(176.03,19.39)
  BOTTOM w0.114: v1(181.39,96.87) 181.39,96.39 178.38,93.38 178.38,89.67 177.99,89.28 U6401.6 176.22,89.28 176.05,89.11 176.05,87.34 176.4,86.99 185.94,86.99 186.47,87.52 189.95,87.52 192.18,89.75 192.18,91.91 192.89,92.62 192.89,93.61 v1(192.44,94.07) ; v1(189.03,125.16) 187.61,126.58 R9033.2 ; v1(322.08,77.69) 322.23,77.54 R6300.2
THERM_SCL: length 15
  BOTTOM w0.114: Q6402.1 190.67,89.12 R6406.2 189.55,88 186.11,88 185.57,87.46 180,87.46 179.6,87.86 v1(178.59,87.86) 178.47,87.98 U6401.8
THERM_SDA: length 15.6
  BOTTOM w0.114: Q6402.4 188.43,91.59 R6405.2 187.61,90.78 187.61,90.16 186.45,89.01 185.38,87.93 180.87,87.93 v1(178.92,89.88) 178.92,89.63 177.93,88.63 U6401.7
THERM_SHDWN_R: length 5.5
  TOP w0.114: R2132.2 224.44,80.49 R2133.2 R2137.1 226.09,80.86 v1(225.58,81.37) 225.58,81.7 225.3,81.98 225.3,82.54 225.66,82.89 U2008.2
THERMDA_1: length 79.5
  TOP w0.114: Q6401.3 189.01,44.29 190.02,45.3 190.02,45.69 189.31,46.41 189.31,47.42 C6402.1 188.25,48.48 188.14,48.48 v1(187.48,49.14)
  IN4 w0.076: v1(187.48,49.14) 186.19,50.43 186.19,78.4 187.2,79.42 187.88,79.42 188.53,80.06 188.53,87.05 189.64,88.17 189.64,95.32 v1(189.41,95.55)
  BOTTOM w0.114: U6401.2 173.38,88.63 173.92,89.17 173.92,90.45 179.28,95.81 179.28,97.17 179.64,97.53 182.26,97.53 183.81,95.98 185.05,95.98 186.09,94.93 188.8,94.93 v1(189.41,95.55)
THERMDC_1: length 75.7
  TOP w0.114: v1(187.48,48.5) 187.59,48.5 188.17,47.92 188.17,47.79 C6402.2 188.75,46.83 187.99,46.06 187.99,45.56
  IN4 w0.076: v1(188.67,95.47) 189.4,94.73 189.4,88.14 188.37,87.11 188.37,80.12 187.82,79.57 187.14,79.57 186.04,78.46 186.04,49.95 v1(187.48,48.5)
  BOTTOM w0.114: v1(188.67,95.47) 188.46,95.26 186.08,95.26 185.14,96.2 183.9,96.2 182.35,97.75 179.54,97.75 179.05,97.26 179.05,95.9 173.69,90.54 173.69,89.55 173.42,89.28 U6401.3
THERMDN: length 5.6
  TOP w0.114: v1(220.05,100.49) 220.05,99.99 221.27,98.77 TP2011.1
  BOTTOM w0.102: U2000.K4 220.05,100.52 v1(220.05,100.49)
THERMDP: length 6.5
  BOTTOM w0.102: U2000.K3 220,99.67 220,99.25 220.13,99.12 220.13,98.48 220.94,97.67 220.94,97.19
  BOTTOM w0.114: 220.94,97.19 220.94,96.92 220.12,96.1 TP2006.1
THRMTRIP#: length 21.5
  TOP w0.114: R9019.1 168.82,136.86 168.82,136.87 Q9000.1 170.85,136.87 171.61,136.11 171.61,130.77 170.59,129.76 170.59,128.51 v1(171.15,127.95)
  IN1 w0.076: v1(174.14,122.01) 173.86,121.72 172.5,121.72 171.43,122.79 171.43,127.68 v1(171.15,127.95)
  BOTTOM w0.127: U9001.J31 174.39,122.26 v1(174.14,122.01)
TLS_ENCRYPTION: length 11.5
  BOTTOM w0.102: v1(261.55,78.91) 261.37,78.91 260.94,78.48 260.94,78.01 260.46,77.52 260.45,77.52 259.65,76.72 259.65,76.59 259.15,76.09 259.15,75.83 258.8,75.49 U9002.BE25
  BOTTOM w0.114: v1(261.55,78.91) 261.78,79.14 261.78,79.97 R9138.2 262.01,80.84 263.3,82.13 263.3,82.51 263.55,82.76 263.55,83.28 263.2,83.64 R9135.1
TOUCH_INT#: length 316.7
  IN2 w0.089: v1(254.64,73.12) 254.87,73.34 255.64,73.34 255.74,73.24 256.19,73.24 257.33,74.39 259.89,74.39 263.82,70.45 264.01,70.45 266.77,67.68 266.77,66.46 266.12,65.81 266.12,65.36 265.09,64.34 265.09,59.79 255.18,49.87 255.18,45.3 254.79,44.92 254.79,43.91 253.08,42.19 253.08,41.71 251.58,40.2 250.41,40.2 249.84,39.63 249.84,38.94 249.47,38.57 249.16,38.26 248.75,38.26 246.2,35.71 245.34,35.71 244.58,34.95 244.58,32.54 243.33,31.29 237.37,31.29 236.06,29.98 233.71,29.98 231.58,27.85 222.57,27.85 217.8,23.08 215.43,23.08 214.84,22.49 206.58,22.49 206.15,22.06 199.6,22.06 198.69,22.98 195.79,22.98 195.15,22.33 191.12,22.33 191,22.44 190.58,22.44 189.75,21.6 181.13,21.6 180.53,21.01 164.97,21.01 164.23,20.26 116,20.26 115.13,21.13 105.1,21.13 104.7,21.53 103.22,21.53 101,23.75 101,28.6 99.22,30.38 99.22,38.59 94.49,43.32 94,43.32 93.75,43.57 93.75,46.33 89.52,50.55 83.91,50.55 82.82,51.64 68.58,51.64 67.96,51.02 66.49,51.02 61,45.53 56.46,45.53 55.1,44.16 41.56,44.16 36.9,48.82 36.9,50.13 32.75,54.28 32.75,56.87 v1(32.17,57.45)
  BOTTOM w0.114: U9002.AP21 253.61,72.95 253.78,73.12 v1(254.64,73.12) ; v1(33.55,56.82) R3029.1 32.17,57.37 v1(32.17,57.45) 31.79,57.83 CON3001.8
TOUCH_PWR_EN: length 322.4
  IN2 w0.089: v1(31.66,47.51) 34.65,47.51 38.39,43.78 55.22,43.78 56.61,45.17 61.15,45.17 65.41,49.44 69.43,49.44 70.19,50.2 89.24,50.2 92.68,46.76 92.68,44.13 93.86,42.96 94.3,42.96 98.64,38.62 98.64,24.98 102.85,20.77 102.85,20.23 103.07,20.02 103.58,20.02 104.13,19.46 171.94,19.46 172.68,20.21 180.98,20.21 181.58,20.8 191.03,20.8 191.68,21.45 199.08,21.45 199.27,21.26 205.55,21.26 206.02,20.79 214.27,20.79 215.76,22.28 218.14,22.28 222.91,27.05 231.91,27.05 234.04,29.18 236.4,29.18 237.7,30.49 243.81,30.49 245.9,32.58 245.9,33.09 245.83,33.16 245.83,33.95 246.94,35.07 246.95,35.07 247.63,35.75 248.81,35.75 249.56,36.5 249.56,36.78 253.47,40.69 254.18,40.69 254.36,40.87 255.76,40.87 256.55,41.67 256.55,44.57 257.49,45.51 257.49,46.8 259.44,48.75 259.44,51.62 260.79,52.97 260.79,53.4 260.64,53.55 260.64,53.93 267.24,60.53 267.24,63.46 267.37,63.59 267.88,63.59 268.06,63.78 268.06,64.93 267.31,65.68 267.31,67.91 259.81,75.4 258.73,75.4 255.78,78.35 255.78,80.66 v3(255.81,80.69)
  BOTTOM w0.114: U9002.BE14 254.77,79.39 255.28,79.9 255.29,79.9 255.5,80.11 255.5,80.37 v3(255.81,80.69) 256.24,81.12 256.24,82.2 256.51,82.47 256.51,82.47 256.76,82.71 256.76,85.75 R9231.1 ; v1(31.66,47.51) 31.72,47.58 R3019.2
TOUCH_RST#: length 322.5
  TOP w0.114: R9240.2 256.83,82.64 256.83,81.12 255.58,79.88 255.58,76.39 v1(255.41,76.22)
  IN2 w0.089: v1(255.41,76.22) 256.95,76.22 258.18,74.99 259.97,74.99 267.13,67.83 267.13,66.31 266.48,65.66 266.48,60.68 256.6,50.79 256.6,45.84 255.18,44.41 255.18,43.65 253.91,42.38 253.91,41.87 253.52,41.49 253.14,41.49 251.68,40.03 250.49,40.03 250.02,39.56 250.02,38.87 249.29,38.14 249.23,38.08 248.83,38.08 246.28,35.53 245.42,35.53 244.78,34.89 244.78,32.48 243.41,31.11 237.45,31.11 236.14,29.8 233.78,29.8 231.65,27.68 222.65,27.68 217.88,22.91 215.51,22.91 214.92,22.32 206.66,22.32 206.23,21.88 199.53,21.88 199.33,22.08 191.42,22.08 190.78,21.43 181.2,21.43 180.6,20.83 165.04,20.83 164.3,20.09 105.74,20.09 104.5,21.33 103.17,21.33 100.81,23.69 100.81,28.54 98.94,30.41 98.94,38.62 94.42,43.14 93.93,43.14 93.52,43.55 93.52,46.17 89.32,50.38 68.76,50.38 68.3,50.84 66.56,50.84 61.07,45.35 56.54,45.35 55.17,43.98 41.49,43.98 36.61,48.86 36.61,50.17 32.52,54.25 32.52,55.97 v1(31.11,57.38)
  BOTTOM w0.114: U9002.BB20 255.63,76 v1(255.41,76.22) ; C3041.2 31.65,56.84 v1(31.11,57.38) 30.99,57.5 CON3001.7
TP#AN35: length 14.7
  TOP w0.114: TP9043.1 257.66,59.58 v1(257.97,59.88)
  IN2 w0.089: v1(256.95,67.78) 257.66,67.78 259.72,65.73 260.66,65.73 261.27,65.12 261.27,64.1 261.5,63.87 261.5,62.49 258.9,59.88 v1(257.97,59.88)
  BOTTOM w0.102: U9002.AN35 257.26,67.47 v1(256.95,67.78)
TP_SCAN_DISABLE#: length 217.9
  TOP w0.076: v3(270.19,25.32) 270.33,25.32 270.52,25.13 270.52,24.46 270.39,24.32 270.39,24.22
  TOP w0.114: v1(278.2,17.51) v1(277.43,18.28) 276.74,18.96 273.39,18.96 273.08,19.27 273.08,19.87 272.57,20.38 R6167.2 272.19,20.54 271.05,21.68 271.05,23.23 270.39,23.89 270.39,24.22
  IN2 w0.089: v1(278.2,17.51) 276.77,16.07 276.77,13.58 268.74,5.55 263.27,5.55 262.67,4.96 262.35,4.96 261.88,5.42 251.33,5.42 250.76,4.85 243.78,4.85 242.22,6.42 239.92,6.42 239.05,5.55 236.51,5.55 236.13,5.93 236.13,6.57 234.96,7.73 226.39,7.73 226.16,7.96 210.35,7.96 209.2,9.11 209.2,9.62 205.75,13.07 205.75,14.02 205.28,14.49 204.15,14.49 202.93,15.7 201.57,15.7 201.43,15.57 198.52,15.57 198.38,15.7 183.79,15.7 179.35,11.27 145.03,11.27 141.6,14.69 105.98,14.69 105.32,14.02 105.32,10.5 100.64,5.83 100.64,5.5 100.18,5.04 99.73,5.04 99.09,4.41 v1(98.38,4.41)
  BOTTOM w0.114: R6359.1 98.32,4.35 v1(98.38,4.41) ; U6001.D8 v3(270.19,25.32)
TP_SCAN_DISABLE#_R: length 9.6
  TOP w0.114: v1(99.73,4.15) 99.67,4.09 Q6351.6
  BOTTOM w0.114: CON6351.8 104.98,6.64 105.08,6.54 105.08,5.55 104.75,5.23 104.48,5.23 104.26,5.45 103.09,5.45 102.96,5.32 102.45,5.32 102.44,5.32 102.09,5.32 101.96,5.45 100.62,5.45 99.77,4.6 99.77,4.2 v1(99.73,4.15) 99.27,3.7 R6359.2
TP_SIGNAL1: length 77.9
  TOP w0.114: CON6352.4 81.33,57.67 80.3,56.64 80.3,52.63 82.06,50.86 88.08,50.86 91.71,47.23 91.71,44.36 93.63,42.45 94.02,42.45 98.16,38.3 98.16,18.37 99.45,17.08 101.44,17.08 104.75,13.77 104.75,10 101.97,7.22 100.44,7.22 99.73,6.51 99.73,6.11 v1(99.27,5.65)
  BOTTOM w0.114: v1(99.27,5.65) 99.79,6.18 103.86,6.18 104.48,6.8 CON6351.9
TP_SIGNAL2: length 76.3
  TOP w0.114: CON6352.3 80.33,57.66 79.92,57.24 79.92,52.69 82.22,50.38 v1(85.88,50.38) 88.24,50.38 91.48,47.14 91.48,44.27 93.53,42.22 93.92,42.22 97.93,38.21 97.93,18.27 99.35,16.85 101.35,16.85 104.52,13.68 104.52,10.1 101.87,7.45 100.34,7.45 99.3,6.41 v1(99.3,6.29)
  BOTTOM w0.114: v1(99.3,6.29) 99.52,6.52 102.05,6.52 102.16,6.41 103.66,6.41 103.98,6.73 CON6351.10
TP_SIGNAL3: length 77
  TOP w0.114: v1(98.71,6.03) 98.71,6.31 100.08,7.68 101.78,7.68 104.29,10.19 104.29,13.58 101.26,16.62 99.26,16.62 97.7,18.18 97.7,38.12 93.83,41.99 93.44,41.99 91.25,44.17 91.25,47.05 88.42,49.87 v1(84.61,49.87) 82.4,49.87 79.33,52.95 CON6352.2
  BOTTOM w0.114: v1(98.71,6.03) 98.76,6.09 98.76,6.39 99.14,6.77 102.12,6.77 102.26,6.63 103.24,6.63 103.48,6.88 CON6351.11
TP_SIGNAL4: length 77.2
  TOP w0.114: CON6352.1 78.33,53.49 82.41,49.41 88.42,49.41 91.02,46.81 91.02,44.08 93.34,41.76 93.73,41.76 97.47,38.02 97.47,18.08 99.16,16.39 101.16,16.39 104.06,13.49 104.06,10.29 101.68,7.91 99.98,7.91 98.59,6.52 v1(97.95,6.52)
  BOTTOM w0.114: CON6351.12 102.98,7.08 102.8,6.9 102.32,6.9 102.22,7 98.43,7 v1(97.95,6.52)
TPCLK-1: length 8.7
  TOP w0.114: v1(102.11,4.54) 102.06,4.49 102.06,4 101.79,3.73 C6351.1 R6353.2
  BOTTOM w0.114: CON6351.6 105.98,6.83 105.6,6.45 105.6,5.43 104.94,4.77 104.29,4.77 104.07,4.99 103.61,4.99 103.16,4.54 v1(102.11,4.54)
TPDATA-1: length 10.3
  TOP w0.114: R6354.2 100.77,5.19 100.77,3.88 C6355.1 100.31,4.04 v1(100.31,4.54)
  BOTTOM w0.114: v1(100.31,4.54) 100.31,4.74 100.79,5.22 101.74,5.22 101.88,5.09 102.54,5.09 102.54,5.09 103.05,5.09 103.18,5.22 104.16,5.22 104.38,5 104.85,5 105.37,5.52 105.37,6.6 105.48,6.71 CON6351.7
TPEV_PEG_VIEW_2: length 74.9
  IN4 w0.076: v1(188.04,96.91) 188.42,97.29 191.29,97.29 193.99,94.59 193.99,89.13 194.82,88.3 194.82,87.21 198.33,83.71 199.02,83.71 200.16,82.56 200.16,81.03 201.85,79.34 204.28,79.34 205.12,80.17 217.36,80.17 219.5,78.03 225.01,78.03 225.51,78.53 227.64,78.53 228.1,78.07 230.33,78.07 v1(231.3,77.1)
  BOTTOM w0.079: U9001.E3 177.2,101.97 177.86,101.97 177.98,102.1 178.87,102.1 179.07,101.9 179.07,101.02
  BOTTOM w0.114: v1(231.3,77.1) 231.83,77.64 232.26,77.64 R9347.2 233.09,77.25 R9348.2 ; v1(188.04,96.91) 187.51,96.38 186.85,96.38 185.85,97.38 185.3,97.38 184.33,98.35 184.33,98.87 183.62,99.59 180.2,99.59 179.07,100.71 179.07,101.02
TPM_CLKRUN_N: length 12.7
  TOP w0.102: 264.19,75.41 264.07,75.29 262.56,75.29 262.31,75.04 262.31,74.74 262.41,74.64 v1(262.41,74.31)
  TOP w0.114: v1(258.1,70.83) 258.32,70.83 258.48,70.68 259.09,70.68 259.49,71.08 259.92,71.08 260.55,71.71 260.86,71.71 262.01,72.85 262.01,73.9 v1(262.41,74.31) ; 264.19,75.41 264.21,75.41 265.65,76.85 R9082.1
  BOTTOM w0.114: U9002.AV32 258.55,70.38 v1(258.1,70.83)
TPM_PLTRST#: length 18.9
  TOP w0.114: 293.88,45.1 293.81,45.18 292.51,45.18 292.25,45.44 R6510.2 292.64,46.07 292.64,47.34 R6507.1 293.42,49.14 294.93,49.14 295.05,49.26 U6500.17
  TOP w0.127: v1(301.2,43.4) 295.93,43.4 295.89,43.35 294.32,43.35 294.02,43.65 294.02,44.96 293.88,45.1
  BOTTOM w0.114: Q6500.6 301.82,44.3 301.51,43.99 301.51,43.52 301.38,43.4 v1(301.2,43.4)
TPM_PP: length 3.6
  TOP w0.114: U6500.7 295.55,55.53 ; 295.55,55.53 295.36,55.72 R6509.1 295.55,56.34 295.94,56.73 295.94,57.11 296.08,57.25 R6500.1 ; 295.55,55.53 v1(295.55,55.54)
TPM_R_IRQ#: length 67.3
  TOP w0.114: U6500.18 295.55,49.28 294.98,48.71 v1(294.21,48.71) 293.63,48.71 v1(293.4,48.48) 293.15,48.22 R6501.1 ; R9252.2 252.89,72.13 252.89,72.86 252.01,73.74 251.6,73.74 251.49,73.64 v1(251.21,73.64)
  IN4 w0.076: v1(293.4,48.48) 293.2,48.27 291.84,48.27 291.36,48.76 289.51,48.76 288.68,49.58 283.93,49.58 282.95,50.56 279.23,50.56 278.74,51.06 277.45,51.06 277.27,51.24 276.73,51.24 275.5,52.47 271.12,52.47 270.95,52.64 267.14,52.64 266.61,52.11 265.46,52.11 264.51,53.06 263.81,53.06 263.53,53.34 262.99,53.34 261.46,54.87 259.43,54.87 258.4,55.89 258.4,57.16 257.99,57.57 257.99,58.38 258.38,58.76 258.38,60.39 256.01,62.75 256.01,64.53 251.45,69.1 251.45,72.91 251.21,73.14 v1(251.21,73.64)
  BOTTOM w0.254: U9002.AL15 251.22,73.64 v1(251.21,73.64)
TPM_VDD1: length 4.5
  TOP w0.254: R6503.1 R6508.2 299.21,56.38 C6501.2 299.37,56 298.91,55.54 v1(298.58,55.54) 298.55,55.5 U6500.1
TS_STOP_EN_IN: length 23.9
  TOP w0.114: v1(49.92,49.04) 50.07,48.89 R3023.1
  IN3 w0.089: v1(49.92,49.04) 48.96,50 37.75,50 33.79,53.96 33.79,56.6 v1(32.96,57.43)
  BOTTOM w0.114: v1(32.96,57.43) 32.59,57.8 CON3001.9
TS_VREF: length 8.3
  BOTTOM w0.127: TP2008.1 196.37,99.15 199.17,101.94 199.17,103.98 200.29,105.1 U2000.AP9
TYPEC1_USB0: length 276.6
  TOP w0.152: v1(259.42,5.88) 259.42,6.09 PD11008.2
  IN1 w0.152: v1(363.25,102.33) 362.81,102.77 362.81,104.64 362.62,104.83 361.75,105.7 361.44,106.01 361.44,107.62 358.87,110.2 358.87,112.81 359.14,113.07 359.14,117.33 358.93,117.53 358.93,119.89 359.19,120.15 359.19,122.66 357.14,124.71 357.14,125.49 357.06,125.57 355.37,127.26 347.08,127.26 341.95,132.38 341.95,135.79 342.17,136.01 342.17,137.66 v4(339.83,139.99)
  IN2 w0.152: v1(363.25,102.33) 362.77,101.84 362.77,86.94 361.25,85.42 361.25,70.13 364.15,67.22 364.15,63.18 363.89,62.92 363.89,40.7 361.36,38.16 361.36,32.7 359.6,30.94 357.82,30.94 354.5,27.62 354.5,25.14 355.9,23.74 355.9,23.65 355.9,20.37 357.04,19.22 357.04,8.65 351.73,3.34 347.05,3.34 347.01,3.38 339.28,3.38 339.16,3.27 339.03,3.27 337.96,2.19 316.09,2.19 314.46,3.82 301.95,3.82 298.32,7.46 v1(297.21,7.46)
  IN3 w0.152: v1(297.21,7.46) 296.58,7.46 295.5,6.38 277.45,6.38 275.23,8.61 272.69,8.61 272.38,8.3 261.84,8.3 v1(259.42,5.88)
  IN4 w0.508: v1(342.04,150.46) 342.04,149.7 342.77,148.97 342.77,147.68 343.19,147.26 343.19,141.19 341.66,139.66 340.16,139.66 v4(339.83,139.99)
  BOTTOM w0.508: PQ10014.3 341.91,149.95 342.04,150.08 v1(342.04,150.46)
  vias: v1(341.54,140.15)
TYPEC2_USB0: length 275.3
  TOP w0.152: v1(260.05,5.88) 260.05,6.77 PD11008.1
  IN1 w0.152: v1(363.25,101.69) 362.58,102.36 362.58,104.55 362.43,104.7 362.36,104.76 361.59,105.54 361.35,105.78 361.21,105.91 361.21,107.53 358.64,110.1 358.64,112.9 358.91,113.17 358.91,117.23 358.71,117.44 358.71,119.99 358.96,120.24 358.96,122.57 356.91,124.61 356.91,125.39 355.28,127.03 346.99,127.03 341.73,132.29 341.73,135.89 341.94,136.1 341.94,137.11 339.25,139.81 339.25,140.3 339,140.55 337.98,140.55 v1(337.47,140.04)
  IN2 w0.152: v1(363.25,101.69) 363.01,101.45 363.01,86.84 361.49,85.32 361.49,70.23 364.4,67.32 364.4,67.2 364.4,63.08 364.13,62.82 364.13,40.6 361.6,38.06 361.6,32.6 359.7,30.7 357.92,30.7 354.74,27.52 354.74,25.24 356.14,23.84 356.14,23.55 356.14,20.47 357.28,19.32 357.28,8.55 351.83,3.1 346.95,3.1 346.91,3.14 339.38,3.14 338.19,1.95 323.15,1.95 323.15,1.95 315.99,1.95 314.36,3.58 301.85,3.58 298.48,6.95 v1(296.78,6.95)
  IN2 w0.508: v1(336.84,136.36) 336.84,136.57 337.47,137.2 v1(337.47,140.04) 337.47,140.26 v1(333.92,143.82)
  IN3 w0.152: v1(260.05,5.88) 262.23,8.06 272.48,8.06 272.79,8.37 275.13,8.37 277.35,6.14 295.97,6.14 v1(296.78,6.95)
  BOTTOM w0.508: v1(333.92,143.82) 333.96,143.78 PQ10015.3
  vias: v1(336.96,132.55)
TYPEC_DET#: length 492.9
  TOP w0.114: v1(358.55,120.41) 358.55,121.16 Q7151.3 359.02,122.06 359.02,122.65 Q7130.6 358.81,123.03 359.82,124.04 Q7130.3
  IN1 w0.076: v1(205.65,10.63) 205.65,9.91 207.64,7.91 212.97,7.91 214.52,6.36 234.21,6.36 235.12,5.45 238.39,5.45 239.82,6.87 242.12,6.87 243.81,5.18 250.5,5.18 251.22,5.91 254.4,5.91 255.12,5.18 261.66,5.18 262.24,5.76 265.8,5.76 266.29,5.27 291.68,5.27 293.47,7.06 293.47,8.33 295.74,10.61 297.97,10.61 300.3,8.28 313.74,8.28 314.26,8.8 317.9,8.8 321.46,5.25 323.12,5.25 323.84,4.52 325.91,4.52 329.09,7.7 329.09,9.24 332.72,12.87 332.72,13.35 332.31,13.76 332.31,17.79 333.05,18.53 333.05,21.22 333.36,21.53 335.69,21.53 337.32,23.16 337.32,25.06 339.78,27.52 341.15,27.52 341.81,28.18 344.05,28.18 344.46,27.78 346.02,27.78 349.97,31.73 351.52,31.73 357.78,37.99 357.78,44.27 359.7,46.19 359.7,57.6 363,60.9 363,65.5 363.38,65.88 363.38,68.25 361.73,69.9 361.73,84.29 362.9,85.46 362.9,99.29 361.74,100.45 361.74,100.75 362.39,101.4 362.39,104.47 362.24,104.62 361.45,105.41 361.02,105.83 361.02,107.45 360.87,107.6 360.87,107.6 358.45,110.02 358.45,112.98 358.72,113.25 358.72,117.16 358.51,117.36 358.51,120.37 v1(358.55,120.41)
  IN3 w0.089: v1(103.1,16.6) 103.1,14.75 105.8,12.05 179.44,12.05 184.14,16.75 197.59,16.75 198.48,15.86 200.67,15.86 202.03,14.5 202.03,11.88 203.28,10.63 v1(205.65,10.63)
  BOTTOM w0.114: PQ26002.2 116.02,97.34 115.6,97.75 PR26003.2 114.75,98.73 114.28,99.2 111.72,99.2 110.14,97.63 110.14,97.12 107.35,94.32 106.46,94.32 105.8,93.66 105.8,93.21 105.49,92.9 105.49,90.95 102.83,88.28 102.83,87.97 102.27,87.42 102.27,86.96 101,85.69 101,76.04 101.38,75.66 101.38,70.17 102.11,69.43 102.11,63.03 103.49,61.65 103.49,51.15 97.49,45.14 97.49,43.37 97.84,43.02 102.52,43.02 102.78,42.76 102.78,37.9 102.53,37.65 102.53,22.53 104.57,20.49 104.57,19.53 103.42,18.39 103.42,16.91 v1(103.1,16.6)
UART0_RXD: length 99.8
  TOP w0.114: v1(274.73,19.39) 276.64,19.39 v1(278.04,20.79) 280.19,20.79 v1(282.1,22.7)
  IN2 w0.089: v1(290.61,53.05) 289.71,53.05 287.1,55.66 284.14,55.66 284.09,55.71 283.81,55.71 283.59,55.93 283.59,55.93 283.2,56.09 283.15,56.11 282.96,56.24 282.95,56.25 282.58,56.49 282.1,56.97 281.72,57.54 281.57,57.77 281.57,57.91 281.54,57.98 280.85,58.67 280.85,60.73 277.87,63.7 277.87,66.2 276.91,67.17 274.99,67.17 274.73,66.91 274.48,66.91 273.82,67.57 272.86,67.57 271.98,68.44 271.98,68.67 268.5,72.15 267.94,72.15 265.98,74.11 265.64,74.11 265.35,74.4 264.99,74.4 262.9,76.49 261.93,76.49 260.63,77.79 260.63,78.83 260.92,79.11 v3(260.92,79.72)
  BOTTOM w0.102: U9002.BE23 258.2,75.92 258.5,76.22 258.5,76.31 259.04,76.85 259.04,76.98 260.2,78.13 260.2,78.13 260.33,78.26 260.33,78.87 260.76,79.29 260.76,79.57 v3(260.92,79.72)
  BOTTOM w0.114: v1(290.61,53.05) 289.47,51.91 289.47,51.16 288.94,50.64 288.94,48.88 289.28,48.54 289.28,47.87 289.21,47.8 289.21,47.46 288.53,46.78 288.53,45.65 288.32,45.44 288.32,40.77 288.32,39.97 290.44,37.85 290.44,35.47 290.83,35.08 290.83,28.57 289.23,26.97 289.23,26.62 288.85,26.23 288.56,26.23 288.07,25.74 288.07,24.86 287.69,24.47 285.05,24.47 283.27,22.7 v1(282.1,22.7) ; v1(274.73,19.39) 274.23,19.89 R9032.2 274.15,19.82 R9021.1
UART0_RXD_R: length 2.6
  BOTTOM w0.114: JCN9000.29 274.24,16.92 TP9001.1 274.15,17.79 R9021.2
UART0_TXD: length 82.8
  TOP w0.114: v1(275.24,56.56) 275.42,56.38 275.42,54.62 274.05,53.26 274.05,50.14 275.48,48.72 275.48,44.19 274.35,43.07 274.35,42.51 274.61,42.25 275.01,42.25 v1(275.5,42.74)
  IN2 w0.089: v1(275.5,42.74) 278.47,39.76 278.47,33.69 278.75,33.41 278.75,32.73 277.76,31.73 277.76,29.2 277.25,28.69 277.25,28.36 277.55,28.05 277.55,21.46 276.6,20.51 274.81,20.51 v1(273.72,19.42)
  IN4 w0.076: v1(275.24,56.56) 274.66,57.14 273.41,57.14 272.29,58.26 268.99,58.26 268,59.25 267.13,59.25 263.49,62.89 262.06,62.89 259.77,65.18 259.77,65.7 260.27,66.19 260.27,66.88 258.3,68.85 256.41,68.85 254.42,70.84 254.42,71.34 254.67,71.59 254.67,72.23 254.16,72.73 254.16,73.34 254.46,73.65 255.25,73.65 255.56,73.34 256.17,73.34 256.87,74.05 v1(256.87,74.79)
  BOTTOM w0.114: R9020.1 273.16,19.84 R9031.2 273.24,19.89 v1(273.72,19.42) ; v1(256.87,74.79) 257.16,74.79 U9002.BB24
UART0_TXD_R: length 2.5
  BOTTOM w0.114: R9020.2 273.16,17.52 TP9000.1 273.74,16.93 JCN9000.28
UART_WAKE#: length 3.1
  BOTTOM w0.114: R4123.1 346.73,63.09 346.49,63.34 345.12,63.34 344.89,63.57 U4100.53
UIM_CLK: length 48
  TOP w0.114: ESD4200.3 307.95,9.17 308.39,9.62 C4214.2 308.51,12.53 308.83,12.85 v1(308.83,14.31)
  IN3 w0.089: v1(308.83,14.31) 308.97,14.31 310.14,15.48 311.03,15.48 311.82,14.7 318.52,14.7 318.88,15.05 320,15.05 322.23,17.29 322.97,17.29 324.19,18.51 326.41,18.51 326.66,18.76 331.25,18.76 331.72,19.23 336.57,19.23 337.6,20.26 v1(337.7,20.26)
  BOTTOM w0.114: CON4200.5 306.44,13.98 307.12,13.3 308.13,13.3 308.83,14 v1(308.83,14.31) ; v1(337.7,20.26) 337.92,20.04 337.92,19.31 338.64,18.59 338.64,17.28 338.5,17.14 CON4201.32
UIM_DATA: length 47.8
  TOP w0.114: v1(306.36,11.01) 306.42,11.07 ESD4200.1 307.44,11.96 307.37,12.03 C4207.2 307.14,12.53 R4212.1 v1(307.04,13.99)
  IN3 w0.089: v1(338.36,20.32) 338.87,19.81 338.87,19.14 337.83,18.1 335.29,18.1 335.18,17.99 332.43,17.99 331.92,17.48 329.37,17.48 328.19,16.3 325.27,16.3 323.71,14.73 320.86,14.73 319.96,13.84 316.17,13.84 315.13,12.8 308.23,12.8 v1(307.04,13.99)
  BOTTOM w0.114: CON4200.4 307.14,14.87 307.04,14.77 v1(307.04,13.99) ; v1(338.36,20.32) 338.92,19.75 338.92,18.86 339.08,18.71 339.08,17.11 339,17.03 CON4201.34
UIM_RESET: length 45.8
  TOP w0.114: v1(309.53,14.31) 309.2,13.99 309.2,12.87 309.54,12.53 C4210.2 309.66,11.77 309.84,11.59 ESD4200.6
  IN3 w0.089: v1(337.5,19.6) 336.73,18.84 334.38,18.84 333.92,18.38 332.27,18.38 331.76,17.87 326.68,17.87 326,17.2 323.79,17.2 323.09,16.5 322.07,16.5 319.8,14.23 311.52,14.23 310.78,14.98 310.19,14.98 v1(309.53,14.31)
  BOTTOM w0.114: CON4200.7 305.04,14.24 306.41,12.87 308.46,12.87 309.53,13.93 v1(309.53,14.31) ; CON4201.30 338,16.99 337.78,17.22 337.78,18.74 337.5,19.02 v1(337.5,19.6)
UIM_VPP: length 12.4
  TOP w0.114: ESD4200.4 310.48,9.17 310.55,9.11 TP4200.1 311.64,9.11 v1(311.99,9.46)
  IN2 w0.089: v1(305.85,14.06) 310.39,9.51 311.94,9.51 v1(311.99,9.46)
  BOTTOM w0.114: CON4200.6 305.74,14.17 v1(305.85,14.06)
UMA_DIS#_GPU: length 3.5
  TOP w0.114: R6045.2 260.15,36.06 259.87,35.78 259.87,35.19 v1(260.28,34.79) 260.41,34.66 R6047.1 260.41,33.33 R17984.1
UMA_ONLY#: length 260.2
  TOP w0.114: Q3002.1 81.95,64.25 R3048.1 81.38,62.15 81.38,61.68 81.57,61.5 81.57,60.76 83.11,59.22 83.11,57.96 82.02,56.88 82.02,53.14 v1(82.14,53.02) ; U3010.6 256.56,41.75 255.68,40.87 255.68,39.98 255.3,39.6 U3008.6 253.76,39.6 253.4,39.97 251.01,39.97 250.2,40.78 247.94,40.78 v1(247.5,40.35) 247.5,39.89 248.02,39.38 249.23,39.38 249.74,38.87 U3009.6
  IN2 w0.089: v1(264.23,60.01) 264.08,60.16 263.38,60.16 260.85,57.64 259.69,57.64 258.71,56.66 258.71,56.21 254.05,51.55 254.05,48.85 252.03,46.83 252.03,44.48 250.62,43.07 248.08,43.07 247.5,42.49 v1(247.5,40.35) 247.12,40.35 244.31,37.54 244.31,36.99 240.01,32.69 236.17,32.69 235.02,31.54 233.42,31.54 230.91,29.02 221.77,29.02 217.22,24.47 214.85,24.47 214.03,23.66 206.1,23.66 205.76,23.32 201.46,23.32 200.48,24.29 190.65,24.29 189.13,22.77 180.6,22.77 180.27,22.44 178.21,22.44 177.57,23.08 171.46,23.08 170.49,22.11 136.2,22.11 136.05,22.27 105.7,22.27 105.28,22.68 103.67,22.68 102.24,24.11 102.24,28.76 100.74,30.26 100.74,38.42 96.73,42.43 96.73,43.98 89.8,50.91 84.26,50.91 v1(82.14,53.02)
  BOTTOM w0.114: U9002.AN47 262.26,63.59 263.61,62.24 263.61,60.63 v1(264.23,60.01)
UMA_SKU_ONC: length 11.3
  TOP w0.114: R3047.2 77.48,62.97 77.48,66.36 v1(78.39,67.27) 79.05,66.61 80.91,66.61 Q3002.2 82.12,65.93 82.86,66.66 Q3001.2
USB2_COMP: length 7
  BOTTOM w0.114: U9002.F4 237.41,69.48 235.46,71.43 235.46,72.23 233.84,73.86 R9058.1
USB30_RX1+: length 220.1
  TOP w0.102: v1(359.95,67.53) 359.67,67.25 353.75,67.25 352.33,68.67 352.33,72.51 351.64,73.2 351.64,74.68 351.91,74.94 353.1,74.94 353.52,74.53 353.81,74.53 353.95,74.38 U7002.7 U7002.4 355.53,74.38 355.68,74.53 355.97,74.53 356.27,74.82 356.27,77.69 356.68,78.1 357.23,78.1 357.36,77.97 357.36,77.35 CON7001.6
  IN4 w0.076: v1(359.95,67.53) 360.25,67.23 360.43,67.23 360.71,67.51 360.71,68.27 361.24,68.8 362.74,68.8 364.78,66.77 364.78,62.7 364.18,62.11 364.18,50.29 362.99,49.1 362.99,44.15 361.86,43.02 361.86,41.64 360.75,40.54 360.75,38.12 356.97,34.34 353.9,34.34 352.17,32.62 350.16,32.62 349.64,32.09 345.48,32.09 343.1,34.47 338.76,34.47 338.23,33.94 336.29,33.94 336.04,33.68 329.71,33.68 328.63,34.76 322.99,34.76 322.23,34 319.51,34 318.29,35.22 315.17,35.22 314.71,35.68 301.14,35.68 300.78,36.04 289.47,36.04 288.27,37.24 286.43,37.24 286.01,37.66 285.17,37.66 284.77,38.06 282.32,38.06 281.74,38.65 278.85,38.65 278.19,39.31 271.6,39.31 271.07,39.84 268.44,39.84 268.22,40.06 262.42,40.06 262.09,40.4 257.02,40.4 256.7,40.07 249.18,40.07 248.47,40.78 246.36,40.78 244.86,42.28 242.95,42.28 242.22,43.01 242.22,44.41 241.6,45.03 241.6,46.17 241.04,46.73 241.04,48.16 239.96,49.24 239.1,49.24 234.6,53.74 234.6,54.29 234.05,54.84 234.05,58.19 233.04,59.2 233.04,60.28 235.12,62.36 237.33,62.36 237.9,62.94 237.9,63.79 238.08,63.97 v1(238.26,63.97)
  BOTTOM w0.102: v1(238.26,63.97) 238.46,64.18 238.46,64.46 238.94,64.94 239.06,64.94 239.46,65.33 239.46,65.37 U9002.C11
USB30_RX1-: length 220.1
  TOP w0.102: v1(359.95,66.77) 359.67,67.05 353.67,67.05 352.13,68.59 352.13,72.43 351.44,73.12 351.44,74.77 351.82,75.15 353.18,75.15 353.6,74.73 353.81,74.73 353.95,74.88 U7002.6 U7002.5 355.53,74.88 355.68,74.73 355.89,74.73 356.06,74.91 356.06,77.77 356.59,78.3 357.08,78.3 357.21,78.43 CON7001.5
  IN4 w0.076: v1(359.95,66.77) 360.25,67.06 360.5,67.06 360.88,67.44 360.88,68.2 361.31,68.63 362.68,68.63 364.61,66.7 364.61,62.77 364.01,62.17 364.01,50.36 362.82,49.17 362.82,44.22 361.69,43.09 361.69,41.71 360.59,40.6 360.59,38.19 356.9,34.51 353.83,34.51 352.1,32.78 350.09,32.78 349.57,32.26 345.55,32.26 343.17,34.63 338.69,34.63 338.16,34.1 336.23,34.1 335.97,33.85 329.78,33.85 328.7,34.93 322.92,34.93 322.16,34.17 319.58,34.17 318.36,35.38 315.24,35.38 314.78,35.84 301.21,35.84 300.84,36.21 289.54,36.21 288.34,37.4 286.5,37.4 286.08,37.83 285.24,37.83 284.83,38.23 282.39,38.23 281.81,38.81 278.92,38.81 278.26,39.47 271.67,39.47 271.14,40.01 268.51,40.01 268.29,40.23 262.49,40.23 262.16,40.56 256.96,40.56 256.63,40.24 249.25,40.24 248.54,40.95 246.43,40.95 244.93,42.45 243.02,42.45 242.39,43.08 242.39,44.48 241.77,45.1 241.77,46.24 241.21,46.8 241.21,48.22 240.02,49.41 239.17,49.41 234.77,53.81 234.77,54.36 234.22,54.9 234.22,58.26 233.2,59.27 233.2,60.21 235.19,62.19 237.4,62.19 238.07,62.87 238.07,63.21 238.2,63.34 v1(238.28,63.34)
  BOTTOM w0.102: U9002.D11 240.02,65.61 239.14,64.73 239.02,64.73 238.67,64.38 238.67,63.72 v1(238.28,63.34)
USB30_RX3+: length 270.4
  IN3 w0.089: v1(27.69,103.27) 27.69,103.26 28.27,102.68 28.27,93.52 33.41,88.38 33.41,82.68 37.09,79 37.09,74.3 38.93,72.45 38.93,68.97 40.29,67.62 45.17,67.62 49.67,63.12 53.1,63.12 55.51,60.71 57.94,60.71 59.81,58.83 72.68,58.83 76.54,54.97 78.9,54.97 79.46,55.53 83.74,55.53 84.3,54.97 90.61,54.97 91.47,54.11 93.79,54.11 96.36,56.68 96.36,58.13 102.86,64.62 104.79,64.62 105.21,64.19 115.77,64.19 120.2,68.63 168.34,68.63 175.33,75.63 208.88,75.63 209.69,74.82 210.45,74.82 210.45,74.82 216.12,74.82 216.5,74.43 216.5,72.89 219.83,69.56 220.21,69.56 220.22,69.56 223.9,69.56 226.21,67.26 230.68,67.26 234.55,63.39 236.05,63.39 236.39,63.73 236.57,63.73 236.84,64 v1(236.84,64.07)
  BOTTOM w0.102: U9002.C10 238.87,65.91 237.29,64.33 237.29,63.93 237.22,63.86 237.05,63.86 v1(236.84,64.07) ; v1(27.69,103.27) 27.97,102.99 28.04,102.99 28.18,103.12 28.18,103.64 28.07,103.74 28.07,104.82 28.23,104.98 28.23,108.04 28.13,108.13 27.79,108.13 27.64,107.99 27.64,107.67 C612.1
USB30_RX3+_C: length 12.5
  IN4 w0.076: CON7000.6 12.75,104.3 12.9,104.15 13.94,104.15 15.78,105.98 15.78,108.04 15.38,108.43 15.24,108.43 v1(15,108.19)
  BOTTOM w0.102: R9526.2 18.39,108.57 18.17,108.57 17.38,107.79 17.18,107.79 17.04,107.65 U7001.2 U7001.9 15.61,107.65 15.07,108.19 v1(15,108.19)
USB30_RX3-: length 270.4
  IN3 w0.089: v1(236.86,63.2) 236.86,63.39 236.71,63.54 236.47,63.54 236.13,63.2 234.47,63.2 230.6,67.07 226.13,67.07 223.82,69.37 220.29,69.37 219.75,69.37 216.31,72.81 216.31,74.35 216.04,74.63 210.53,74.63 209.61,74.63 208.8,75.44 175.41,75.44 168.41,68.44 120.28,68.44 115.84,64 105.14,64 104.71,64.43 102.94,64.43 96.55,58.05 96.55,56.61 93.87,53.92 91.39,53.92 90.53,54.78 84.22,54.78 83.67,55.34 79.54,55.34 78.98,54.78 76.46,54.78 72.6,58.64 59.73,58.64 57.86,60.52 55.43,60.52 53.02,62.93 49.59,62.93 45.09,67.43 40.21,67.43 38.74,68.89 38.74,72.37 36.9,74.22 36.9,78.92 33.22,82.6 33.22,88.3 28.08,93.44 28.08,102.6 27.92,102.76 27.82,102.76 v1(27.69,102.63)
  BOTTOM w0.102: C615.1 27.99,108.34 28.22,108.34 28.43,108.13 28.43,104.89 28.28,104.74 28.28,103.82 28.38,103.72 28.38,103.04 28.12,102.78 27.85,102.78 v1(27.69,102.63) ; v1(236.86,63.2) 236.86,63.57 236.95,63.65 237.31,63.65 237.5,63.84 237.5,64.25 238.77,65.52 238.88,65.52 U9002.B10
USB30_RX3-_C: length 12.5
  IN4 w0.076: v1(15.04,108.83) 15.27,108.6 15.45,108.6 15.95,108.1 15.95,105.91 14.01,103.98 13.02,103.98 12.75,103.72 CON7000.5
  BOTTOM w0.102: v1(15.04,108.83) 15.04,108.75 15.64,108.15 U7001.10 U7001.1 17.02,108.15 17.18,107.99 17.3,107.99 18.08,108.78 18.39,108.78 R9525.2
USB30_RX4+: length 291.5
  IN3 w0.089: v1(31.32,80.56) 31.32,80.25 31.37,80.21 32.11,80.21 32.42,79.91 32.42,78.31 31.91,77.8 31.91,73.99 35.58,70.32 35.97,70.32 36.58,69.71 36.58,67.47 40.01,64.04 41.69,64.04 47.92,57.81 49.75,57.81 53.31,54.26 59.15,54.26 59.98,53.43 64.18,53.43 65.29,52.33 79.53,52.33 79.88,51.98 90.16,51.98 90.41,51.73 94.76,51.73 101.57,44.92 101.57,39.83 105.59,35.81 105.59,33.69 106.92,32.36 107.99,32.36 117.41,22.94 153.33,22.94 154.43,24.04 170.21,24.04 170.52,24.35 179.28,24.35 180.09,25.16 186.56,25.16 187.15,25.74 189.88,25.74 190.42,26.28 202.71,26.28 204.94,28.51 229.37,28.51 235.62,34.76 235.62,37.81 236.63,38.83 236.63,55.99 237.9,57.26 237.9,58.43 242.26,62.79 242.26,64.57 242.76,65.07 242.76,66.3 242.63,66.43 242.45,66.43 v1(242.35,66.33)
  BOTTOM w0.102: v1(242.35,66.33) 242.63,66.33 242.79,66.17 U9002.J15 ; C613.1 30,90.04 30,90.36 30.08,90.44 31.02,90.44 32.21,89.24 32.21,80.87 31.67,80.33 31.55,80.33 v1(31.32,80.56)
USB30_RX4+_C: length 13.7
  BOTTOM w0.102: CON7002.6 13.04,86.53 13.04,85.92 12.89,85.77 12.41,85.77 11.87,86.31 11.87,87.07 12.62,87.82 13.12,87.82 13.88,88.58 13.88,89.08 14.29,89.5 15.01,89.5 15.15,89.36 U7000.9 U7000.2 16.92,89.36 17.06,89.5 17.89,89.5 18.55,90.16 20.06,90.16 R9528.2

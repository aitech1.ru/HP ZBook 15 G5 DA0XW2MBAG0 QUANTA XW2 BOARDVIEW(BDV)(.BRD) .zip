# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Library data of the parts (continued)
D9000 = DIODE SCHOTTKY_1
D9001 = DIODE SCHOTTKY_0
D9004 PD9002 PD9005 PD9501 PD11004 = Schottky_DIODE_BGM
ESD4200 ESD7200 = CDA6C05GTH_0
F3000 F7200 = FUSE
H1-H4 H7-H35 PAD2-PAD13 PAD15 PAD18-PAD21 = HOLE 1
H5 H6 = 3x2_1.1
J9000 = OPEN
JCN9000 = CONN_2
JDIM1000 JDIM1002 = DDR3_2
JDIM1001 JDIM1003 = DDR3_3
L2001 L3605 L3606 = BEAD_BGM
L2010 L3003 L3005 = BEAD_BGM_0
L3004 = BW
L3604 = BEAD
L3607 L3608 = P_L_0
L3609-L3616 = INDUCTOR_0
L4000 = INDUCTOR_2
L4100 = SI3441DV_1
L6000 PL2100-PL2102 PL8001 PL9001 PL9004 PL9005 PL9501 PL11000 PL13001-PL13003 PL13005 PL14001 PL15001 PL16001 PL17001 PL18001 PL20000-PL20003 = INDUCTOR_BGM
L7000-L7002 L8000 L9000 = BW_BGM
L8001 = INDUCTOR
LED6000 = D-LED_0
LED9000 = LED_2P_BGM
LED9002 LED9003 = LED_0
LED9004 = D-LED_1
PCN10000 = DCJACK_040003HR00_11P_BGM
PCN12000 = Header_8P_BGM
PD11001 PD11003 PD11005 PD11007 = DIODE_BGM
PD11008 = BAT54C_BGM
PD12000 PD12001 = BAV99W_BGM
PJP13001 PJP13002 PJP14000 PJP15000 PJP16000 PJP16001 PJP17000 = JUMPER2_0
PJP18000 = Short_jump_BGM
PL12000-PL12002 PL13004 PL18000 PR8005 PR8006 PR8023 PR9025 PR9026 PR9029 PR9032 PR9502 PR9503 PR9508 PR9511 PR9512 PR11001 PR11002 PR11016 PR11017 PR13020 PR13021 PR16016 PR18005 PR18014 PR20004 PR20005 PR20018 PR20019 PR20034 PR20035 PR20049 PR20050 = SHORTPAD_BGM
PL16000 PL17000 = IND
PQ8002-PQ8004 PQ9501 PQ9502 PQ11003 PQ12003 PQ12004 PQ12008 PQ14000 PQ14001 PQ23003 PQ23004 PQ23006 PQ26000 PQ26003 PQ26006 Q2000 Q2006 Q2008 Q2010-Q2013 Q2015-Q2018 Q2021 Q2022 Q2500 Q2501 Q3001-Q3006 Q3010 Q3600 Q3603 Q3606 Q4104 Q4200 Q4201 Q5101 Q5102 Q6001 Q6003-Q6008 Q6300 Q6501 Q6800-Q6805 Q7120 Q7146 Q7300 Q7301 Q8000 Q9003 Q9010 Q9043 = MOS-N_3P_ESD_BGM
PQ9001 PQ9004-PQ9008 PQ20000-PQ20003 = MOS-N-Dual_10P_BGM
PQ10000 PQ10001 PQ10006 PQ10007 PQ10011-PQ10013 PQ11000 = MOS-P_8P_BGM
PQ10002 PQ10003 PQ10009 PQ10014-PQ10016 PQ11004 PQ12005 = MOS-P_3P_BGM
PQ10004 PQ10005 Q2019 Q2020 Q2023 Q2024 Q3007-Q3009 Q3602 Q4000 Q4105 Q4106 Q6002 Q6351 Q6402 Q6500 Q9001 Q9002 Q9032 Q9042 Q9046 Q9047 = MOS-N_Dual_6P_ESD_BGM
PQ10008 PQ10010 PQ12006 PQ12007 PQ12011 PQ12012 PQ26001 PQ26004 = PNP_BGM
PQ10017-PQ10019 PQ11005 = PNP_Dual_6P_BGM_2
PQ11001 PQ11002 = MOS-N_8P_BGM
PQ12009 PQ26002 PQ26005 Q7151 Q8012 = NPN_BGM
PQ14002 PQ23005 PQ23007 PQ23008 Q3000 Q4101 Q7130 Q9009 Q9036-Q9040 = 2N7002DW
PQ24000 Q2014 = 2N7002
PR8001-PR8004 PR8007-PR8010 PR8012 PR8013 PR8018 PR8021 PR8022 PR9001-PR9006 PR9011-PR9018 PR9021 PR9023 PR9024 PR9027 PR9028 PR9030 PR9035 PR9037 PR9038 PR9040 PR9041 PR9212 PR9213 PR9220 PR9222 PR9501 PR9504-PR9507 PR9509 PR9510 PR9519-PR9522 PR9802 PR9803 PR9807-PR9809 PR9811-PR9816 PR9819-PR9824 PR10000-PR10012 PR10015-PR10018 PR10020 PR10021 PR10023-PR10034 PR11004-PR11010 PR11012-PR11015 PR11018-PR11043 PR12000 PR12001 PR12003 PR12009-PR12011 PR12013-PR12032 PR12034-PR12037 PR13000-PR13019 PR13022-PR13026 PR14007 PR14009 PR14016 PR16015 PR16017-PR16019 PR18000 PR18002-PR18004 PR18006 PR18008-PR18013 PR19000-PR19050 PR19052-PR19057 PR20000-PR20003 PR20006-PR20008 PR20010-PR20017 PR20020-PR20023 PR20025-PR20033 PR20036-PR20038 PR20040-PR20048 PR20051-PR20053 PR20055-PR20064 PR20066 PR20068 PR20070 PR20072 PR21000-PR21014 PR23010 PR23014 PR23016 PR23022-PR23028 PR26000-PR26011 PR26013-PR26018 R106 R288 R402 R500-R520 R522-R530 R532-R550 R601-R604 R613-R615 R618-R623 R626-R635 R908 R909 R1000-R1010 R1012 R1015 R1017-R1031 R1034-R1037 R1039 R1041 R1043-R1050 R2001 R2010-R2012 R2020 R2022-R2040 R2042-R2044 R2046 R2050 R2057 R2059 R2060 R2062-R2099 R2101-R2105 R2107-R2129 R2132 R2133 R2135-R2143 R2145-R2148 R2150-R2152 R2226-R2228 R2231-R2235 R2500-R2525 R3008 R3011 R3013 R3030 R3031 R3034 R3040-R3045 R3047-R3068 R3075-R3077 R3081 R3083-R3086 R3092 R3093 R3200 R3203-R3207 R3601-R3604 R3606 R3607 R3609-R3612 R3615-R3618 R3622 R3629 R3648 R3649 R3652 R3655 R3680-R3683 R4019 R4020 R4022-R4024 R4101 R4102 R4118 R4120 R4121 R4125 R4127 R4129-R4135 R4137 R4138 R4208 R4209 R4213 R4221 R4227 R5000 R6000 R6001 R6003 R6004 R6008 R6011 R6014-R6023 R6025-R6032 R6034-R6040 R6045 R6047 R6050 R6053 R6056 R6061 R6062 R6066 R6068 R6071-R6073 R6075 R6077-R6080 R6082 R6090 R6091 R6097 R6098 R6100 R6130-R6138 R6152 R6164 R6165 R6167 R6169 R6170 R6172-R6179 R6187-R6190 R6214 R6223-R6225 R6231 R6234 R6238 R6240 R6241 R6358 R6404 R6407 R6412 R6413 R6504 R7140-R7142 R7153-R7155 R7175-R7178 R7188 R7190-R7192 R7199 R7205 R7206 R7307-R7316 R7320 R7323 R7324 R7327-R7331 R7333 R8018 R8019 R8025 R8026 R8033 R8048-R8063 R8098 R8501 R8502 R8505-R8508 R8511 R8512 R8530-R8534 R8551 R8556 R8557 R8570-R8575 R8588 R8680-R8684 R9000 R9001 R9003-R9021 R9026 R9028 R9030-R9034 R9036-R9050 R9052-R9068 R9071-R9084 R9086-R9095 R9097-R9107 R9110-R9139 R9141 R9142 R9144 R9145 R9148-R9154 R9157-R9161 R9164-R9197 R9199-R9208 R9210-R9216 R9220 R9221 R9223-R9225 R9227 R9229 R9231 R9232 R9234 R9236 R9237 R9239-R9253 R9255 R9256 R9261 R9262 R9266 R9271-R9275 R9279 R9282-R9285 R9300-R9330 R9335-R9338 R9340 R9342-R9355 R9357 R9358 R9360-R9369 R9371-R9383 R9502 R9507-R9509 R9512-R9514 R9525-R9528 R9531 R9533 R9535 R9543-R9545 R9547 R9549 R9550 R9586-R9589 R9592-R9600 R9602-R9607 R9614-R9627 R10000-R10043 R10048-R10056 R17879 R17887 R17888 R17906-R17908 R17911 R17930-R17937 R17949-R17952 R17956 R17963 R17972-R17975 R17977 R17978 R17980-R17985 R17987 R17992 R18002-R18006 R18008 R18011 R18018-R18024 R18043-R18047 R18064 R18066-R18079 R18088-R18090 R18099-R18103 R18105-R18107 = RES_BGM
PR9805 PR9806 = SHORTPAD_V01_BGM
PR11000 PR11011 = R_Current_SEN_BGM
PR14000 PR14001 PR14003-PR14006 PR14008 PR14010-PR14015 PR14017 PR15000-PR15010 PR15012 PR16000 PR16001 PR16004-PR16010 PR16013 PR16014 PR17000-PR17007 PR17009-PR17020 PR22004-PR22008 PR22010 PR22012 PR22013 PR23007-PR23009 PR23011-PR23013 PR23015 PR23017 PR23018 PR23020 PR23021 PR24000-PR24004 PR25000-PR25005 PR25007-PR25026 R6005 = RES
PR20009 PR20024 PR20039 PR20054 PR20065 PR20067 PR20069 PR20071 = Thermistor_BGM
PU8001 PU18000 = AOZ2263QI-18_BGM
PU9001 = RT8813DGQW_BGM
PU9002 = RT9610BZQW_BGM
PU9501 = AOZ1331DI_BGM
PU9502 = SY8002ABC_6P_BGM
PU9503 U2001 U2006 U2007 U12003 = NL17SZ08DFT2G_5P_BGM
PU9802 = PAC1934-1-JQX-TR_16P_BGM
PU11000 = MAX8731EEI_12
PU11001 = G753T11U_BGM
PU13000 = NB679AGD-Z_BGM_0
PU13001 = NB680AGD-Z_BGM_1
PU13002 = AOZ2261QI-18_BGM
PU14000 = MAX1993ETG_0
PU15000 PU16000 = MAX1993ETG_8
PU16001 = G9661-25ADJF12U_BGM
PU17000 = MAX1993ETG_30
PU19000 = MP2949AGQKT-0070-Z_BGM_0
PU20000-PU20003 = MP8693_12P_BGM
PU20004 = G717R41U_16P_BGM
PU21000 PU21001 = MP86903-CGLT-Z_BGM
PU21002 = MP86901-AGQT_13P_BGM
PU22000-PU22002 = G923_0
PU23000 PU23001 = 74AHCT1G08SE-7_5P_BGM
PU23002 = AOZ1335DI_BGM
PU24000 = TPS51100_2
PU25000 = AS393MTR-G1
PU25001 U12002 = IMISM530_1
PU25002 = M74VHC1GT32DFT2G_5P_BGM
Q4001 Q4102 Q4103 Q6301 Q6401 Q9000 Q9004 Q9035 = NPN_0
Q6806 Q9006 Q9007 = IRLML5103
Q9008 = 2N7002_3
R400 R401 R403-R409 R910-R912 R3000-R3002 R3004 R3007 R3009 R3010 R3012 R3014 R3016 R3017 R3019-R3027 R3029 R3036 R3037 R3039 R3079 R3080 R3082 R3091 R3094 R3201 R3202 R3600 R3605 R3608 R3613 R3614 R3619 R3620 R3626-R3628 R3630 R3631 R3636-R3647 R3678 R3679 R4100 R4103 R4104 R4106-R4108 R4110-R4117 R4119 R4122 R4124 R4200-R4207 R4210-R4212 R4214-R4217 R4219 R4222-R4226 R5001 R5100 R5102-R5104 R5106 R5108 R5109 R5111 R6092-R6096 R6181-R6186 R6201-R6205 R6210 R6212 R6215 R6218 R6221 R6222 R6228 R6229 R6237 R6300-R6305 R6351 R6353-R6355 R6359 R6401-R6403 R6405 R6406 R6500-R6503 R6507-R6514 R6802-R6828 R7008 R7011 R7013 R7016 R7019 R7022 R7100 R7101 R7187 R7189 R7200-R7204 R7322 R8001 R8002 R8005-R8017 R8020-R8024 R8027-R8029 R8031 R8032 R8034-R8047 R9257-R9260 R9263 R9265 R9267-R9270 R9276-R9278 R9280 R9281 R9286-R9288 R9299 R9339 R9341 R9501 R9503-R9506 R9546 R9590 R9591 R17898 R17900-R17904 R17909 R17910 R17938-R17943 R17947 R17948 R17953 R17964-R17967 R17979 = R
R4000-R4002 R4005-R4007 R4012 R4021 R4025 R4026 R6230 R7300 = R_0
R4003 R4004 R4008 R4009 R4011 R4123 R7302 R9370 R17958 = R_1
R4010 = R_10
R4013 R4014 = R_3
R4015-R4018 = R_2
R7301 R7303 = R_8
R7304 = R_13
R7305 R7306 = R_15
R9002 = R_4
R9085 = R-0603_0
RP6800 = RP-8
RV6000 RV6001 = VARISTOR_BGM
TP503 TP505 TP512 TP513 TP1000-TP1007 TP3600-TP3608 TP4100-TP4110 TP4200 TP4201 TP5100 TP5102 TP6201-TP6207 TP8000-TP8003 TP8005-TP8010 TP8519 TP8520 TP8522-TP8526 TP9000-TP9009 TP9014 TP9016 TP9019 TP9021 TP9025-TP9028 TP9030 TP9031 TP9034 TP9035 TP9039 TP9040 TP9043 TP9050-TP9062 TP9500-TP9502 TP11000-TP11002 TP16000 TP22000 TP22001 TP22011 TP22040-TP22070 TP98005-TP98008 = TP_BGM
TP2000-TP2008 TP2010-TP2012 TP2014 TP2015 = PAD
TP4000-TP4003 = PAD_1
U49 U2008-U2011 U9000 U9003 U12001 = Logic_AND_BGM
U500 U501 = PS8461
U600 U601 = PTN36001_BGM
U603 = PS8511_1
U2000 = U_GPU_GB4C
U2004 U2005 = 7SH08
U3000 = NCT3522U_BGM
U3001-U3003 U3005 U4101 = NCT3522U_BGM_0
U3007 = PS8331B_13
U3008-U3010 U3606 U3607 = 74LVC1G3157GW_6P_BGM
U3011 = IMISM530_4
U3201 = NCT3522U_BGM_1
U3600 = CX8400-11Z_60P_BGM
U3601 = HPA022642RTJR
U3602 U3603 = PS8339A_1
U4000 = 82579LM_1
U4001 = NS680016_3
U4100 = AC-9560_152P_V02_BGM
U4102 U4103 = 74LVC1G32GW_5P_BGM
U4200 U7003 U7004 = BD82047FVJ-GE2_BGM_0
U6001 = NPCX797HA0BX_144P_BGM
U6002 = IMISM530_2
U6003 = 74LVC2G07GW_BGM
U6004 = G2129BAJ1U_8P_BGM
U6202 = W25Q256JVEIQ_8P_BGM_1
U6203 = SST25LF080A_0
U6204 = W25Q256JVEIQ_8P_BGM
U6300 U6301 = 7SHC00_0
U6401 = LM86
U6402 = LM86_0
U6500 = SLB9670VQ_BGM
U7000-U7002 = PUSB3FR4
U7005 = G995_0
U7112 U7113 = NX5P3290AUK_16P_BGM
U7300 = IC_AU9540-GBS_SSOP_0
U7301 = RTS5258S-GRT_32P_BGM
U8000 = W25Q80DV_1
U8001 = Titan Ridge for Host_0
U8500 = CCG5_0
U9001 = CPU_CFL_H_1440P_BGM
U9002 = PCH_CFL_H_874P_BGM
U9500 = HP2DCTR_BGM
U12005 = MC74VHC1G08DFT2G_5P_BGM
U12006 = PS8209_0
VRAM2500-VRAM2503 = 23CNOPN001
Y2000 Y8000 = CRYSTAL_4P_BGM
Y4000 = CRYSTAL2_2
Y7300 = XTAL TSX-3225 EPSONTOYO _0
Y9000 = CRYSTAL2_0
Y9001 = CRYSTAL_2P_BGM

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
10P8R
  rect 0.305x1.092 smd: 1(-1.27,-0.85) 2(-0.635,-0.85) 3(0,-0.85) 4(0.635,-0.85) 5(1.27,-0.85) 6(1.27,0.85) 7(0.635,0.85) 8(0,0.85) 9(-0.635,0.85) 10(-1.27,0.85)
50207-00471-001-4P-L-SMT
  rect 0.508x0.991 smd: 1(-1.2,1.45) 2(-0.4,1.45) 3(0.4,1.45) 4(1.2,1.45)
  rect 1.194x1.499 smd: 5(-2.5,0.102) 6(2.5,0.102)
50273-0040N-V09-4P-L
  rect 0.787x1.6 smd: 1(-1.875,2.9) 2(-0.625,2.9) 3(0.625,2.9) 4(1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
50506-01501-V01-15P-L
  rect 0.305x0.889 smd: 1(-3.5,3.05) 2(-3,3.05) 3(-2.5,3.05) 4(-2,3.05) 5(-1.5,3.05) 6(-1,3.05) 7(-0.5,3.05) 8(0,3.05) 9(0.5,3.05) 10(1,3.05) 11(1.5,3.05) 12(2,3.05) 13(2.5,3.05) 14(3,3.05) 15(3.5,3.05)
  rect 0.991x2.007 smd: 16(-5.6,0) 17(5.6,0)
50524-01001-001-10P-L
  rect 0.305x1.295 smd: 1(-4.5,5.65) 2(-3.5,5.65) 3(-2.5,5.65) 4(-1.5,5.65) 5(-0.5,5.65) 6(0.5,5.65) 7(1.5,5.65) 8(2.5,5.65) 9(3.5,5.65) 10(4.5,5.65)
  rect 1.803x2.21 smd: 11(-7.15,0) 12(7.15,0)
50950-0084N-001-8P-SOCKET
  round 0.838 hole 0.838 unplated: (2.5,-2)
  round 1.041 hole 1.041 unplated: (2.5,2)
  rect 0.838x1.397 smd: 1(-1.905,-4.8) 2(-0.635,-4.8) 3(0.635,-4.8) 4(1.905,-4.8) 5(1.905,4.8) 6(0.635,4.8) 7(-0.635,4.8) 8(-1.905,4.8)
50951-0084N-001-8P-SOCKET
  round 0.889 hole 0.889 unplated: (0,-2)
  round 1.092 hole 1.092 unplated: (0,2)
  rect 0.66x1.346 smd: 1(-3.905,-3.825) 2(-2.635,-3.825) 3(-1.365,-3.825) 4(-0.095,-3.825) 5(-0.095,3.825) 6(-1.365,3.825) 7(-2.635,3.825) 8(-3.905,3.825)
51619-00801-V03-8P-L
  rect 0.305x1.295 smd: 1(-1.75,2.8) 2(-1.25,2.8) 3(-0.75,2.8) 4(-0.25,2.8) 5(0.25,2.8) 6(0.75,2.8) 7(1.25,2.8) 8(1.75,2.8)
  rect 1.803x1.397 smd: 9(-3.4,0) 10(3.4,0)
51653-00401-V01-4P-L
  rect 0.305x1.295 smd: 1(-1.5,2.65) 2(-0.5,2.65) 3(0.5,2.65) 4(1.5,2.65)
  rect 1.803x1.397 smd: 5(-3.65,0) 6(3.65,0)
51697-0420M-001-42P-L
  rect 0.305x1.245 smd: 1(-10.25,3.275) 2(-9.75,3.275) 3(-9.25,3.275) 4(-8.75,3.275) 5(-8.25,3.275) 6(-7.75,3.275) 7(-7.25,3.275) 8(-6.75,3.275) 9(-6.25,3.275) 10(-5.75,3.275) 11(-5.25,3.275) 12(-4.75,3.275) 13(-4.25,3.275) 14(-3.75,3.275) 15(-3.25,3.275) 16(-2.75,3.275) 17(-2.25,3.275) 18(-1.75,3.275) 19(-1.25,3.275) 20(-0.75,3.275) 21(-0.25,3.275) 22(0.25,3.275) 23(0.75,3.275) 24(1.25,3.275) 25(1.75,3.275) 26(2.25,3.275) 27(2.75,3.275) 28(3.25,3.275) 29(3.75,3.275) 30(4.25,3.275) 31(4.75,3.275) 32(5.25,3.275) 33(5.75,3.275) 34(6.25,3.275) 35(6.75,3.275) 36(7.25,3.275) 37(7.75,3.275) 38(8.25,3.275) 39(8.75,3.275) 40(9.25,3.275) 41(9.75,3.275) 42(10.25,3.275)
  rect 1.397x1.194 smd: 43(-12.705,0) 44(12.705,0)
88511-180N-18P-L
  rect 0.305x1.295 smd: 1(-4.25,2.8) 2(-3.75,2.8) 3(-3.25,2.8) 4(-2.75,2.8) 5(-2.25,2.8) 6(-1.75,2.8) 7(-1.25,2.8) 8(-0.75,2.8) 9(-0.25,2.8) 10(0.25,2.8) 11(0.75,2.8) 12(1.25,2.8) 13(1.75,2.8) 14(2.25,2.8) 15(2.75,2.8) 16(3.25,2.8) 17(3.75,2.8) 18(4.25,2.8)
  rect 1.803x1.397 smd: 19(-5.9,0) 20(5.9,0)
AUDIO-2SJ3088-027211F-6P
  round 1.194 hole 1.194 unplated: (0,0)
  oval 0.991x1.803 hole 0.61x1.397: 1(3.8,3.1) 2(-3.7,-2.65) 3(3.7,-4.75) 4(-4.6,-4.75) 5(-2.2,3.1) 6(-3.8,3.1)
  oval 0.991x1.905 hole 0.61x1.499: 7(4.6,-1.1) 8(-4.6,-0.1)
BAT-C144RN-K0823-L-8P-L-SMT
  round 1.6 hole 0.991: 1(-7,0) 2(-5,0) 3(-3,0) 4(-1,0) 5(1,0) 6(3,0) 7(5,0) 8(7,0)
  oval 1.6x3.404 hole 0.991x2.794: 9(-10.125,0) 10(10.125,0)
BGA16-NXP-NX5P3290A
  round 0.254 smd: A1(-0.75,-0.75) A2(-0.75,-0.25) A3(-0.75,0.25) A4(-0.75,0.75) B1(-0.25,-0.75) B2(-0.25,-0.25) B3(-0.25,0.25) B4(-0.25,0.75) C1(0.25,-0.75) C2(0.25,-0.25) C3(0.25,0.25) C4(0.25,0.75) D1(0.75,-0.75) D2(0.75,-0.25) D3(0.75,0.25) D4(0.75,0.75)
BGA49-NXP-TFA9891
  round 0.254 smd: A1(-1.21,-0.965) A2(-1.21,-0.565) A3(-1.21,-0.165) A4(-1.21,0.235) A5(-1.21,0.635) A6(-1.21,1.035) A7(-1.21,1.435) B1(-0.81,-0.965) B2(-0.81,-0.565) B3(-0.81,-0.165) B4(-0.81,0.235) B5(-0.81,0.635) B6(-0.81,1.035) B7(-0.81,1.435) C1(-0.41,-0.965) C2(-0.41,-0.565) C3(-0.41,-0.165) C4(-0.41,0.235) C5(-0.41,0.635) C6(-0.41,1.035) C7(-0.41,1.435) D1(-0.01,-0.965) D2(-0.01,-0.565) D3(-0.01,-0.165) D4(-0.01,0.235) D5(-0.01,0.635) D6(-0.01,1.035) D7(-0.01,1.435) E1(0.39,-0.965) E2(0.39,-0.565) E3(0.39,-0.165) E4(0.39,0.235) E5(0.39,0.635) E6(0.39,1.035) E7(0.39,1.435) F1(0.79,-0.965) F2(0.79,-0.565) F3(0.79,-0.165) F4(0.79,0.235) F5(0.79,0.635) F6(0.79,1.035) F7(0.79,1.435) G1(1.19,-0.965) G2(1.19,-0.565) G3(1.19,-0.165) G4(1.19,0.235) G5(1.19,0.635) G6(1.19,1.035) G7(1.19,1.435)
BGA96-TEXAS-TPS65982
  round 0.254 smd: A1(-2.5,-2.5) A2(-2.5,-2) A3(-2.5,-1.5) A4(-2.5,-1) A5(-2.5,-0.5) A6(-2.5,0) A7(-2.5,0.5) A8(-2.5,1) A9(-2.5,1.5) A10(-2.5,2) A11(-2.5,2.5) B1(-2,-2.5) B2(-2,-2) B3(-2,-1.5) B4(-2,-1) B5(-2,-0.5) B6(-2,0) B7(-2,0.5) B8(-2,1) B9(-2,1.5) B10(-2,2) B11(-2,2.5) C1(-1.5,-2.5) C2(-1.5,-2) C10(-1.5,2) C11(-1.5,2.5) D1(-1,-2.5) D2(-1,-2) D5(-1,-0.5) D6(-1,0) D7(-1,0.5) D8(-1,1) D10(-1,2) D11(-1,2.5) E1(-0.5,-2.5) E2(-0.5,-2) E4(-0.5,-1) E5(-0.5,-0.5) E6(-0.5,0) E7(-0.5,0.5) E8(-0.5,1) E10(-0.5,2) E11(-0.5,2.5) F1(0,-2.5) F2(0,-2) F4(0,-1) F5(0,-0.5) F6(0,0) F7(0,0.5) F8(0,1) F10(0,2) F11(0,2.5) G1(0.5,-2.5) G2(0.5,-2) G4(0.5,-1) G5(0.5,-0.5) G6(0.5,0) G7(0.5,0.5) G8(0.5,1) G10(0.5,2) G11(0.5,2.5) H1(1,-2.5) H2(1,-2) H4(1,-1) H5(1,-0.5) H6(1,0) H7(1,0.5) H8(1,1) H10(1,2) H11(1,2.5) J1(1.5,-2.5) J2(1.5,-2) J10(1.5,2) J11(1.5,2.5) K1(2,-2.5) K2(2,-2) K3(2,-1.5) K4(2,-1) K5(2,-0.5) K6(2,0) K7(2,0.5) K8(2,1) K9(2,1.5) K10(2,2) K11(2,2.5) L1(2.5,-2.5) L2(2.5,-2) L3(2.5,-1.5) L4(2.5,-1) L5(2.5,-0.5) L6(2.5,0) L7(2.5,0.5) L8(2.5,1) L9(2.5,1.5) L10(2.5,2) L11(2.5,2.5)
BGA144-NUVOTON-NPCX797H
  round 0.356 smd: A1(-3.575,-3.575) A2(-3.575,-2.925) A3(-3.575,-2.275) A4(-3.575,-1.625) A5(-3.575,-0.975) A6(-3.575,-0.325) A7(-3.575,0.325) A8(-3.575,0.975) A9(-3.575,1.625) A10(-3.575,2.275) A11(-3.575,2.925) A12(-3.575,3.575) B1(-2.925,-3.575) B2(-2.925,-2.925) B3(-2.925,-2.275) B4(-2.925,-1.625) B5(-2.925,-0.975) B6(-2.925,-0.325) B7(-2.925,0.325) B8(-2.925,0.975) B9(-2.925,1.625) B10(-2.925,2.275) B11(-2.925,2.925) B12(-2.925,3.575) C1(-2.275,-3.575) C2(-2.275,-2.925) C3(-2.275,-2.275) C4(-2.275,-1.625) C5(-2.275,-0.975) C6(-2.275,-0.325) C7(-2.275,0.325) C8(-2.275,0.975) C9(-2.275,1.625) C10(-2.275,2.275) C11(-2.275,2.925) C12(-2.275,3.575) D1(-1.625,-3.575) D2(-1.625,-2.925) D3(-1.625,-2.275) D4(-1.625,-1.625) D5(-1.625,-0.975) D6(-1.625,-0.325) D7(-1.625,0.325) D8(-1.625,0.975) D9(-1.625,1.625) D10(-1.625,2.275) D11(-1.625,2.925) D12(-1.625,3.575) E1(-0.975,-3.575) E2(-0.975,-2.925) E3(-0.975,-2.275) E4(-0.975,-1.625) E5(-0.975,-0.975) E6(-0.975,-0.325) E7(-0.975,0.325) E8(-0.975,0.975) E9(-0.975,1.625) E10(-0.975,2.275) E11(-0.975,2.925) E12(-0.975,3.575) F1(-0.325,-3.575) F2(-0.325,-2.925) F3(-0.325,-2.275) F4(-0.325,-1.625) F5(-0.325,-0.975) F6(-0.325,-0.325) F7(-0.325,0.325) F8(-0.325,0.975) F9(-0.325,1.625) F10(-0.325,2.275) F11(-0.325,2.925) F12(-0.325,3.575) G1(0.325,-3.575) G2(0.325,-2.925) G3(0.325,-2.275) G4(0.325,-1.625) G5(0.325,-0.975) G6(0.325,-0.325) G7(0.325,0.325) G8(0.325,0.975) G9(0.325,1.625) G10(0.325,2.275) G11(0.325,2.925) G12(0.325,3.575) H1(0.975,-3.575) H2(0.975,-2.925) H3(0.975,-2.275) H4(0.975,-1.625) H5(0.975,-0.975) H6(0.975,-0.325) H7(0.975,0.325) H8(0.975,0.975) H9(0.975,1.625) H10(0.975,2.275) H11(0.975,2.925) H12(0.975,3.575) J1(1.625,-3.575) J2(1.625,-2.925) J3(1.625,-2.275) J4(1.625,-1.625) J5(1.625,-0.975) J6(1.625,-0.325) J7(1.625,0.325) J8(1.625,0.975) J9(1.625,1.625) J10(1.625,2.275) J11(1.625,2.925) J12(1.625,3.575) K1(2.275,-3.575) K2(2.275,-2.925) K3(2.275,-2.275) K4(2.275,-1.625) K5(2.275,-0.975) K6(2.275,-0.325) K7(2.275,0.325) K8(2.275,0.975) K9(2.275,1.625) K10(2.275,2.275) K11(2.275,2.925) K12(2.275,3.575) L1(2.925,-3.575) L2(2.925,-2.925) L3(2.925,-2.275) L4(2.925,-1.625) L5(2.925,-0.975) L6(2.925,-0.325) L7(2.925,0.325) L8(2.925,0.975) L9(2.925,1.625) L10(2.925,2.275) L11(2.925,2.925) L12(2.925,3.575) M1(3.575,-3.575) M2(3.575,-2.925) M3(3.575,-2.275) M4(3.575,-1.625) M5(3.575,-0.975) M6(3.575,-0.325) M7(3.575,0.325) M8(3.575,0.975) M9(3.575,1.625) M10(3.575,2.275) M11(3.575,2.925) M12(3.575,3.575)
BGA170-HYNIX-H5GQ1H24MJR
  round 0.356 smd: A1(-6.4,-5.2) A2(-6.4,-4.4) A3(-6.4,-3.6) A4(-6.4,-2.8) A5(-6.4,-2) A10(-6.4,2) A11(-6.4,2.8) A12(-6.4,3.6) A13(-6.4,4.4) A14(-6.4,5.2) B1(-5.6,-5.2) B2(-5.6,-4.4) B3(-5.6,-3.6) B4(-5.6,-2.8) B5(-5.6,-2) B10(-5.6,2) B11(-5.6,2.8) B12(-5.6,3.6) B13(-5.6,4.4) B14(-5.6,5.2) C1(-4.8,-5.2) C2(-4.8,-4.4) C3(-4.8,-3.6) C4(-4.8,-2.8) C5(-4.8,-2) C10(-4.8,2) C11(-4.8,2.8) C12(-4.8,3.6) C13(-4.8,4.4) C14(-4.8,5.2) D1(-4,-5.2) D2(-4,-4.4) D3(-4,-3.6) D4(-4,-2.8) D5(-4,-2) D10(-4,2) D11(-4,2.8) D12(-4,3.6) D13(-4,4.4) D14(-4,5.2) E1(-3.2,-5.2) E2(-3.2,-4.4) E3(-3.2,-3.6) E4(-3.2,-2.8) E5(-3.2,-2) E10(-3.2,2) E11(-3.2,2.8) E12(-3.2,3.6) E13(-3.2,4.4) E14(-3.2,5.2) F1(-2.4,-5.2) F2(-2.4,-4.4) F3(-2.4,-3.6) F4(-2.4,-2.8) F5(-2.4,-2) F10(-2.4,2) F11(-2.4,2.8) F12(-2.4,3.6) F13(-2.4,4.4) F14(-2.4,5.2) G1(-1.6,-5.2) G2(-1.6,-4.4) G3(-1.6,-3.6) G4(-1.6,-2.8) G5(-1.6,-2) G10(-1.6,2) G11(-1.6,2.8) G12(-1.6,3.6) G13(-1.6,4.4) G14(-1.6,5.2) H1(-0.8,-5.2) H2(-0.8,-4.4) H3(-0.8,-3.6) H4(-0.8,-2.8) H5(-0.8,-2) H10(-0.8,2) H11(-0.8,2.8) H12(-0.8,3.6) H13(-0.8,4.4) H14(-0.8,5.2) J1(0,-5.2) J2(0,-4.4) J3(0,-3.6) J4(0,-2.8) J5(0,-2) J10(0,2) J11(0,2.8) J12(0,3.6) J13(0,4.4) J14(0,5.2) K1(0.8,-5.2) K2(0.8,-4.4) K3(0.8,-3.6) K4(0.8,-2.8) K5(0.8,-2) K10(0.8,2) K11(0.8,2.8) K12(0.8,3.6) K13(0.8,4.4) K14(0.8,5.2) L1(1.6,-5.2) L2(1.6,-4.4) L3(1.6,-3.6) L4(1.6,-2.8) L5(1.6,-2) L10(1.6,2) L11(1.6,2.8) L12(1.6,3.6) L13(1.6,4.4) L14(1.6,5.2) M1(2.4,-5.2) M2(2.4,-4.4) M3(2.4,-3.6) M4(2.4,-2.8) M5(2.4,-2) M10(2.4,2) M11(2.4,2.8) M12(2.4,3.6) M13(2.4,4.4) M14(2.4,5.2) N1(3.2,-5.2) N2(3.2,-4.4) N3(3.2,-3.6) N4(3.2,-2.8) N5(3.2,-2) N10(3.2,2) N11(3.2,2.8) N12(3.2,3.6) N13(3.2,4.4) N14(3.2,5.2) P1(4,-5.2) P2(4,-4.4) P3(4,-3.6) P4(4,-2.8) P5(4,-2) P10(4,2) P11(4,2.8) P12(4,3.6) P13(4,4.4) P14(4,5.2) R1(4.8,-5.2) R2(4.8,-4.4) R3(4.8,-3.6) R4(4.8,-2.8) R5(4.8,-2) R10(4.8,2) R11(4.8,2.8) R12(4.8,3.6) R13(4.8,4.4) R14(4.8,5.2) T1(5.6,-5.2) T2(5.6,-4.4) T3(5.6,-3.6) T4(5.6,-2.8) T5(5.6,-2) T10(5.6,2) T11(5.6,2.8) T12(5.6,3.6) T13(5.6,4.4) T14(5.6,5.2) U1(6.4,-5.2) U2(6.4,-4.4) U3(6.4,-3.6) U4(6.4,-2.8) U5(6.4,-2) U10(6.4,2) U11(6.4,2.8) U12(6.4,3.6) U13(6.4,4.4) U14(6.4,5.2)
BGA337-INTEL-DSL6540
  round 0.254 smd: A1(-5.06,-5.06) A23(-5.06,5.06) AA2(4.14,-4.6) AA22(4.14,4.6) AB2(4.6,-4.6) AB3(4.6,-4.14) AB4(4.6,-3.68) AB5(4.6,-3.22) AB6(4.6,-2.76) AB7(4.6,-2.3) AB8(4.6,-1.84) AB9(4.6,-1.38) AB10(4.6,-0.92) AB11(4.6,-0.46) AB12(4.6,0) AB13(4.6,0.46) AB14(4.6,0.92) AB15(4.6,1.38) AB16(4.6,1.84) AB17(4.6,2.3) AB18(4.6,2.76) AB19(4.6,3.22) AB20(4.6,3.68) AB21(4.6,4.14) AB22(4.6,4.6) AC1(5.06,-5.06) AC23(5.06,5.06) B2(-4.6,-4.6) B3(-4.6,-4.14) B4(-4.6,-3.68) B5(-4.6,-3.22) B6(-4.6,-2.76) B7(-4.6,-2.3) B8(-4.6,-1.84) B9(-4.6,-1.38) B10(-4.6,-0.92) B11(-4.6,-0.46) B12(-4.6,0) B13(-4.6,0.46) B14(-4.6,0.92) B15(-4.6,1.38) B16(-4.6,1.84) B17(-4.6,2.3) B18(-4.6,2.76) B19(-4.6,3.22) B20(-4.6,3.68) B21(-4.6,4.14) B22(-4.6,4.6) C2(-4.14,-4.6) C22(-4.14,4.6) D2(-3.68,-4.6) D4(-3.9,-3.9) D5(-3.9,-3.25) D6(-3.9,-2.6) D8(-3.9,-1.95) D9(-3.9,-1.3) D11(-3.9,-0.65) D12(-3.9,0) D13(-3.9,0.65) D15(-3.9,1.3) D16(-3.9,1.95) D18(-3.9,2.6) D19(-3.9,3.25) D20(-3.9,3.9) D22(-3.68,4.6) E2(-3.22,-4.6) E4(-3.25,-3.9) E5(-3.25,-3.25) E6(-3.25,-2.6) E8(-3.25,-1.95) E9(-3.25,-1.3) E11(-3.25,-0.65) E12(-3.25,0) E13(-3.25,0.65) E15(-3.25,1.3) E16(-3.25,1.95) E18(-3.25,2.6) E19(-3.25,3.25) E20(-3.25,3.9) E22(-3.22,4.6) F2(-2.76,-4.6) F4(-2.6,-3.9) F5(-2.6,-3.25) F6(-2.6,-2.6) F8(-2.6,-1.95) F9(-2.6,-1.3) F11(-2.6,-0.65) F12(-2.6,0) F13(-2.6,0.65) F15(-2.6,1.3) F16(-2.6,1.95) F18(-2.6,2.6) F19(-2.6,3.25) F20(-2.6,3.9) F22(-2.76,4.6) G2(-2.3,-4.6) G22(-2.3,4.6) H2(-1.84,-4.6) H4(-1.95,-3.9) H5(-1.95,-3.25) H6(-1.95,-2.6) H8(-1.95,-1.95) H9(-1.95,-1.3) H11(-1.95,-0.65) H12(-1.95,0) H13(-1.95,0.65) H15(-1.95,1.3) H16(-1.95,1.95) H18(-1.95,2.6) H19(-1.95,3.25) H20(-1.95,3.9) H22(-1.84,4.6) J2(-1.38,-4.6) J4(-1.3,-3.9) J5(-1.3,-3.25) J6(-1.3,-2.6) J8(-1.3,-1.95) J9(-1.3,-1.3) J11(-1.3,-0.65) J12(-1.3,0) J13(-1.3,0.65) J15(-1.3,1.3) J16(-1.3,1.95) J18(-1.3,2.6) J19(-1.3,3.25) J20(-1.3,3.9) J22(-1.38,4.6) K2(-0.92,-4.6) K22(-0.92,4.6) L2(-0.46,-4.6) L4(-0.65,-3.9) L5(-0.65,-3.25) L6(-0.65,-2.6) L8(-0.65,-1.95) L9(-0.65,-1.3) L11(-0.65,-0.65) L12(-0.65,0) L13(-0.65,0.65) L15(-0.65,1.3) L16(-0.65,1.95) L18(-0.65,2.6) L19(-0.65,3.25) L20(-0.65,3.9) L22(-0.46,4.6) M2(0,-4.6) M4(0,-3.9) M5(0,-3.25) M6(0,-2.6) M8(0,-1.95) M9(0,-1.3) M11(0,-0.65) M12(0,0) M13(0,0.65) M15(0,1.3) M16(0,1.95) M18(0,2.6) M19(0,3.25) M20(0,3.9) M22(0,4.6) N2(0.46,-4.6) N4(0.65,-3.9) N5(0.65,-3.25) N6(0.65,-2.6) N8(0.65,-1.95) N9(0.65,-1.3) N11(0.65,-0.65) N12(0.65,0) N13(0.65,0.65) N15(0.65,1.3) N16(0.65,1.95) N18(0.65,2.6) N19(0.65,3.25) N20(0.65,3.9) N22(0.46,4.6) P2(0.92,-4.6) P22(0.92,4.6) R2(1.38,-4.6) R4(1.3,-3.9) R5(1.3,-3.25) R6(1.3,-2.6) R8(1.3,-1.95) R9(1.3,-1.3) R11(1.3,-0.65) R12(1.3,0) R13(1.3,0.65) R15(1.3,1.3) R16(1.3,1.95) R18(1.3,2.6) R19(1.3,3.25) R20(1.3,3.9) R22(1.38,4.6) T2(1.84,-4.6) T4(1.95,-3.9) T5(1.95,-3.25) T6(1.95,-2.6) T8(1.95,-1.95) T9(1.95,-1.3) T11(1.95,-0.65) T12(1.95,0) T13(1.95,0.65) T15(1.95,1.3) T16(1.95,1.95) T18(1.95,2.6) T19(1.95,3.25) T20(1.95,3.9) T22(1.84,4.6) U2(2.3,-4.6) U22(2.3,4.6) V2(2.76,-4.6) V4(2.6,-3.9) V5(2.6,-3.25) V6(2.6,-2.6) V8(2.6,-1.95) V9(2.6,-1.3) V11(2.6,-0.65) V12(2.6,0) V13(2.6,0.65) V15(2.6,1.3) V16(2.6,1.95) V18(2.6,2.6) V19(2.6,3.25) V20(2.6,3.9) V22(2.76,4.6) W2(3.22,-4.6) W4(3.25,-3.9) W5(3.25,-3.25) W6(3.25,-2.6) W8(3.25,-1.95) W9(3.25,-1.3) W11(3.25,-0.65) W12(3.25,0) W13(3.25,0.65) W15(3.25,1.3) W16(3.25,1.95) W18(3.25,2.6) W19(3.25,3.25) W20(3.25,3.9) W22(3.22,4.6) Y2(3.68,-4.6) Y4(3.9,-3.9) Y5(3.9,-3.25) Y6(3.9,-2.6) Y8(3.9,-1.95) Y9(3.9,-1.3) Y11(3.9,-0.65) Y12(3.9,0) Y13(3.9,0.65) Y15(3.9,1.3) Y16(3.9,1.95) Y18(3.9,2.6) Y19(3.9,3.25) Y20(3.9,3.9) Y22(3.68,4.6)
  oval 0.33x0.178 smd: A2(-5.06,-4.6) A3(-5.06,-4.14) A4(-5.06,-3.68) A5(-5.06,-3.22) A6(-5.06,-2.76) A7(-5.06,-2.3) A8(-5.06,-1.84) A9(-5.06,-1.38) A10(-5.06,-0.92) A11(-5.06,-0.46) A12(-5.06,0) A13(-5.06,0.46) A14(-5.06,0.92) A15(-5.06,1.38) A16(-5.06,1.84) A17(-5.06,2.3) A18(-5.06,2.76) A19(-5.06,3.22) A20(-5.06,3.68) A21(-5.06,4.14) A22(-5.06,4.6) AC2(5.06,-4.6) AC3(5.06,-4.14) AC4(5.06,-3.68) AC5(5.06,-3.22) AC6(5.06,-2.76) AC7(5.06,-2.3) AC8(5.06,-1.84) AC9(5.06,-1.38) AC10(5.06,-0.92) AC11(5.06,-0.46) AC12(5.06,0) AC13(5.06,0.46) AC14(5.06,0.92) AC15(5.06,1.38) AC16(5.06,1.84) AC17(5.06,2.3) AC18(5.06,2.76) AC19(5.06,3.22) AC20(5.06,3.68) AC21(5.06,4.14) AC22(5.06,4.6)
  oval 0.178x0.33 smd: AA1(4.14,-5.06) AA23(4.14,5.06) AB1(4.6,-5.06) AB23(4.6,5.06) B1(-4.6,-5.06) B23(-4.6,5.06) C1(-4.14,-5.06) C23(-4.14,5.06) D1(-3.68,-5.06) D23(-3.68,5.06) E1(-3.22,-5.06) E23(-3.22,5.06) F1(-2.76,-5.06) F23(-2.76,5.06) G1(-2.3,-5.06) G23(-2.3,5.06) H1(-1.84,-5.06) H23(-1.84,5.06) J1(-1.38,-5.06) J23(-1.38,5.06) K1(-0.92,-5.06) K23(-0.92,5.06) L1(-0.46,-5.06) L23(-0.46,5.06) M1(0,-5.06) M23(0,5.06) N1(0.46,-5.06) N23(0.46,5.06) P1(0.92,-5.06) P23(0.92,5.06) R1(1.38,-5.06) R23(1.38,5.06) T1(1.84,-5.06) T23(1.84,5.06) U1(2.3,-5.06) U23(2.3,5.06) V1(2.76,-5.06) V23(2.76,5.06) W1(3.22,-5.06) W23(3.22,5.06) Y1(3.68,-5.06) Y23(3.68,5.06)
BGA874-INTEL-CNL-PCH-H
  round 0.305 smd: A2(-11.314,-11.46) A3(-11.314,-10.959) A4(-11.314,-10.459) A46(-11.314,10.459) A47(-11.314,10.959) A48(-11.314,11.46) AA19(-1.549,-3.099) AA20(-1.549,-2.324) AA22(-1.549,-1.549) AA23(-1.549,-0.775) AA25(-1.549,0) AA27(-1.549,0.775) AA28(-1.549,1.549) AA30(-1.549,2.324) AA31(-1.549,3.099) AB19(-0.775,-3.099) AB20(-0.775,-2.324) AB22(-0.775,-1.549) AB23(-0.775,-0.775) AB25(-0.775,0) AB27(-0.775,0.775) AB28(-0.775,1.549) AB30(-0.775,2.324) AB31(-0.775,3.099) AC6(-0.579,-9.374) AC7(-0.579,-8.612) AC9(-0.579,-7.85) AC11(-0.579,-7.088) AC12(-0.579,-6.326) AC14(-0.579,-5.564) AC15(-0.579,-4.802) AC17(-0.579,-4.04) AC33(-0.579,4.04) AC35(-0.579,4.802) AC36(-0.579,5.564) AC38(-0.579,6.326) AC39(-0.579,7.088) AC41(-0.579,7.85) AC43(-0.579,8.612) AC44(-0.579,9.374) AD19(0,-3.099) AD20(0,-2.324) AD22(0,-1.549) AD23(0,-0.775) AD25(0,0) AD27(0,0.775) AD28(0,1.549) AD30(0,2.324) AD31(0,3.099) AE6(0.579,-9.374) AE7(0.579,-8.612) AE9(0.579,-7.85) AE11(0.579,-7.088) AE12(0.579,-6.326) AE14(0.579,-5.564) AE15(0.579,-4.802) AE17(0.579,-4.04) AE33(0.579,4.04) AE35(0.579,4.802) AE36(0.579,5.564) AE38(0.579,6.326) AE39(0.579,7.088) AE41(0.579,7.85) AE43(0.579,8.612) AE44(0.579,9.374) AF19(0.775,-3.099) AF20(0.775,-2.324) AF22(0.775,-1.549) AF23(0.775,-0.775) AF25(0.775,0) AF27(0.775,0.775) AF28(0.775,1.549) AF30(0.775,2.324) AF31(0.775,3.099) AG19(1.549,-3.099) AG20(1.549,-2.324) AG22(1.549,-1.549) AG23(1.549,-0.775) AG25(1.549,0) AG27(1.549,0.775) AG28(1.549,1.549) AG30(1.549,2.324) AG31(1.549,3.099) AH9(2.205,-7.919) AH10(2.014,-7.18) AH12(2.014,-6.402) AH14(2.014,-5.564) AH15(2.014,-4.789) AH17(2.014,-4.027) AH33(2.014,4.027) AH35(2.014,4.789) AH36(2.014,5.564) AH38(2.014,6.402) AH40(2.014,7.18) AH41(2.205,7.919) AJ6(2.586,-9.397) AJ7(2.395,-8.658) AJ19(2.324,-3.099) AJ20(2.324,-2.324) AJ22(2.324,-1.549) AJ23(2.324,-0.775) AJ25(2.324,0) AJ27(2.324,0.775) AJ28(2.324,1.549) AJ30(2.324,2.324) AJ31(2.324,3.099) AJ43(2.395,8.658) AJ44(2.586,9.397) AK19(3.099,-3.099) AK20(3.099,-2.324) AK22(3.099,-1.549) AK23(3.099,-0.775) AK25(3.099,0) AK27(3.099,0.775) AK28(3.099,1.549) AK30(3.099,2.324) AK31(3.099,3.099) AL9(3.495,-7.914) AL10(3.259,-7.181) AL12(3.259,-6.419) AL13(3.259,-5.657) AL15(3.259,-4.895) AL17(3.259,-4.133) AL21(3.578,-2.014) AL24(3.591,-0.579) AL26(3.591,0.579) AL29(3.578,2.014) AL33(3.259,4.133) AL35(3.259,4.895) AL37(3.259,5.657) AL38(3.259,6.419) AL40(3.259,7.181) AL41(3.495,7.914) AM7(3.843,-8.635) AM18(3.683,-3.259) AM32(3.683,3.259) AM43(3.843,8.635) AN6(4.224,-9.295) AN10(4.656,-7.181) AN12(4.351,-6.444) AN13(4.351,-5.682) AN15(4.351,-4.92) AN16(4.394,-4.351) AN18(4.394,-3.259) AN21(4.289,-2.014) AN24(4.302,-0.579) AN26(4.302,0.579) AN29(4.289,2.014) AN32(4.394,3.259) AN34(4.394,4.351) AN35(4.351,4.92) AN37(4.351,5.682) AN38(4.351,6.444) AN40(4.656,7.181) AN44(4.224,9.295) AP9(4.968,-7.914) AP21(5.064,-2.014) AP24(5.064,-0.579) AP26(5.064,0.579) AP29(5.064,2.014) AP41(4.968,7.914) AR8(5.469,-8.508) AR12(5.443,-6.444) AR13(5.443,-5.682) AR15(5.443,-4.92) AR16(5.182,-4.351) AR18(5.156,-3.259) AR32(5.156,3.259) AR34(5.182,4.351) AR35(5.443,4.92) AR37(5.443,5.682) AR38(5.443,6.444) AR42(5.469,8.508) AT6(5.659,-9.295) AT10(5.773,-7.181) AT16(5.944,-4.351) AT18(5.918,-3.259) AT21(5.902,-2.014) AT24(5.826,-0.579) AT26(5.826,0.579) AT29(5.902,2.014) AT32(5.918,3.259) AT34(5.944,4.351) AT40(5.773,7.181) AT44(5.659,9.295) AU9(6.416,-7.914) AU24(6.588,-0.579) AU26(6.588,0.579) AU41(6.416,7.914) AV6(7.094,-9.295) AV7(6.764,-8.597) AV11(6.975,-7.079) AV13(6.757,-5.748) AV16(6.719,-4.656) AV18(6.68,-3.259) AV21(6.679,-2.014) AV29(6.679,2.014) AV32(6.68,3.259) AV34(6.719,4.656) AV37(6.757,5.748) AV39(6.975,7.079) AV43(6.764,8.597) AV44(7.094,9.295) AW9(7.577,-7.824) AW10(7.509,-7.262) AW13(7.49,-6.01) AW15(7.452,-4.892) AW18(7.413,-3.495) AW21(7.419,-2.205) AW24(7.35,-0.579) AW26(7.35,0.579) AW29(7.419,2.205) AW32(7.413,3.495) AW35(7.452,4.892) AW37(7.49,6.01) AW40(7.509,7.262) AW41(7.577,7.824) AY8(7.898,-8.533) AY42(7.898,8.533) B1(-10.96,-11.814) B2(-10.83,-11.33) B3(-10.878,-10.709) B47(-10.878,10.709) B48(-10.83,11.33) B49(-10.96,11.814) BA6(8.203,-9.13) BA12(8.135,-6.485) BA14(8.135,-5.24) BA17(8.135,-3.843) BA20(8.158,-2.395) BA24(8.112,-0.579) BA26(8.112,0.579) BA30(8.158,2.395) BA33(8.135,3.843) BA36(8.135,5.24) BA38(8.135,6.485) BA44(8.203,9.13) BB6(8.706,-9.088) BB7(9,-8.589) BB9(8.774,-8.024) BB11(8.795,-6.866) BB14(8.795,-5.621) BB16(8.795,-4.224) BB20(8.897,-2.586) BB24(8.874,-0.579) BB26(8.874,0.579) BB30(8.897,2.586) BB34(8.795,4.224) BB36(8.795,5.621) BB39(8.795,6.866) BB41(8.774,8.024) BB43(9,8.589) BB44(8.706,9.088) BC5(9.254,-9.634) BC45(9.254,9.634) BD1(9.959,-11.814) BD4(9.983,-10.474) BD46(9.983,10.474) BD49(9.959,11.814) BE1(10.459,-11.814) BE2(10.196,-11.373) BE3(10.311,-10.86) BE4(10.487,-10.391) BE5(10.212,-9.965) BE45(10.212,9.965) BE46(10.487,10.391) BE47(10.311,10.86) BE48(10.196,11.373) BE49(10.459,11.814) BF1(10.96,-11.814) BF2(10.83,-11.33) BF3(10.878,-10.709) BF47(10.878,10.709) BF48(10.83,11.33) BF49(10.96,11.814) BG2(11.314,-11.46) BG3(11.314,-10.959) BG4(11.314,-10.459) BG46(11.314,10.459) BG47(11.314,10.959) BG48(11.314,11.46) C1(-10.459,-11.814) C2(-10.196,-11.373) C3(-10.311,-10.86) C4(-10.487,-10.391) C5(-10.212,-9.965) C45(-10.212,9.965) C46(-10.487,10.391) C47(-10.311,10.86) C48(-10.196,11.373) C49(-10.459,11.814) D1(-9.959,-11.814) D4(-9.983,-10.474) D46(-9.983,10.474) D49(-9.959,11.814) E5(-9.254,-9.634) E45(-9.254,9.634) F6(-8.706,-9.088) F7(-9,-8.589) F9(-8.774,-8.024) F11(-8.795,-6.866) F14(-8.795,-5.621) F16(-8.795,-4.224) F20(-8.897,-2.586) F24(-8.874,-0.579) F26(-8.874,0.579) F30(-8.897,2.586) F34(-8.795,4.224) F36(-8.795,5.621) F39(-8.795,6.866) F41(-8.774,8.024) F43(-9,8.589) F44(-8.706,9.088) G6(-8.203,-9.13) G12(-8.135,-6.485) G14(-8.135,-5.24) G17(-8.135,-3.843) G20(-8.158,-2.395) G24(-8.112,-0.579) G26(-8.112,0.579) G30(-8.158,2.395) G33(-8.135,3.843) G36(-8.135,5.24) G38(-8.135,6.485) G44(-8.203,9.13) H8(-7.898,-8.533) H42(-7.898,8.533) J9(-7.577,-7.824) J10(-7.509,-7.262) J13(-7.49,-6.01) J15(-7.452,-4.892) J18(-7.413,-3.495) J21(-7.419,-2.205) J24(-7.35,-0.579) J26(-7.35,0.579) J29(-7.419,2.205) J32(-7.413,3.495) J35(-7.452,4.892) J37(-7.49,6.01) J40(-7.509,7.262) J41(-7.577,7.824) K6(-7.094,-9.295) K7(-6.764,-8.597) K11(-6.975,-7.079) K13(-6.757,-5.748) K16(-6.719,-4.656) K18(-6.68,-3.259) K21(-6.679,-2.014) K29(-6.679,2.014) K32(-6.68,3.259) K34(-6.719,4.656) K37(-6.757,5.748) K39(-6.975,7.079) K43(-6.764,8.597) K44(-7.094,9.295) L9(-6.416,-7.914) L24(-6.588,-0.579) L26(-6.588,0.579) L41(-6.416,7.914) M6(-5.659,-9.295) M10(-5.773,-7.181) M16(-5.944,-4.351) M18(-5.918,-3.259) M21(-5.902,-2.014) M24(-5.826,-0.579) M26(-5.826,0.579) M29(-5.902,2.014) M32(-5.918,3.259) M34(-5.944,4.351) M40(-5.773,7.181) M44(-5.659,9.295) N8(-5.469,-8.508) N12(-5.443,-6.444) N13(-5.443,-5.682) N15(-5.443,-4.92) N16(-5.182,-4.351) N18(-5.156,-3.259) N32(-5.156,3.259) N34(-5.182,4.351) N35(-5.443,4.92) N37(-5.443,5.682) N38(-5.443,6.444) N42(-5.469,8.508) P9(-4.968,-7.914) P21(-5.064,-2.014) P24(-5.064,-0.579) P26(-5.064,0.579) P29(-5.064,2.014) P41(-4.968,7.914) R6(-4.224,-9.295) R10(-4.656,-7.181) R12(-4.351,-6.444) R13(-4.351,-5.682) R15(-4.351,-4.92) R16(-4.394,-4.351) R18(-4.394,-3.259) R21(-4.289,-2.014) R24(-4.302,-0.579) R26(-4.302,0.579) R29(-4.289,2.014) R32(-4.394,3.259) R34(-4.394,4.351) R35(-4.351,4.92) R37(-4.351,5.682) R38(-4.351,6.444) R40(-4.656,7.181) R44(-4.224,9.295) T7(-3.843,-8.635) T17(-3.683,-3.811) T18(-3.683,-3.259) T32(-3.683,3.259) T43(-3.843,8.635) U9(-3.495,-7.914) U10(-3.259,-7.181) U12(-3.259,-6.419) U13(-3.259,-5.657) U15(-3.259,-4.895) U17(-3.259,-4.133) U21(-3.578,-2.014) U24(-3.591,-0.579) U26(-3.591,0.579) U29(-3.578,2.014) U33(-3.259,4.133) U35(-3.259,4.895) U37(-3.259,5.657) U38(-3.259,6.419) U40(-3.259,7.181) U41(-3.495,7.914) V19(-3.099,-3.099) V20(-3.099,-2.324) V22(-3.099,-1.549) V23(-3.099,-0.775) V25(-3.099,0) V27(-3.099,0.775) V28(-3.099,1.549) V30(-3.099,2.324) V31(-3.099,3.099) W6(-2.586,-9.397) W7(-2.395,-8.658) W19(-2.324,-3.099) W20(-2.324,-2.324) W22(-2.324,-1.549) W23(-2.324,-0.775) W25(-2.324,0) W27(-2.324,0.775) W28(-2.324,1.549) W30(-2.324,2.324) W31(-2.324,3.099) W43(-2.395,8.658) W44(-2.586,9.397) Y9(-2.205,-7.919) Y10(-2.014,-7.18) Y12(-2.014,-6.402) Y14(-2.014,-5.564) Y15(-2.014,-4.789) Y17(-2.014,-4.027) Y33(-2.014,4.027) Y35(-2.014,4.789) Y36(-2.014,5.564) Y38(-2.014,6.402) Y40(-2.014,7.18) Y41(-2.205,7.919)
  round 0.279 smd: A5(-11.314,-9.958) A45(-11.314,9.958) BC1(9.458,-11.814) BC49(9.458,11.814) BG5(11.314,-9.958) BG45(11.314,9.958) E1(-9.458,-11.814) E49(-9.458,11.814)
  oval 0.254x0.203 smd: A6(-11.314,-9.399) A8(-11.314,-8.294) A42(-11.314,8.294) A44(-11.314,9.399) BD8(9.813,-8.411) BD12(9.813,-6.214) BD17(9.813,-4.017) BD21(9.813,-1.82) BD29(9.813,1.82) BD33(9.813,4.017) BD38(9.813,6.214) BD42(9.813,8.411) BE9(10.186,-7.784) BE10(10.059,-7.283) BE14(10.186,-5.587) BE15(10.059,-5.086) BE18(10.186,-3.39) BE19(10.059,-2.889) BE23(10.186,-1.193) BE24(10.059,-0.692) BE26(10.059,0.692) BE27(10.186,1.193) BE31(10.059,2.889) BE32(10.186,3.39) BE35(10.059,5.086) BE36(10.186,5.587) BE40(10.059,7.283) BE41(10.186,7.784) BG6(11.314,-9.399) BG8(11.314,-8.294) BG42(11.314,8.294) BG44(11.314,9.399) C9(-10.186,-7.784) C10(-10.059,-7.283) C14(-10.186,-5.587) C15(-10.059,-5.086) C18(-10.186,-3.39) C19(-10.059,-2.889) C23(-10.186,-1.193) C24(-10.059,-0.692) C26(-10.059,0.692) C27(-10.186,1.193) C31(-10.059,2.889) C32(-10.186,3.39) C35(-10.059,5.086) C36(-10.186,5.587) C40(-10.059,7.283) C41(-10.186,7.784) D8(-9.813,-8.411) D12(-9.813,-6.214) D17(-9.813,-4.017) D21(-9.813,-1.82) D29(-9.813,1.82) D33(-9.813,4.017) D38(-9.813,6.214) D42(-9.813,8.411)
  oval 0.254x0.152 smd: A13(-11.314,-6.072) A17(-11.314,-3.875) A22(-11.314,-1.678) A25(-11.314,0) A28(-11.314,1.678) A33(-11.314,3.875) A37(-11.314,6.072) B10(-10.603,-7.123) B12(-10.816,-6.265) B14(-10.687,-5.587) B15(-10.603,-4.926) B17(-10.816,-4.068) B18(-10.687,-3.39) B19(-10.603,-2.729) B21(-10.816,-1.871) B23(-10.687,-1.193) B24(-10.603,-0.532) B25(-10.806,0) B26(-10.603,0.532) B27(-10.687,1.193) B29(-10.816,1.871) B31(-10.603,2.729) B32(-10.687,3.39) B33(-10.816,4.068) B35(-10.603,4.926) B36(-10.687,5.587) B38(-10.816,6.265) B40(-10.603,7.123) BE11(10.118,-6.76) BE12(10.313,-6.295) BE16(10.118,-4.563) BE17(10.313,-4.098) BE20(10.118,-2.366) BE21(10.313,-1.901) BE25(10.298,0) BE29(10.313,1.901) BE30(10.118,2.366) BE33(10.313,4.098) BE34(10.118,4.563) BE38(10.313,6.295) BE39(10.118,6.76) BF10(10.603,-7.123) BF12(10.816,-6.265) BF14(10.687,-5.587) BF15(10.603,-4.926) BF17(10.816,-4.068) BF18(10.687,-3.39) BF19(10.603,-2.729) BF21(10.816,-1.871) BF23(10.687,-1.193) BF24(10.603,-0.532) BF25(10.806,0) BF26(10.603,0.532) BF27(10.687,1.193) BF29(10.816,1.871) BF31(10.603,2.729) BF32(10.687,3.39) BF33(10.816,4.068) BF35(10.603,4.926) BF36(10.687,5.587) BF38(10.816,6.265) BF40(10.603,7.123) BG13(11.314,-6.072) BG17(11.314,-3.875) BG22(11.314,-1.678) BG25(11.314,0) BG28(11.314,1.678) BG33(11.314,3.875) BG37(11.314,6.072) C11(-10.118,-6.76) C12(-10.313,-6.295) C16(-10.118,-4.563) C17(-10.313,-4.098) C20(-10.118,-2.366) C21(-10.313,-1.901) C25(-10.298,0) C29(-10.313,1.901) C30(-10.118,2.366) C33(-10.313,4.098) C34(-10.118,4.563) C38(-10.313,6.295) C39(-10.118,6.76)
  oval 0.152x0.254 smd: AA1(-1.678,-11.814) AA49(-1.678,11.814) AB2(-1.193,-11.187) AB48(-1.193,11.187) AC2(-0.532,-11.103) AC48(-0.532,11.103) AD1(0,-11.814) AD2(0,-11.306) AD3(0,-10.798) AD47(0,10.798) AD48(0,11.306) AD49(0,11.814) AE2(0.532,-11.103) AE48(0.532,11.103) AF2(1.193,-11.187) AF48(1.193,11.187) AG1(1.678,-11.814) AG49(1.678,11.814) AH2(1.871,-11.316) AH3(1.901,-10.813) AH47(1.901,10.813) AH48(1.871,11.316) AJ3(2.366,-10.618) AJ47(2.366,10.618) AK2(2.729,-11.103) AK48(2.729,11.103) AL2(3.39,-11.187) AL48(3.39,11.187) AM1(3.875,-11.814) AM2(4.068,-11.316) AM3(4.098,-10.813) AM47(4.098,10.813) AM48(4.068,11.316) AM49(3.875,11.814) AN3(4.563,-10.618) AN47(4.563,10.618) AP2(4.926,-11.103) AP48(4.926,11.103) P2(-4.926,-11.103) P48(-4.926,11.103) R3(-4.563,-10.618) R47(-4.563,10.618) T1(-3.875,-11.814) T2(-4.068,-11.316) T3(-4.098,-10.813) T47(-4.098,10.813) T48(-4.068,11.316) T49(-3.875,11.814) U2(-3.39,-11.187) U48(-3.39,11.187) V2(-2.729,-11.103) V48(-2.729,11.103) W3(-2.366,-10.618) W47(-2.366,10.618) Y2(-1.871,-11.316) Y3(-1.901,-10.813) Y47(-1.901,10.813) Y48(-1.871,11.316)
  round 0.254 smd: AA5(-1.601,-9.856) AA45(-1.601,9.856) AC4(-0.579,-10.06) AC46(-0.579,10.06) AE4(0.579,-10.06) AE46(0.579,10.06) AG5(1.601,-9.856) AG45(1.601,9.856) AJ4(2.274,-10.098) AJ46(2.274,10.098) AK4(2.776,-10.06) AK46(2.776,10.06) AM5(3.799,-9.856) AM45(3.799,9.856) AN4(4.471,-10.098) AN46(4.471,10.098) AP4(4.973,-10.06) AP46(4.973,10.06) AT5(5.996,-9.856) AT45(5.996,9.856) AV4(6.669,-10.098) AV46(6.669,10.098) AW4(7.17,-10.06) AW46(7.17,10.06) B6(-10.811,-9.397) B44(-10.811,9.397) BA2(8.526,-11.316) BA3(8.594,-10.809) BA4(8.468,-10.304) BA5(8.193,-9.856) BA45(8.193,9.856) BA46(8.468,10.304) BA47(8.594,10.809) BA48(8.526,11.316) BB3(9.315,-11.318) BB4(9.126,-10.825) BB46(9.126,10.825) BB47(9.315,11.318) BC8(9.356,-8.193) BC10(9.56,-7.17) BC13(9.356,-5.996) BC15(9.56,-4.973) BC17(9.356,-3.799) BC19(9.56,-2.776) BC22(9.356,-1.601) BC24(9.56,-0.579) BC26(9.56,0.579) BC28(9.356,1.601) BC31(9.56,2.776) BC33(9.356,3.799) BC35(9.56,4.973) BC37(9.356,5.996) BC40(9.56,7.17) BC42(9.356,8.193) BD7(9.872,-8.914) BD11(9.598,-6.669) BD16(9.598,-4.471) BD20(9.598,-2.274) BD30(9.598,2.274) BD34(9.598,4.471) BD39(9.598,6.669) BD43(9.872,8.914) BE6(10.357,-9.091) BE44(10.357,9.091) BF6(10.811,-9.397) BF44(10.811,9.397) C6(-10.357,-9.091) C44(-10.357,9.091) D7(-9.872,-8.914) D11(-9.598,-6.669) D16(-9.598,-4.471) D20(-9.598,-2.274) D30(-9.598,2.274) D34(-9.598,4.471) D39(-9.598,6.669) D43(-9.872,8.914) E8(-9.356,-8.193) E10(-9.56,-7.17) E13(-9.356,-5.996) E15(-9.56,-4.973) E17(-9.356,-3.799) E19(-9.56,-2.776) E22(-9.356,-1.601) E24(-9.56,-0.579) E26(-9.56,0.579) E28(-9.356,1.601) E31(-9.56,2.776) E33(-9.356,3.799) E35(-9.56,4.973) E37(-9.356,5.996) E40(-9.56,7.17) E42(-9.356,8.193) F3(-9.315,-11.318) F4(-9.126,-10.825) F46(-9.126,10.825) F47(-9.315,11.318) G2(-8.526,-11.316) G3(-8.594,-10.809) G4(-8.468,-10.304) G5(-8.193,-9.856) G45(-8.193,9.856) G46(-8.468,10.304) G47(-8.594,10.809) G48(-8.526,11.316) J4(-7.17,-10.06) J46(-7.17,10.06) K4(-6.669,-10.098) K46(-6.669,10.098) M5(-5.996,-9.856) M45(-5.996,9.856) P4(-4.973,-10.06) P46(-4.973,10.06) R4(-4.471,-10.098) R46(-4.471,10.098) T5(-3.799,-9.856) T45(-3.799,9.856) V4(-2.776,-10.06) V46(-2.776,10.06) W4(-2.274,-10.098) W46(-2.274,10.098)
  oval 0.203x0.254 smd: AB3(-1.193,-10.686) AB47(-1.193,10.686) AC3(-0.692,-10.559) AC47(-0.692,10.559) AE3(0.692,-10.559) AE47(0.692,10.559) AF3(1.193,-10.686) AF47(1.193,10.686) AH4(1.82,-10.313) AH46(1.82,10.313) AK3(2.883,-10.559) AK47(2.883,10.559) AL3(3.39,-10.686) AL47(3.39,10.686) AM4(4.017,-10.313) AM46(4.017,10.313) AP3(5.08,-10.559) AP47(5.08,10.559) AR3(5.587,-10.686) AR47(5.587,10.686) AT1(6.097,-11.814) AT49(6.097,11.814) AU4(6.214,-10.313) AU46(6.214,10.313) AW3(7.277,-10.559) AW47(7.277,10.559) AY3(7.784,-10.686) AY47(7.784,10.686) BA1(8.32,-11.814) BA49(8.32,11.814) G1(-8.32,-11.814) G49(-8.32,11.814) H3(-7.784,-10.686) H47(-7.784,10.686) J3(-7.277,-10.559) J47(-7.277,10.559) L4(-6.214,-10.313) L46(-6.214,10.313) M1(-6.097,-11.814) M49(-6.097,11.814) N3(-5.587,-10.686) N47(-5.587,10.686) P3(-5.08,-10.559) P47(-5.08,10.559) T4(-4.017,-10.313) T46(-4.017,10.313) U3(-3.39,-10.686) U47(-3.39,10.686) V3(-2.883,-10.559) V47(-2.883,10.559) Y4(-1.82,-10.313) Y46(-1.82,10.313)
  oval 0.152x0.305 smd: AR2(5.587,-11.187) AR48(5.587,11.187) AU2(6.265,-11.316) AU3(6.295,-10.813) AU47(6.295,10.813) AU48(6.265,11.316) AV3(6.76,-10.618) AV47(6.76,10.618) AW2(7.123,-11.103) AW48(7.123,11.103) AY2(7.784,-11.187) AY48(7.784,11.187) H2(-7.784,-11.187) H48(-7.784,11.187) J2(-7.123,-11.103) J48(-7.123,11.103) K3(-6.76,-10.618) K47(-6.76,10.618) L2(-6.265,-11.316) L3(-6.295,-10.813) L47(-6.295,10.813) L48(-6.265,11.316) N2(-5.587,-11.187) N48(-5.587,11.187)
  oval 0.305x0.152 smd: B8(-10.816,-8.462) B9(-10.687,-7.784) B41(-10.687,7.784) B42(-10.816,8.462) BE8(10.313,-8.492) BE42(10.313,8.492) BF8(10.816,-8.462) BF9(10.687,-7.784) BF41(10.687,7.784) BF42(10.816,8.462) C8(-10.313,-8.492) C42(-10.313,8.492)
BGA908-NVIDIA-N18P-Q3-A1
  round 0.38 smd: A2(-13.7,-12.9) A3(-13.7,-12.1) A5(-13.7,-10.4) A6(-13.7,-9.6) A8(-13.7,-7.9) A9(-13.7,-7.1) A11(-13.7,-5.4) A12(-13.7,-4.6) A14(-13.7,-2.9) A15(-13.7,-2.1) A17(-13.7,-0.4) A18(-13.7,0.4) A20(-13.7,2.1) A21(-13.7,2.9) A23(-13.7,4.6) A24(-13.7,5.4) A26(-13.7,7.1) A27(-13.7,7.9) A29(-13.7,9.6) A30(-13.7,10.4) A32(-13.7,12.1) A33(-13.7,12.9) AA1(2.9,-13.7) AA2(2.9,-12.9) AA3(2.9,-12.1) AA4(2.9,-11.3) AA5(2.9,-10.5) AA6(2.9,-9.65) AA7(2.9,-8.8) AA8(2.9,-8) AA27(2.9,8) AA28(2.9,8.8) AA29(2.9,9.65) AA30(2.9,10.5) AA31(2.9,11.3) AA32(2.9,12.1) AA33(2.9,12.9) AA34(2.9,13.7) AB2(3.75,-12.9) AB3(3.75,-12.1) AB4(3.75,-11.3) AB5(3.75,-10.5) AB7(3.75,-8.8) AB8(3.75,-8) AB27(3.75,8) AB28(3.75,8.8) AB30(3.75,10.5) AB31(3.75,11.3) AB32(3.75,12.1) AB33(3.75,12.9) AC1(4.6,-13.7) AC2(4.6,-12.9) AC3(4.6,-12.1) AC4(4.6,-11.3) AC5(4.6,-10.5) AC6(4.6,-9.65) AC7(4.6,-8.8) AC8(4.6,-8) AC27(4.6,8) AC28(4.6,8.8) AC29(4.6,9.65) AC30(4.6,10.5) AC31(4.6,11.3) AC32(4.6,12.1) AC33(4.6,12.9) AC34(4.6,13.7) AD1(5.4,-13.7) AD2(5.4,-12.9) AD3(5.4,-12.1) AD4(5.4,-11.3) AD5(5.4,-10.5) AD6(5.4,-9.65) AD7(5.4,-8.8) AD8(5.4,-8) AD27(5.4,8) AD28(5.4,8.8) AD29(5.4,9.65) AD30(5.4,10.5) AD31(5.4,11.3) AD32(5.4,12.1) AD33(5.4,12.9) AD34(5.4,13.7) AE2(6.25,-12.9) AE3(6.25,-12.1) AE4(6.25,-11.3) AE5(6.25,-10.5) AE7(6.25,-8.8) AE8(6.25,-8) AE27(6.25,8) AE28(6.25,8.8) AE30(6.25,10.5) AE31(6.25,11.3) AE32(6.25,12.1) AE33(6.25,12.9) AF1(7.1,-13.7) AF2(7.1,-12.9) AF3(7.1,-12.1) AF4(7.1,-11.3) AF5(7.1,-10.5) AF6(7.1,-9.65) AF7(7.1,-8.8) AF8(7.1,-8) AF27(7.1,8) AF28(7.1,8.8) AF29(7.1,9.65) AF30(7.1,10.5) AF31(7.1,11.3) AF32(7.1,12.1) AF33(7.1,12.9) AF34(7.1,13.7) AG1(7.9,-13.7) AG2(7.9,-12.9) AG3(7.9,-12.1) AG4(7.9,-11.3) AG5(7.9,-10.5) AG6(7.9,-9.65) AG7(7.9,-8.8) AG8(8,-8) AG9(8,-7.1) AG10(8,-6.25) AG11(8,-5.4) AG12(8,-4.6) AG13(8,-3.75) AG14(8,-2.9) AG15(8,-2.1) AG16(8,-1.25) AG17(8,-0.4) AG18(8,0.4) AG19(8,1.25) AG20(8,2.1) AG21(8,2.9) AG22(8,3.75) AG23(8,4.6) AG24(8,5.4) AG25(8,6.25) AG26(8,7.1) AG27(8,8) AG28(7.9,8.8) AG29(7.9,9.65) AG30(7.9,10.5) AG31(7.9,11.3) AG32(7.9,12.1) AG33(7.9,12.9) AG34(7.9,13.7) AH2(8.75,-12.9) AH3(8.75,-12.1) AH4(8.75,-11.3) AH5(8.75,-10.5) AH6(8.75,-9.65) AH7(8.8,-8.8) AH8(8.8,-7.9) AH9(8.8,-7.1) AH10(8.8,-6.25) AH11(8.8,-5.4) AH12(8.8,-4.6) AH13(8.8,-3.75) AH14(8.8,-2.9) AH15(8.8,-2.1) AH16(8.8,-1.25) AH17(8.8,-0.4) AH18(8.8,0.4) AH19(8.8,1.25) AH20(8.8,2.1) AH21(8.8,2.9) AH22(8.8,3.75) AH23(8.8,4.6) AH24(8.8,5.4) AH25(8.8,6.25) AH26(8.8,7.1) AH27(8.8,7.9) AH28(8.8,8.8) AH29(8.75,9.65) AH30(8.75,10.5) AH31(8.75,11.3) AH32(8.75,12.1) AH33(8.75,12.9) AJ1(9.6,-13.7) AJ2(9.6,-12.9) AJ3(9.6,-12.1) AJ4(9.6,-11.3) AJ5(9.6,-10.5) AJ6(9.65,-9.65) AJ7(9.65,-8.75) AJ8(9.65,-7.9) AJ9(9.65,-7.1) AJ11(9.65,-5.4) AJ12(9.65,-4.6) AJ14(9.65,-2.9) AJ15(9.65,-2.1) AJ17(9.65,-0.4) AJ18(9.65,0.4) AJ20(9.65,2.1) AJ21(9.65,2.9) AJ23(9.65,4.6) AJ24(9.65,5.4) AJ26(9.65,7.1) AJ27(9.65,7.9) AJ28(9.65,8.75) AJ29(9.65,9.65) AJ30(9.6,10.5) AJ31(9.6,11.3) AJ32(9.6,12.1) AJ33(9.6,12.9) AJ34(9.6,13.7) AK1(10.4,-13.7) AK2(10.4,-12.9) AK3(10.4,-12.1) AK4(10.4,-11.3) AK5(10.5,-10.5) AK6(10.5,-9.6) AK7(10.5,-8.75) AK8(10.5,-7.9) AK9(10.5,-7.1) AK10(10.5,-6.25) AK11(10.5,-5.4) AK12(10.5,-4.6) AK13(10.5,-3.75) AK14(10.5,-2.9) AK15(10.5,-2.1) AK16(10.5,-1.25) AK17(10.5,-0.4) AK18(10.5,0.4) AK19(10.5,1.25) AK20(10.5,2.1) AK21(10.5,2.9) AK22(10.5,3.75) AK23(10.5,4.6) AK24(10.5,5.4) AK25(10.5,6.25) AK26(10.5,7.1) AK27(10.5,7.9) AK28(10.5,8.75) AK29(10.5,9.6) AK30(10.5,10.5) AK31(10.4,11.3) AK32(10.4,12.1) AK33(10.4,12.9) AK34(10.4,13.7) AL2(11.25,-12.9) AL3(11.25,-12.1) AL4(11.3,-11.3) AL5(11.3,-10.4) AL6(11.3,-9.6) AL7(11.3,-8.75) AL8(11.3,-7.9) AL9(11.3,-7.1) AL10(11.3,-6.25) AL11(11.3,-5.4) AL12(11.3,-4.6) AL13(11.3,-3.75) AL14(11.3,-2.9) AL15(11.3,-2.1) AL16(11.3,-1.25) AL17(11.3,-0.4) AL18(11.3,0.4) AL19(11.3,1.25) AL20(11.3,2.1) AL21(11.3,2.9) AL22(11.3,3.75) AL23(11.3,4.6) AL24(11.3,5.4) AL25(11.3,6.25) AL26(11.3,7.1) AL27(11.3,7.9) AL28(11.3,8.75) AL29(11.3,9.6) AL30(11.3,10.4) AL31(11.3,11.3) AL32(11.25,12.1) AL33(11.25,12.9) AM1(12.1,-13.7) AM2(12.1,-12.9) AM3(12.1,-12.1) AM4(12.1,-11.25) AM5(12.1,-10.4) AM6(12.1,-9.6) AM7(12.1,-8.75) AM8(12.1,-7.9) AM9(12.1,-7.1) AM10(12.1,-6.25) AM11(12.1,-5.4) AM12(12.1,-4.6) AM13(12.1,-3.75) AM14(12.1,-2.9) AM15(12.1,-2.1) AM16(12.1,-1.25) AM17(12.1,-0.4) AM18(12.1,0.4) AM19(12.1,1.25) AM20(12.1,2.1) AM21(12.1,2.9) AM22(12.1,3.75) AM23(12.1,4.6) AM24(12.1,5.4) AM25(12.1,6.25) AM26(12.1,7.1) AM27(12.1,7.9) AM28(12.1,8.75) AM29(12.1,9.6) AM30(12.1,10.4) AM31(12.1,11.25) AM32(12.1,12.1) AM33(12.1,12.9) AM34(12.1,13.7) AN1(12.9,-13.7) AN2(12.9,-12.9) AN3(12.9,-12.1) AN4(12.9,-11.25) AN5(12.9,-10.4) AN6(12.9,-9.6) AN7(12.9,-8.75) AN8(12.9,-7.9) AN9(12.9,-7.1) AN10(12.9,-6.25) AN11(12.9,-5.4) AN12(12.9,-4.6) AN13(12.9,-3.75) AN14(12.9,-2.9) AN15(12.9,-2.1) AN16(12.9,-1.25) AN17(12.9,-0.4) AN18(12.9,0.4) AN19(12.9,1.25) AN20(12.9,2.1) AN21(12.9,2.9) AN22(12.9,3.75) AN23(12.9,4.6) AN24(12.9,5.4) AN25(12.9,6.25) AN26(12.9,7.1) AN27(12.9,7.9) AN28(12.9,8.75) AN29(12.9,9.6) AN30(12.9,10.4) AN31(12.9,11.25) AN32(12.9,12.1) AN33(12.9,12.9) AN34(12.9,13.7) AP2(13.7,-12.9) AP3(13.7,-12.1) AP5(13.7,-10.4) AP6(13.7,-9.6) AP8(13.7,-7.9) AP9(13.7,-7.1) AP11(13.7,-5.4) AP12(13.7,-4.6) AP14(13.7,-2.9) AP15(13.7,-2.1) AP17(13.7,-0.4) AP18(13.7,0.4) AP20(13.7,2.1) AP21(13.7,2.9) AP23(13.7,4.6) AP24(13.7,5.4) AP26(13.7,7.1) AP27(13.7,7.9) AP29(13.7,9.6) AP30(13.7,10.4) AP32(13.7,12.1) AP33(13.7,12.9) B1(-12.9,-13.7) B2(-12.9,-12.9) B3(-12.9,-12.1) B4(-12.9,-11.25) B5(-12.9,-10.4) B6(-12.9,-9.6) B7(-12.9,-8.75) B8(-12.9,-7.9) B9(-12.9,-7.1) B10(-12.9,-6.25) B11(-12.9,-5.4) B12(-12.9,-4.6) B13(-12.9,-3.75) B14(-12.9,-2.9) B15(-12.9,-2.1) B16(-12.9,-1.25) B17(-12.9,-0.4) B18(-12.9,0.4) B19(-12.9,1.25) B20(-12.9,2.1) B21(-12.9,2.9) B22(-12.9,3.75) B23(-12.9,4.6) B24(-12.9,5.4) B25(-12.9,6.25) B26(-12.9,7.1) B27(-12.9,7.9) B28(-12.9,8.75) B29(-12.9,9.6) B30(-12.9,10.4) B31(-12.9,11.25) B32(-12.9,12.1) B33(-12.9,12.9) B34(-12.9,13.7) C1(-12.1,-13.7) C2(-12.1,-12.9) C3(-12.1,-12.1) C4(-12.1,-11.25) C5(-12.1,-10.4) C6(-12.1,-9.6) C7(-12.1,-8.75) C8(-12.1,-7.9) C9(-12.1,-7.1) C10(-12.1,-6.25) C11(-12.1,-5.4) C12(-12.1,-4.6) C13(-12.1,-3.75) C14(-12.1,-2.9) C15(-12.1,-2.1) C16(-12.1,-1.25) C17(-12.1,-0.4) C18(-12.1,0.4) C19(-12.1,1.25) C20(-12.1,2.1) C21(-12.1,2.9) C22(-12.1,3.75) C23(-12.1,4.6) C24(-12.1,5.4) C25(-12.1,6.25) C26(-12.1,7.1) C27(-12.1,7.9) C28(-12.1,8.75) C29(-12.1,9.6) C30(-12.1,10.4) C31(-12.1,11.25) C32(-12.1,12.1) C33(-12.1,12.9) C34(-12.1,13.7) D2(-11.25,-12.9) D3(-11.25,-12.1) D4(-11.3,-11.3) D5(-11.3,-10.4) D6(-11.3,-9.6) D7(-11.3,-8.75) D8(-11.3,-7.9) D9(-11.3,-7.1) D10(-11.3,-6.25) D11(-11.3,-5.4) D12(-11.3,-4.6) D13(-11.3,-3.75) D14(-11.3,-2.9) D15(-11.3,-2.1) D16(-11.3,-1.25) D17(-11.3,-0.4) D18(-11.3,0.4) D19(-11.3,1.25) D20(-11.3,2.1) D21(-11.3,2.9) D22(-11.3,3.75) D23(-11.3,4.6) D24(-11.3,5.4) D25(-11.3,6.25) D26(-11.3,7.1) D27(-11.3,7.9) D28(-11.3,8.75) D29(-11.3,9.6) D30(-11.3,10.4) D31(-11.3,11.3) D32(-11.25,12.1) D33(-11.25,12.9) E1(-10.4,-13.7) E2(-10.4,-12.9) E3(-10.4,-12.1) E4(-10.4,-11.3) E5(-10.5,-10.5) E6(-10.5,-9.6) E7(-10.5,-8.75) E8(-10.5,-7.9) E9(-10.5,-7.1) E10(-10.5,-6.25) E11(-10.5,-5.4) E12(-10.5,-4.6) E13(-10.5,-3.75) E14(-10.5,-2.9) E15(-10.5,-2.1) E16(-10.5,-1.25) E17(-10.5,-0.4) E18(-10.5,0.4) E19(-10.5,1.25) E20(-10.5,2.1) E21(-10.5,2.9) E22(-10.5,3.75) E23(-10.5,4.6) E24(-10.5,5.4) E25(-10.5,6.25) E26(-10.5,7.1) E27(-10.5,7.9) E28(-10.5,8.75) E29(-10.5,9.6) E30(-10.5,10.5) E31(-10.4,11.3) E32(-10.4,12.1) E33(-10.4,12.9) E34(-10.4,13.7) F1(-9.6,-13.7) F2(-9.6,-12.9) F3(-9.6,-12.1) F4(-9.6,-11.3) F5(-9.6,-10.5) F6(-9.65,-9.65) F7(-9.65,-8.75) F8(-9.65,-7.9) F9(-9.65,-7.1) F11(-9.65,-5.4) F12(-9.65,-4.6) F14(-9.65,-2.9) F15(-9.65,-2.1) F17(-9.65,-0.4) F18(-9.65,0.4) F20(-9.65,2.1) F21(-9.65,2.9) F23(-9.65,4.6) F24(-9.65,5.4) F26(-9.65,7.1) F27(-9.65,7.9) F28(-9.65,8.75) F29(-9.65,9.65) F30(-9.6,10.5) F31(-9.6,11.3) F32(-9.6,12.1) F33(-9.6,12.9) F34(-9.6,13.7) G2(-8.75,-12.9) G3(-8.75,-12.1) G4(-8.75,-11.3) G5(-8.75,-10.5) G6(-8.75,-9.65) G7(-8.8,-8.8) G8(-8.8,-7.9) G9(-8.8,-7.1) G10(-8.8,-6.25) G11(-8.8,-5.4) G12(-8.8,-4.6) G13(-8.8,-3.75) G14(-8.8,-2.9) G15(-8.8,-2.1) G16(-8.8,-1.25) G17(-8.8,-0.4) G18(-8.8,0.4) G19(-8.8,1.25) G20(-8.8,2.1) G21(-8.8,2.9) G22(-8.8,3.75) G23(-8.8,4.6) G24(-8.8,5.4) G25(-8.8,6.25) G26(-8.8,7.1) G27(-8.8,7.9) G28(-8.8,8.8) G29(-8.75,9.65) G30(-8.75,10.5) G31(-8.75,11.3) G32(-8.75,12.1) G33(-8.75,12.9) H1(-7.9,-13.7) H2(-7.9,-12.9) H3(-7.9,-12.1) H4(-7.9,-11.3) H5(-7.9,-10.5) H6(-7.9,-9.65) H7(-7.9,-8.8) H8(-8,-8) H9(-8,-7.1) H10(-8,-6.25) H11(-8,-5.4) H12(-8,-4.6) H13(-8,-3.75) H14(-8,-2.9) H15(-8,-2.1) H16(-8,-1.25) H17(-8,-0.4) H18(-8,0.4) H19(-8,1.25) H20(-8,2.1) H21(-8,2.9) H22(-8,3.75) H23(-8,4.6) H24(-8,5.4) H25(-8,6.25) H26(-8,7.1) H27(-8,8) H28(-7.9,8.8) H29(-7.9,9.65) H30(-7.9,10.5) H31(-7.9,11.3) H32(-7.9,12.1) H33(-7.9,12.9) H34(-7.9,13.7) J1(-7.1,-13.7) J2(-7.1,-12.9) J3(-7.1,-12.1) J4(-7.1,-11.3) J5(-7.1,-10.5) J6(-7.1,-9.65) J7(-7.1,-8.8) J8(-7.1,-8) J27(-7.1,8) J28(-7.1,8.8) J29(-7.1,9.65) J30(-7.1,10.5) J31(-7.1,11.3) J32(-7.1,12.1) J33(-7.1,12.9) J34(-7.1,13.7) K2(-6.25,-12.9) K3(-6.25,-12.1) K4(-6.25,-11.3) K5(-6.25,-10.5) K7(-6.25,-8.8) K8(-6.25,-8) K27(-6.25,8) K28(-6.25,8.8) K30(-6.25,10.5) K31(-6.25,11.3) K32(-6.25,12.1) K33(-6.25,12.9) L1(-5.4,-13.7) L2(-5.4,-12.9) L3(-5.4,-12.1) L4(-5.4,-11.3) L5(-5.4,-10.5) L6(-5.4,-9.65) L7(-5.4,-8.8) L8(-5.4,-8) L27(-5.4,8) L28(-5.4,8.8) L29(-5.4,9.65) L30(-5.4,10.5) L31(-5.4,11.3) L32(-5.4,12.1) L33(-5.4,12.9) L34(-5.4,13.7) M1(-4.6,-13.7) M2(-4.6,-12.9) M3(-4.6,-12.1) M4(-4.6,-11.3) M5(-4.6,-10.5) M6(-4.6,-9.65) M7(-4.6,-8.8) M8(-4.6,-8) M27(-4.6,8) M28(-4.6,8.8) M29(-4.6,9.65) M30(-4.6,10.5) M31(-4.6,11.3) M32(-4.6,12.1) M33(-4.6,12.9) M34(-4.6,13.7) N2(-3.75,-12.9) N3(-3.75,-12.1) N4(-3.75,-11.3) N5(-3.75,-10.5) N7(-3.75,-8.8) N8(-3.75,-8) N27(-3.75,8) N28(-3.75,8.8) N30(-3.75,10.5) N31(-3.75,11.3) N32(-3.75,12.1) N33(-3.75,12.9) P1(-2.9,-13.7) P2(-2.9,-12.9) P3(-2.9,-12.1) P4(-2.9,-11.3) P5(-2.9,-10.5) P6(-2.9,-9.65) P7(-2.9,-8.8) P8(-2.9,-8) P27(-2.9,8) P28(-2.9,8.8) P29(-2.9,9.65) P30(-2.9,10.5) P31(-2.9,11.3) P32(-2.9,12.1) P33(-2.9,12.9) P34(-2.9,13.7) R1(-2.1,-13.7) R2(-2.1,-12.9) R3(-2.1,-12.1) R4(-2.1,-11.3) R5(-2.1,-10.5) R6(-2.1,-9.65) R7(-2.1,-8.8) R8(-2.1,-8) R27(-2.1,8) R28(-2.1,8.8) R29(-2.1,9.65) R30(-2.1,10.5) R31(-2.1,11.3) R32(-2.1,12.1) R33(-2.1,12.9) R34(-2.1,13.7) T2(-1.25,-12.9) T3(-1.25,-12.1) T4(-1.25,-11.3) T5(-1.25,-10.5) T7(-1.25,-8.8) T8(-1.25,-8) T27(-1.25,8) T28(-1.25,8.8) T30(-1.25,10.5) T31(-1.25,11.3) T32(-1.25,12.1) T33(-1.25,12.9) U1(-0.4,-13.7) U2(-0.4,-12.9) U3(-0.4,-12.1) U4(-0.4,-11.3) U5(-0.4,-10.5) U6(-0.4,-9.65) U7(-0.4,-8.8) U8(-0.4,-8) U27(-0.4,8) U28(-0.4,8.8) U29(-0.4,9.65) U30(-0.4,10.5) U31(-0.4,11.3) U32(-0.4,12.1) U33(-0.4,12.9) U34(-0.4,13.7) V1(0.4,-13.7) V2(0.4,-12.9) V3(0.4,-12.1) V4(0.4,-11.3) V5(0.4,-10.5) V6(0.4,-9.65) V7(0.4,-8.8) V8(0.4,-8) V27(0.4,8) V28(0.4,8.8) V29(0.4,9.65) V30(0.4,10.5) V31(0.4,11.3) V32(0.4,12.1) V33(0.4,12.9) V34(0.4,13.7) W2(1.25,-12.9) W3(1.25,-12.1) W4(1.25,-11.3) W5(1.25,-10.5) W7(1.25,-8.8) W8(1.25,-8) W27(1.25,8) W28(1.25,8.8) W30(1.25,10.5) W31(1.25,11.3) W32(1.25,12.1) W33(1.25,12.9) Y1(2.1,-13.7) Y2(2.1,-12.9) Y3(2.1,-12.1) Y4(2.1,-11.3) Y5(2.1,-10.5) Y6(2.1,-9.65) Y7(2.1,-8.8) Y8(2.1,-8) Y27(2.1,8) Y28(2.1,8.8) Y29(2.1,9.65) Y30(2.1,10.5) Y31(2.1,11.3) Y32(2.1,12.1) Y33(2.1,12.9) Y34(2.1,13.7)
  round 0.4 smd: AA12(3.5,-5.5) AA13(3.5,-4.5) AA14(3.5,-3.5) AA15(3.5,-2.5) AA16(3.5,-1.5) AA17(3.5,-0.5) AA18(3.5,0.5) AA19(3.5,1.5) AA20(3.5,2.5) AA21(3.5,3.5) AA22(3.5,4.5) AA23(3.5,5.5) AB12(4.5,-5.5) AB13(4.5,-4.5) AB14(4.5,-3.5) AB15(4.5,-2.5) AB16(4.5,-1.5) AB17(4.5,-0.5) AB18(4.5,0.5) AB19(4.5,1.5) AB20(4.5,2.5) AB21(4.5,3.5) AB22(4.5,4.5) AB23(4.5,5.5) AC12(5.5,-5.5) AC13(5.5,-4.5) AC14(5.5,-3.5) AC15(5.5,-2.5) AC16(5.5,-1.5) AC17(5.5,-0.5) AC18(5.5,0.5) AC19(5.5,1.5) AC20(5.5,2.5) AC21(5.5,3.5) AC22(5.5,4.5) AC23(5.5,5.5) M12(-5.5,-5.5) M13(-5.5,-4.5) M14(-5.5,-3.5) M15(-5.5,-2.5) M16(-5.5,-1.5) M17(-5.5,-0.5) M18(-5.5,0.5) M19(-5.5,1.5) M20(-5.5,2.5) M21(-5.5,3.5) M22(-5.5,4.5) M23(-5.5,5.5) N12(-4.5,-5.5) N13(-4.5,-4.5) N14(-4.5,-3.5) N15(-4.5,-2.5) N16(-4.5,-1.5) N17(-4.5,-0.5) N18(-4.5,0.5) N19(-4.5,1.5) N20(-4.5,2.5) N21(-4.5,3.5) N22(-4.5,4.5) N23(-4.5,5.5) P12(-3.5,-5.5) P13(-3.5,-4.5) P14(-3.5,-3.5) P15(-3.5,-2.5) P16(-3.5,-1.5) P17(-3.5,-0.5) P18(-3.5,0.5) P19(-3.5,1.5) P20(-3.5,2.5) P21(-3.5,3.5) P22(-3.5,4.5) P23(-3.5,5.5) R12(-2.5,-5.5) R13(-2.5,-4.5) R14(-2.5,-3.5) R15(-2.5,-2.5) R16(-2.5,-1.5) R17(-2.5,-0.5) R18(-2.5,0.5) R19(-2.5,1.5) R20(-2.5,2.5) R21(-2.5,3.5) R22(-2.5,4.5) R23(-2.5,5.5) T12(-1.5,-5.5) T13(-1.5,-4.5) T14(-1.5,-3.5) T15(-1.5,-2.5) T16(-1.5,-1.5) T17(-1.5,-0.5) T18(-1.5,0.5) T19(-1.5,1.5) T20(-1.5,2.5) T21(-1.5,3.5) T22(-1.5,4.5) T23(-1.5,5.5) U12(-0.5,-5.5) U13(-0.5,-4.5) U14(-0.5,-3.5) U15(-0.5,-2.5) U16(-0.5,-1.5) U17(-0.5,-0.5) U18(-0.5,0.5) U19(-0.5,1.5) U20(-0.5,2.5) U21(-0.5,3.5) U22(-0.5,4.5) U23(-0.5,5.5) V12(0.5,-5.5) V13(0.5,-4.5) V14(0.5,-3.5) V15(0.5,-2.5) V16(0.5,-1.5) V17(0.5,-0.5) V18(0.5,0.5) V19(0.5,1.5) V20(0.5,2.5) V21(0.5,3.5) V22(0.5,4.5) V23(0.5,5.5) W12(1.5,-5.5) W13(1.5,-4.5) W14(1.5,-3.5) W15(1.5,-2.5) W16(1.5,-1.5) W17(1.5,-0.5) W18(1.5,0.5) W19(1.5,1.5) W20(1.5,2.5) W21(1.5,3.5) W22(1.5,4.5) W23(1.5,5.5) Y12(2.5,-5.5) Y13(2.5,-4.5) Y14(2.5,-3.5) Y15(2.5,-2.5) Y16(2.5,-1.5) Y17(2.5,-0.5) Y18(2.5,0.5) Y19(2.5,1.5) Y20(2.5,2.5) Y21(2.5,3.5) Y22(2.5,4.5) Y23(2.5,5.5)

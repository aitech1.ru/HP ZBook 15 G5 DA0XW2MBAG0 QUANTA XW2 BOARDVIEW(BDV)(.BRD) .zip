# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 189.44,39.11 189.44,38.55 189.67,38.32 191.68,38.32 192.44,37.56 192.44,34.58 192.26,34.41 192.24,34.4 192.22,34.39 192.15,34.39 192.08,34.38 190.41,34.38 190.1,34.69 190.1,36.9 189.82,37.17 188.12,37.17 187.87,37.43 187.87,39 188.09,39.23 189.31,39.23
GND on BOTTOM (solid shape): 217.35,56.12 217.35,55.64 217.61,55.37 217.61,54.41 217.87,54.16 218.98,54.16 219.11,54.03 219.11,53.53 218.98,53.4 217.2,53.4 217.08,53.53 217.08,54.16 217.31,54.39 217.31,55.37 217.17,55.51 217.03,55.51 216.82,55.72 216.82,56.17 216.88,56.22 217.25,56.22
GND on BOTTOM (solid shape): 209.21,28.35 209.39,28.16 209.39,27.83 210.3,26.91 212.05,26.91 212.78,26.18 216.52,26.18 216.87,25.82 216.87,24.58 216.05,23.76 211.65,23.76 211.64,23.76 211.01,23.76 209.31,25.46 208.15,26.62 208.15,27.42 207.92,27.65 206.5,27.65 206.4,27.75 206.4,28.05 206.48,28.13 207.19,28.13 207.42,28.36 209.21,28.36
GND on BOTTOM (solid shape): 216.36,46.27 216.36,45.76 217.2,44.92 217.28,44.92 217.66,44.54 218.88,44.54 218.93,44.49 218.93,44.34 218.88,44.29 218.47,44.29 218.46,44.27 217.01,44.27 216.87,44.13 215.58,44.13 215.4,43.96 211.64,43.96 211.45,44.15 204.36,44.15 204.22,44.29 204.22,45.35 204.38,45.51 209.33,45.51 210.34,46.52 216.11,46.52
GND on BOTTOM (solid shape): 216.43,21.87 216.43,20.86 217.23,20.06 217.23,19.67 217.14,19.59 210.44,19.59 210.04,19.2 209.2,19.2 209.2,19.19 209.1,19.09 209.1,16.7 209.09,16.6 209.1,16.45 208.62,15.97 207.73,15.97 207.32,16.37 207.32,19.23 209.23,21.13 209.23,21.81 209.46,22.04 216.26,22.04
GND on BOTTOM (solid shape): 123.27,127.71 123.27,127.5 122.91,127.13 122.91,126.61 122.33,126.03 122.33,125.56 122.23,125.46 122.12,125.56 122.12,126.43 122.29,126.6 122.29,127.24 122.89,127.84 123.15,127.84
GND on BOTTOM (solid shape): 124.03,115.7 124.03,115.43 123.6,115 123.6,114.35 123.22,113.97 123.22,113.5 123.11,113.4 123.01,113.5 123.01,115.13 123.66,115.78 123.95,115.78
GND on BOTTOM (solid shape): 257.97,50.38 257.97,49.94 258.35,49.56 258.35,48.72 258.33,48.69 258.32,48.68 258.12,48.44 258.19,48.12 258.2,48.11 258.2,48.07 257.84,47.72 256.83,47.72 255.68,48.86 255.68,49.37 257.08,50.76 257.59,50.76
GND on BOTTOM (solid shape): 144.39,135.34 144.56,135.31 144.72,135.34 144.73,135.35 145.65,135.35 145.66,135.34 145.83,135.31 145.99,135.34 146,135.35 146.56,135.35 146.69,135.22 146.69,132.17 146.56,132.04 144.79,132.04 144.02,131.28 143.64,131.28 143.14,131.79 143.14,135.09 143.39,135.35 144.38,135.35
GND on BOTTOM (solid shape): 243.34,20.26 243.34,18.72 243.31,18.69 243.31,18.69 243.27,18.66 243,18.66 242.62,18.28 242.62,17.92 242.5,17.79 238.41,17.79 238.09,18.11 238.09,18.56 238.02,18.63 237.27,18.63 237.19,18.71 237.19,19.32 237.27,19.39 237.9,19.39 238.41,19.9 238.41,20.49 238.43,20.52 238.46,20.54 243.06,20.54
GND on BOTTOM (solid shape): 332.81,21.41 332.81,18.63 332.71,18.54 332.19,18.54 332.17,18.52 332.03,18.52 331.92,18.49 331.84,18.41 331.83,18.39 331.81,18.38 331.75,18.38 331.73,18.39 331.72,18.41 331.65,18.49 331.54,18.52 331.52,18.52 331.49,18.55 331.49,18.77 331.88,19.17 331.88,21.71 332.01,21.84 332.38,21.84
GND on BOTTOM (solid shape): 196.52,159.71 196.52,159.53 195.93,158.95 195.93,158.87 195.8,158.73 195.8,157.65 195.81,157.63 195.81,156.18 195.66,156.02 195.33,156.02 195.26,156.1 195.26,156.73 194.21,157.77 194.15,157.77 194.14,157.78 193.9,157.86 193.67,157.77 193.1,157.77 192.7,158.17 192.7,159.61 193.01,159.92 196.3,159.92
GND on BOTTOM (solid shape): 189.02,67.05 189.05,67.04 189.07,67.01 189.34,66.79 189.68,66.89 189.75,66.92 189.82,66.89 189.9,66.82 189.9,63.06 189.74,62.91 188.22,62.91 188.09,63.03 188.09,66.89 188.25,67.05
GND on BOTTOM (solid shape): 218.25,107.44 218.4,107.44 218.58,107.26 218.58,107.06 218.91,106.73 218.91,106.52 218.72,106.33 218.31,106.33 218.12,106.14 216.6,106.14 216.39,105.94 215.3,105.94 214.69,105.33 214.31,105.33 213.47,106.17 213.47,106.78 213.55,106.85 213.75,106.85 213.9,106.7 214.39,106.7 214.54,106.85 214.82,106.85 215.33,106.34 216.04,106.34 216.62,106.93 216.85,106.93 217.43,106.34 217.79,106.34 218.02,106.57 218.02,107.03 217.43,107.61 217.43,107.82 217.51,107.89 217.79,107.89
GND on BOTTOM (solid shape): 209.35,9.34 209.35,9.31 209.45,8.97 209.78,8.87 209.81,8.88 209.96,8.73 209.96,6.9 209.92,6.83 209.9,6.75 209.9,6.73 209.73,6.56 207.98,6.56 207.74,6.79 207.74,8.15 206.71,9.18 206.15,9.18 205.95,9.39 205.95,10.2 206,10.25 208.44,10.25
GND on BOTTOM (solid shape): 171.32,136.23 171.35,136.22 171.37,136.18 171.37,135.98 171.94,135.41 173.96,135.41 174.02,135.35 174.02,132.04 173.77,131.79 172.91,131.79 172.89,131.79 172.88,131.8 172.63,131.9 172.37,131.8 172.36,131.79 172.34,131.79 169.83,131.79 169.58,132.04 169.58,135.09 169.96,135.47 169.96,135.98 170.21,136.23
GND on BOTTOM (solid shape): 214.87,117.83 214.87,117.5 214.82,117.44 214.57,117.44 214.37,117.68 214.06,117.68 213.97,117.62 213.9,117.54 213.85,117.43 213.84,117.3 213.24,116.71 213.09,116.71 212.89,116.5 212.61,116.5 212.44,116.67 212.44,116.8 213.54,117.89 214.81,117.89
GND on BOTTOM (solid shape): 236.88,68.04 237.06,67.97 237.23,68.04 237.78,68.04 238.03,67.78 238.03,67.53 237.79,67.29 237.75,67.29 237.63,67.17 236.91,67.17 236.43,66.69 234.41,66.69 234.3,66.81 234.3,67.15 234.35,67.2 235.59,67.2 235.74,67.2 235.82,67.27 235.99,67.27 236.2,67.48 236.41,67.48 236.58,67.65 236.58,67.73 236.63,67.78 236.63,67.91 236.76,68.04
GND on BOTTOM (solid shape): 328.23,23.69 328.22,23.66 328.25,23.43 328.4,23.26 328.4,17.45 328.38,17.38 328.31,17.35 328.22,17.34 328.14,17.3 327.96,17.26 327.82,17.14 327.14,17.14 326.68,17.61 326.68,18.63 326.8,18.76 327.44,18.76 327.57,18.89 327.57,20.03 326.55,21.05 326.55,23.71 326.68,23.84 328.07,23.84
GND on BOTTOM (solid shape): 211.95,115.69 211.95,115.56 209.87,113.48 209.85,113.48 209.33,112.97 209.33,112.95 209.26,112.87 209.26,111.65 209.25,111.65 209.25,111.6 209.48,111.37 209.81,111.37 210.37,111.93 210.75,111.93 210.88,111.8 210.88,111.62 210.34,111.09 210.34,110.61 210.45,110.5 210.45,110.33 210.29,110.17 210.01,110.17 209.86,110.33 209.58,110.33 209.43,110.17 209.43,110.02 208.92,109.51 208.62,109.51 208.46,109.67 208.46,109.92 209.02,110.48 209.02,110.99 208.67,111.35 208.44,111.35 208.34,111.45 208.34,112.69 211.59,115.95 211.69,115.95
GND on BOTTOM (solid shape): 355.17,126.81 355.39,126.71 355.61,126.61 355.63,126.58 355.93,126.35 356.2,126.08 356.24,126 356.27,125.92 356.27,117.95 356.24,117.95 355.51,117.95 355.25,118.2 355.25,123.63 355.87,124.25 355.87,125.11 355.86,125.12 355.81,125.21 355.71,125.27 355.68,125.3 355.64,125.3 355.51,125.44 352.33,125.44 352.22,125.55 352.22,126.06 352.79,126.63 353.02,126.78 353.29,126.84
GND on BOTTOM (solid shape): 233.2,140.65 233.2,138.36 232.95,138.11 232.8,138.11 232.72,138.15 232.7,138.23 232.34,138.69 231.98,138.23 231.96,138.15 231.88,138.11 231.43,138.11 231.17,138.36 231.17,140.65 231.43,140.9 232.95,140.9
GND on BOTTOM (solid shape): 154.9,158.97 154.99,158.91 154.97,158.8 154.84,158.46 154.97,158.12 154.98,158.11 154.99,158.08 154.98,158.04 154.97,158.04 154.85,157.75 154.92,157.44 154.92,156.45 154.01,155.54 149.64,155.54 149.41,155.77 149.41,158.18 149.66,158.43 151.77,158.43 152.31,158.97
GND on BOTTOM (solid shape): 218.35,88.12 218.35,86.56 219.19,85.71 219.19,83.43 218.43,82.67 218.43,79.27 218.09,78.93 215.8,78.93 215.42,79.31 215.42,82.74 215.55,82.86 216.34,82.86 217.4,83.93 217.59,83.93 217.74,83.99 217.8,84.14 217.8,84.44 217.74,84.59 217.59,84.66 217.48,84.66 217.06,85.08 217.06,87.44 217.06,87.44 217.06,87.51 216.67,87.91 216.67,88.47 216.68,88.56 216.67,88.65 216.68,88.67 216.79,88.78 217.68,88.78
GND on BOTTOM (solid shape): 359.44,127.98 359.44,127.6 359.79,127.25 359.81,127.23 359.8,127.2 359.8,127.15 359.8,126.82 359.82,126.74 359.82,125.82 359.7,125.69 359.06,125.69 358.93,125.82 358.93,126.3 358.94,126.33 358.96,126.35 359.17,126.74 358.86,127.05 358.85,127.05 358.68,127.22 358.68,127.98 358.81,128.11 359.32,128.11
GND on BOTTOM (solid shape): 200.56,83.73 203.36,83.73 203.75,83.34 203.75,83.31 203.75,83.28 203.75,83.22 203.75,81.62 203.1,80.96 203.1,80.44 203.62,80.44 203.69,80.52 203.8,80.54 203.87,80.45 203.87,79.94 203.61,79.69 199.17,79.69 199.04,79.81 199.04,82.74 199.04,82.74 198.74,83.04 198.74,83.05 198.68,83.11 198.2,83.11 198.07,83.24 198.07,83.63 198.29,83.85 200.44,83.85
GND on BOTTOM (solid shape): 209.58,95.31 209.58,91.39 209.71,91.26 209.71,84.13 209.51,83.93 205.51,83.93 205.42,84.02 205.42,84.67 205.95,85.2 205.96,85.2 206.07,85.26 206.13,85.37 206.13,85.38 206.21,85.46 206.24,85.48 206.27,85.47 206.7,85.59 206.71,86.03 206.71,86.88 206.72,86.91 206.76,86.93 208.43,86.93 208.85,87.35 208.85,88.87 208.44,89.28 208.44,90.26 207.93,90.77 207.93,93.56 208.06,93.69 208.06,95.18 208.44,95.56 209.33,95.56
GND on BOTTOM (solid shape): 193.2,132.42 193.2,131.16 193.14,131.06 193.03,131.08 192.42,130.8 193.03,130.52 193.14,130.54 193.2,130.44 193.2,130.09 193,129.88 193,129.76 191.17,129.76 191.04,129.88 191.04,130.65 191.8,131.41 191.8,132.68 191.88,132.76 192.86,132.76
GND on BOTTOM (solid shape): 215.24,95.5 215.25,95.47 215.25,92.71 215.05,92.51 214.79,92.51 214.54,92.26 214.54,91.06 214.54,91.03 214.52,91.02 214.41,90.62 214.74,90.37 214.78,90.35 214.79,90.32 214.79,88.23 216.06,86.96 216.06,85.18 215.54,84.66 215.52,84.66 215.38,84.59 215.31,84.45 215.31,84.44 214.92,84.04 213.77,84.04 213.65,84.16 213.65,87.7 213.53,87.82 213.53,88.44 213.26,88.71 213.26,90.74 213.76,91.25 213.76,91.78 213.77,91.79 213.77,95.44 213.9,95.56 215.18,95.56
GND on BOTTOM (solid shape): 340.65,110.15 340.65,107.91 340.39,107.66 340.09,107.66 339.93,107.81 339.93,108.92 340.01,109 340.29,109.12 340.16,109.38 340.14,109.39 340.12,109.42 340.12,109.43 340.14,109.47 340.17,109.48 340.34,109.65 340.17,109.81 339.99,109.81 339.91,109.83 339.87,109.91 339.87,109.93 339.86,109.95 339.86,110.12 339.93,110.2 340.6,110.2
GND on BOTTOM (solid shape): 358.3,43.02 358.3,41.11 358.05,40.86 357.79,40.86 357.38,40.45 357.15,40.45 357.05,40.35 355.53,40.35 355.38,40.5 355.38,40.93 355.56,40.93 355.81,41.19 355.81,41.24 357.04,41.24 357.04,41.19 357.06,41.13 357.08,41.08 357.1,41.04 357.13,40.99 357.17,40.95 357.22,40.92 357.27,40.9 357.32,40.88 357.37,40.87 357.42,40.87 357.48,40.88 357.53,40.89 357.58,40.91 357.63,40.94 357.67,40.97 357.7,41.01 357.73,41.06 357.76,41.11 357.77,41.16 357.78,41.21 357.78,41.27 357.77,41.32 357.76,41.37 357.73,41.42 357.7,41.46 357.67,41.5 357.63,41.54 357.58,41.57 357.53,41.59 357.48,41.6 357.42,41.61 357.37,41.61 357.32,41.6 357.27,41.58 357.22,41.55 357.17,41.52 357.13,41.49 357.1,41.44 357.08,41.4 357.06,41.35 357.04,41.29 357.04,41.24 355.81,41.24 355.81,41.42 356.01,41.62 356.14,41.62 356.22,41.7 356.53,41.7 357.98,43.14 358.17,43.14
GND on BOTTOM (solid shape): 243.38,154.48 243.38,150.79 242.86,150.27 242.86,149.01 241.99,148.14 241.12,148.14 240.81,148.15 240.69,148.27 240.81,148.4 241.12,148.4 241.12,148.65 240.81,148.65 240.69,148.77 240.81,148.9 241.12,148.9 241.12,149.15 240.81,149.15 240.69,149.27 240.81,149.4 241.12,149.4 241.12,149.65 240.56,149.65 240.53,149.66 240.51,149.7 240.51,150.74 240.06,151.19 239.43,151.19 239.17,151.44 239.17,154.65 239.43,154.9 242.95,154.9
GND on BOTTOM (solid shape): 178.35,59.01 178.35,57.6 178.34,57.56 178.3,57.55 178.23,57.55 178.23,55.86 178.17,55.8 178.03,55.8 177.99,55.81 177.98,55.85 177.98,57.55 177.88,57.55 177.85,57.56 177.83,57.6 177.83,57.65 177.38,57.65 177.38,57.6 177.36,57.56 177.33,57.55 177.23,57.55 177.23,55.85 177.22,55.81 177.18,55.8 177.03,55.8 176.99,55.81 176.98,55.85 176.98,57.55 176.88,57.55 176.85,57.56 176.83,57.6 176.83,57.65 176.38,57.65 176.38,57.6 176.36,57.56 176.33,57.55 176.23,57.55 176.23,55.85 176.22,55.81 176.18,55.8 176,55.8 175.98,55.81 175.98,57.55 175.98,58.75 176.77,59.54 177.83,59.54
GND on BOTTOM (solid shape): 212,39.84 212.5,39.84 212.63,39.71 212.63,39.08 213.14,38.57 213.14,37.86 213.12,37.82 213.09,37.81 213.02,37.81 212.98,37.82 212.97,37.86 212.97,38.2 212.72,38.2 212.72,37.86 212.71,37.82 212.67,37.81 212.52,37.81 212.48,37.82 212.47,37.86 212.47,38.2 212.22,38.2 212.22,37.86 212.21,37.82 212.17,37.81 212.02,37.81 211.98,37.82 211.97,37.86 211.97,38.2 211.72,38.2 211.72,37.86 211.71,37.82 211.67,37.81 210.6,37.81 210.22,37.43 210.22,36.29 209.96,36.03 207.93,36.03 207.55,36.41 207.55,37.17 208.19,37.81 208.19,39.08 208.69,39.59 208.69,40.1 208.82,40.22 211.61,40.22
GND on BOTTOM (solid shape): 164.45,26.76 172.63,26.76 172.79,26.6 172.79,26.16 172.5,25.87 172.09,25.87 171.89,25.67 171.89,24.27 172.14,24.02 176.36,24.02 176.38,23.99 176.38,23.33 176.28,23.23 171.28,23.23 170.05,24.46 168.28,24.46 168.08,24.65 159.23,24.65 158.77,25.11 158.77,25.14 158.68,25.22 158.68,25.77 170.83,25.77 170.84,25.72 170.85,25.66 170.87,25.61 170.89,25.57 170.93,25.52 170.97,25.49 171.01,25.46 171.06,25.43 171.11,25.41 171.16,25.4 171.22,25.4 171.27,25.41 171.32,25.42 171.37,25.44 171.42,25.47 171.46,25.5 171.49,25.54 171.52,25.59 171.55,25.64 171.56,25.69 171.57,25.74 171.57,25.8 171.56,25.85 171.55,25.9 171.52,25.95 171.49,26 171.46,26.04 171.42,26.07 171.37,26.1 171.32,26.12 171.27,26.13 171.22,26.14 171.16,26.14 171.11,26.13 171.06,26.11 171.01,26.09 170.97,26.05 170.93,26.02 170.89,25.97 170.87,25.93 170.85,25.88 170.84,25.82 170.83,25.77 158.68,25.77 158.68,26.98 158.83,27.13 164.08,27.13
GND on BOTTOM (solid shape): 130.72,26.75 130.72,25.63 130.95,25.4 131.95,25.4 132.11,25.24 132.11,25.22 132.59,24.53 133.41,24.69 133.73,25.02 134.14,25.02 134.72,25.28 134.9,25.88 134.88,26 134.83,26.11 134.84,26.21 134.92,26.25 137.7,26.25 137.83,26.13 137.83,25.49 137.19,24.86 137.19,23.46 137.07,23.33 116.49,23.33 116.11,23.71 116.11,26.13 116.1,26.13 116.1,27.03 116.22,27.15 130.33,27.15
GND on BOTTOM (solid shape): 252.41,84.8 252.41,84.28 252.41,84.24 252.41,84.2 251.98,84.19 251.87,83.78 251.97,83.49 252.25,83.35 252.29,83.34 252.3,83.3 252.3,83.14 252.12,82.96 251.39,82.96 251.35,82.98 251.3,83.04 251.25,83.08 250.92,83.4 250.92,83.59 251.03,83.71 251.44,83.71 251.46,83.73 251.67,84.02 251.39,84.23 251.37,84.23 251.09,84.51 251.09,84.84 251.17,84.93 252.28,84.93
GND on BOTTOM (solid shape): 203.61,67.17 203.61,65.08 203.87,64.83 207.3,64.83 207.42,64.7 207.42,63.94 207.55,63.81 208.44,63.81 208.95,64.32 208.95,64.7 209.07,64.83 212.76,64.83 212.88,64.7 212.88,64.07 213.14,63.81 213.9,63.81 215.4,65.31 215.4,65.65 215.5,65.75 216.41,65.75 216.57,65.6 216.57,65.21 216.95,64.83 220.38,64.83 220.5,64.7 220.5,64.07 220.76,63.81 221.52,63.81 222.03,64.32 222.03,64.7 222.16,64.83 225.84,64.83 225.97,64.7 225.97,64.07 226.22,63.81 226.98,63.81 227.49,64.32 227.49,64.75 227.5,64.78 227.52,64.8 227.74,65.04 227.68,65.37 227.67,65.38 227.67,65.42 227.74,65.5 229.27,65.5 229.65,65.11 229.65,62.29 229.52,62.16 190.91,62.16 190.79,62.29 190.79,64.7 190.91,64.83 194.22,64.83 194.34,64.7 194.34,63.94 194.47,63.81 195.36,63.81 196.37,64.83 199.68,64.83 199.8,64.7 199.8,64.07 200.06,63.81 200.82,63.81 201.33,64.32 201.33,67.5 201.43,67.6 203.18,67.6
GND on BOTTOM (solid shape): 218.93,117.77 218.93,117.62 218.88,117.57 218.79,117.5 218.73,117.4 218.73,117.39 218.5,117.17 218.5,116.97 218.48,116.93 218.42,116.86 217.52,115.96 217.48,115.93 217.45,115.9 217.42,115.86 217.28,115.72 216.98,115.72 214.23,112.97 213.81,112.97 213.8,112.98 213.48,112.93 213.39,112.62 213.42,112.54 213.48,112.47 213.49,112.46 213.5,112.44 213.5,112.19 212.99,111.68 212.99,111.63 212.92,111.56 212.9,111.56 212.8,111.53 212.71,111.49 212.7,111.48 212.58,111.48 212.13,111.93 212.13,112.64 213.5,114.02 214.46,114.02 215.27,114.83 215.46,114.83 215.49,114.86 215.65,114.95 215.74,115.11 215.79,115.15 215.79,115.34 217.18,116.73 217.44,116.73 217.48,116.77 217.52,116.82 218.6,117.9 218.81,117.9
GND on BOTTOM (solid shape): 188.83,62.24 188.83,54.19 188.42,53.79 187.28,53.79 187.2,53.86 187.2,54.9 187.25,54.98 187.34,54.99 187.85,55.34 187.34,55.68 187.25,55.69 187.2,55.77 187.2,59.6 187.25,59.68 187.34,59.69 187.85,60.03 187.34,60.38 187.25,60.39 187.2,60.47 187.2,62.24 187.41,62.45 188.63,62.45
GND on BOTTOM (solid shape): 211.08,118.51 211.31,118.51 211.91,117.91 211.91,117.48 211.42,116.99 211.17,116.75 208.85,114.42 208.52,114.42 208.44,114.5 208.44,114.8 210.34,116.7 210.34,116.7 210.42,116.76 210.48,116.84 210.48,116.84 211.15,117.51 211.15,117.79 210.93,118 210.47,118 209.92,117.45 209.64,117.45 209.05,118.03 208.65,118.03 208.57,118.03 208.39,117.85 208.39,117.79 208.38,117.7 208.39,117.61 208.39,117.27 208.85,116.81 208.87,116.77 208.9,116.74 208.9,116.4 208.72,116.23 208.19,116.23 207.8,116.61 207.8,117.9 207.85,117.98 207.94,117.99 208.41,118.33 207.94,118.66 207.85,118.68 207.8,118.76 207.8,118.96 208.19,119.35 210.25,119.35
GND on BOTTOM (solid shape): outline of 99 points within 164.88,19.37 175.93,21.17
GND on BOTTOM (solid shape): outline of 92 points within 137.14,142.3 176.82,156.89
GND on BOTTOM (solid shape): 253.14,53.27 253.14,53.2 252.25,52.31 252.25,52.24 252.25,52.23 252.23,52.13 252.25,52.02 252.25,52.01 252.25,50.96 251.9,50.61 251.49,50.61 250.98,51.12 250.98,51.61 251.25,51.87 251.27,51.87 251.53,52.13 251.27,52.38 251.2,52.41 251.17,52.48 250.92,52.74 250.66,52.48 250.66,52.46 250.52,52.31 250.41,52.3 250.35,52.39 250.35,52.82 250.51,52.99 250.71,52.99 250.92,52.89 251.15,52.95 251.17,52.95 251.25,52.95 251.39,52.87 251.54,52.87 251.62,52.87 251.67,52.81 251.78,52.69 251.95,52.65 252.06,52.65 252.83,53.43 252.99,53.43
GND on BOTTOM (solid shape): outline of 81 points within 196.76,153.42 200.7,157.01
GND on BOTTOM (solid shape): outline of 157 points within 303.31,50.94 312.76,56.63
GND on BOTTOM (solid shape): 263.88,67.45 263.9,67.44 264.02,67.37 264.13,67.35 264.22,67.32 264.25,67.23 264.24,67.15 264.25,67.07 264.25,67.05 264.24,67.03 264.12,66.92 264.12,66.87 264.11,66.85 264.12,66.54 264.43,66.52 264.52,66.54 264.59,66.49 264.61,66.45 264.64,66.41 264.67,66.34 264.64,66.27 264.17,65.79 264.15,65.78 264.13,65.78 263.97,65.72 263.91,65.56 263.91,65.54 263.9,65.52 263.76,65.38 263.72,65.38 263.65,65.4 263.61,65.47 263.52,65.63 263.35,65.68 263.28,65.7 263.24,65.76 263.21,65.84 263.16,65.92 263.14,66.01 263.2,66.08 263.35,66.24 263.33,66.46 263.32,66.47 263.32,66.51 263.39,66.57 263.39,66.6 263.41,66.62 263.58,66.94 263.39,67.24 263.36,67.27 263.37,67.31 263.38,67.34 263.42,67.39 263.49,67.4 263.61,67.4 263.72,67.44 263.73,67.45
GND on BOTTOM (solid shape): 265.43,69 265.45,68.98 265.46,68.96 265.46,68.63 265.42,68.55 265.32,68.54 264.87,68.32 265.09,67.86 265.15,67.8 265.14,67.72 265.09,67.55 265.12,67.38 265.12,67.3 265.06,67.24 265.05,67.24 264.98,67.24 264.92,67.3 264.75,67.48 264.49,67.5 264.4,67.52 264.36,67.6 264.25,67.82 264.01,67.84 263.93,67.84 263.88,67.89 263.67,68.09 263.39,68.07 263.32,68.07 263.26,68.12 263.23,68.17 263.18,68.21 263.15,68.29 263.18,68.36 263.28,68.52 263.29,68.71 263.28,68.73 263.31,68.76 263.36,68.76 263.59,68.53 263.77,68.53 263.98,68.48 264.15,68.62 264.21,68.68 264.29,68.67 264.42,68.65 264.53,68.71 264.57,68.74 264.61,68.79 264.63,68.85 264.66,68.91 264.73,68.93 264.82,68.94 264.89,68.98 264.91,69 265.38,69 265.38,69 265.41,69.01
GND on BOTTOM (solid shape): 40.77,149.99 41.17,149.79 41.25,149.36 32.41,120.68 31.89,118.85 31,111.07 31.69,103.27 31.58,103.16 29.88,102.71 29.5,102.71 28.86,103.34 28.86,105.06 30.2,106.4 30.04,112.78 30.91,119.1 31.43,120.97 38.51,143.94 38.51,145.63 37.88,146.27 29.75,146.27 29.12,146.9 29.12,148.47 28.61,148.98 19.2,148.98 19.2,141.2 18.46,139.42 16.68,138.68 11.87,138.68 8.32,135.12 8.32,134.49 7.61,133.78 7.36,133.78 7.35,133.8 7.07,133.96 6.75,134.02 5.55,134.02 4.91,133.76 4.64,133.12 4.64,132.85 4.63,132.81 4.59,132.8 0.56,132.8 0.52,132.81 0.51,132.85 0.51,139.2 0.65,139.55 1,139.69 16.68,139.69 17.75,140.13 18.19,141.2 18.19,149.5 18.33,149.85 18.68,149.99
GND on BOTTOM (solid shape): outline of 123 points within 112.94,56.13 121.23,60.19
GND on BOTTOM (solid shape): outline of 144 points within 331.88,63.57 348.14,75.4
GND on BOTTOM (solid shape): outline of 125 points within 132.47,56.13 140.24,59.6
GND on BOTTOM (solid shape): 250.3,80.88 250.39,80.9 250.46,80.85 250.64,80.67 250.89,80.65 250.98,80.62 251.01,80.52 251,80.48 251,80.44 251.01,80.37 251.04,80.31 251.1,80.25 251.18,80.21 251.25,80.14 251.22,80.05 250.84,79.67 250.84,79.61 250.83,79.57 250.79,79.51 250.72,79.5 250.42,79.4 250.32,79.1 250.29,79.03 250.22,78.99 250.09,78.95 250,78.86 249.92,78.8 249.83,78.84 249.78,78.9 249.71,78.94 249.66,78.99 249.69,79.17 249.74,79.25 249.84,79.25 250.12,79.26 250.21,79.54 249.96,79.72 249.72,79.53 249.65,79.47 249.56,79.49 249.48,79.53 249.4,79.56 249.34,79.61 249.32,79.68 249.32,79.79 249.26,79.89 249.19,79.94 249.11,79.96 249.04,80 249.02,80.08 249.02,80.15 248.95,80.26 248.95,80.3 248.96,80.33 248.98,80.34 249.02,80.36 249.05,80.35 249.07,80.33 249.17,80.27 249.29,80.28 249.32,80.29 249.39,80.31 249.45,80.27 249.55,80.19 249.69,80.15 249.84,80.18 249.98,80.27 250.06,80.42 250.06,80.6 250.05,80.61 250.06,80.64
GND on BOTTOM (solid shape): 235.24,52.29 235.24,49.45 235.22,49.43 235.21,49.42 235.1,49.34 235.02,49.23 235,49.02 235.09,48.84 235.12,48.77 235.09,48.7 234.97,48.37 235.18,48.09 235.2,48.08 235.24,48.04 235.24,46.27 235.19,46.18 235.1,46.17 234.61,45.82 235.1,45.47 235.19,45.46 235.24,45.38 235.24,44.99 235.19,44.9 235.1,44.89 234.65,44.71 234.77,44.24 234.81,44.16 234.77,44.08 234.61,43.81 234.72,43.52 234.74,43.45 234.72,43.38 234.67,42.93 235.1,42.78 235.19,42.77 235.24,42.68 235.24,41.66 235.22,41.63 235.19,41.61 235.11,41.61 235.1,41.6 235.08,41.6 235.06,41.6 234.66,41.42 234.72,40.98 234.74,40.91 234.72,40.84 234.67,40.39 235.1,40.24 235.19,40.23 235.24,40.14 235.24,37.17 234.11,36.04 233.47,36.04 233.31,35.88 231.43,35.88 231.31,35.99 231.31,36.63 231.35,36.67 232.92,36.67 233.43,37.17 233.84,37.17 234.09,37.43 234.09,52.29 234.22,52.41 235.11,52.41
GND on BOTTOM (solid shape): outline of 106 points within 329.7,97.4 367.95,139.12
GND on BOTTOM (solid shape): outline of 160 points within 165.51,55.75 175.23,59.25
GND on BOTTOM (solid shape): outline of 92 points within 341.15,93.89 344.05,96.99
GND on BOTTOM (solid shape): outline of 141 points within 156.88,55.75 164.75,60.81
GND on BOTTOM (solid shape): outline of 155 points within 121.98,56.13 131.73,58.97
GND on BOTTOM (solid shape): outline of 168 points within 207.75,105.75 220.81,116.96
GND on BOTTOM (solid shape): outline of 124 points within 259.11,68.97 263.71,72.92
GND on BOTTOM (solid shape): outline of 184 points within 345.03,112.42 348.27,115.67
GND on BOTTOM (solid shape): outline of 142 points within 30.77,67.78 139.22,161.49
GND on BOTTOM (solid shape): outline of 260 points within 181.13,65.95 332.9,161.49
GND on BOTTOM (solid shape): outline of 937 points within 327.62,16.22 369.97,155.2
GND on BOTTOM (solid shape): outline of 1180 points within 0.51,0.51 337.09,117.58
GND on BOTTOM (solid shape): outline of 1517 points within 340.38,109.47 350.43,119.6
GND on BOTTOM (solid shape): outline of 1409 points within 156.88,39.46 179.04,49.24
GND on BOTTOM (solid shape): outline of 1947 points within 111.97,39.46 140.62,49.11
GND on BOTTOM (solid shape): outline of 10235 points within 238.39,54.89 263.13,80.94
GND on GND (solid shape): outline of 236788 points within 0.51,0.51 369.97,161.49
GND on IN1 (solid shape): 141.43,148.78 141.43,146.88 141.15,146.6 137.98,146.6 137.17,147.41 137.17,148.81 137.42,149.06 141.15,149.06
GND on IN1 (solid shape): 159.24,148.78 159.24,146.8 159.11,146.67 156.06,146.67 155.86,146.88 155.86,148.66 156.22,149.01 159.01,149.01
GND on IN1 (solid shape): 168.46,148.86 168.46,146.88 168.28,146.7 165.54,146.7 165.36,146.88 165.36,148.86 165.54,149.04 168.28,149.04
GND on IN1 (solid shape): 274.22,63.78 274.22,63.66 271.68,61.12 271.55,61.12 270.28,62.39 270.28,62.51 272.82,65.05 272.95,65.05
GND on IN1 (solid shape): 150.32,148.78 150.32,146.88 150.07,146.62 145.83,146.62 145.12,147.33 145.12,148.58 145.32,148.78 146.77,148.78 147.02,149.04 150.07,149.04
GND on IN1 (solid shape): 22.64,131.92 22.64,131.41 22.13,130.9 22.13,129.25 21.88,129 17.81,129 17.63,129.17 17.63,130.22 18.07,130.65 18.07,132.17 18.19,132.3 22.26,132.3
GND on IN1 (solid shape): 176.38,155.64 176.38,145.89 176.16,145.66 170.21,145.66 170.03,145.84 170.03,147.84 170.31,148.12 170.31,154.19 171.63,155.51 174.23,155.51 174.81,156.1 175.93,156.1
GND on IN1 (solid shape): 290.1,23.99 290.1,21.07 289.97,20.94 287.94,20.94 287.31,20.31 286.93,20.31 286.29,20.94 286.29,23.87 286.42,23.99 288.45,23.99 289.08,24.63 289.47,24.63
GND on IN1 (solid shape): 340.14,124.8 340.14,121.76 340.01,121.63 337.85,121.63 337.22,120.99 336.71,120.99 336.58,121.12 336.58,121.5 336.33,121.76 336.33,124.42 336.58,124.68 338.49,124.68 339.12,125.31 339.63,125.31
GND on IN1 (solid shape): 229.99,92.72 229.99,92.1 229.52,91.63 229.52,90.44 229.51,90.4 229.47,90.39 225.63,90.39 225.6,90.4 225.58,90.44 225.58,92.65 225.76,92.82 229.89,92.82
GND on IN1 (solid shape): 124.48,161.49 124.83,161.35 124.97,161 124.97,160.5 126.92,157.06 130.88,156.97 132.42,158.44 132.99,160.5 132.99,161 132.99,161.04 132.99,161.08 133,161.12 133.01,161.15 133.03,161.19 133.04,161.22 133.06,161.26 133.08,161.29 133.11,161.32 133.13,161.35 133.16,161.37 133.19,161.4 133.22,161.42 133.26,161.44 133.29,161.45 133.33,161.47 133.37,161.48 133.4,161.49 133.44,161.49 133.48,161.49 138.56,161.49 138.56,157.98 137.04,156.45 131.95,156.45 131.54,156.18 131.1,155.94 128.48,155.5 126,156.45 122.72,156.45 122.72,156.44 121.96,156.44 121.79,156.62 121.79,156.89 122.92,161.13 123.1,161.39 123.4,161.49
GND on IN1 (solid shape): 200.53,7.46 202.72,7.46 204.5,5.68 204.5,3.17 206.15,1.52 208.35,1.52 210.73,3.9 212.25,3.9 212.9,3.25 212.9,1.51 213.3,1.11 229.65,1.11 230.06,1.52 230.16,1.52 230.66,2.03 230.66,3.39 230.92,3.65 232.7,3.65 233.82,2.52 263.18,2.52 264.34,2.29 265.32,1.64 265.44,1.52 268.17,1.52 268.29,1.64 269.27,2.29 270.43,2.52 295.18,2.52 296.34,2.29 297.32,1.64 297.44,1.52 336.93,1.52 337.09,1.36 337.09,0.76 336.84,0.51 297.43,0.51 297.05,0.58 296.73,0.8 296.6,0.92 295.95,1.36 295.18,1.51 270.43,1.51 269.66,1.35 269.01,0.92 268.89,0.8 268.56,0.58 268.18,0.51 265.43,0.51 265.05,0.58 264.73,0.8 264.6,0.92 263.95,1.36 263.18,1.51 235.88,1.51 235.3,1.42 234.77,1.17 234.03,0.67 233.76,0.55 233.48,0.51 197.21,0.51 196.86,0.65 196.72,1 196.72,10.34 196.88,10.5 197.48,10.5
GND on IN1 (solid shape): outline of 97 points within 0.51,69.7 120.48,150.15
GND on IN1 (solid shape): outline of 149 points within 175.83,65.95 327.18,161.49
GND on IN1 (solid shape): outline of 190 points within 327.62,16.25 369.97,155.2
GND on IN1 (solid shape): outline of 709 points within 332.24,63.55 348.39,76.06
GND on IN1 (solid shape): outline of 869 points within 0.51,0.51 186.44,117.58
GND on IN1 (solid shape): outline of 5049 points within 125.38,131.21 187.93,157.27
GND on VCC (solid shape): 310.4,73.28 310.43,73.26 310.5,73.14 310.83,72.74 311.27,72.48 311.3,72.46 311.3,72.43 311.3,71.71 311.07,71.48 308.36,71.48 306.65,70.97 304.92,70.54 301.4,67.02 301.4,66.26 301.02,65.88 288.78,65.88 288.32,66.33 288.32,71.31 288.36,71.39 288.44,71.41 299.54,70.73 310.37,73.28
GND on VCC (solid shape): outline of 1389 points within 95.49,0.51 186.56,12.54
GND on VCC (solid shape): outline of 2608 points within 84.41,74.89 138.21,161.49
GND on VCC (solid shape): outline of 8409 points within 0.51,38.01 46.01,149.99
GND on VCC (solid shape): outline of 21661 points within 322.23,15.46 369.97,155.2
GND on VCC (solid shape): outline of 28569 points within 108.26,32.98 184.69,108.17
GND on VCC (solid shape): outline of 47791 points within 129.7,45.56 269.72,161.49
GND on IN2 (solid shape): 22.64,131.92 22.64,131.41 22.13,130.9 22.13,129.25 21.88,129 17.81,129 17.43,129.38 17.43,130.01 18.07,130.65 18.07,132.17 18.19,132.3 22.26,132.3
GND on IN2 (solid shape): 274.22,63.78 274.22,63.66 271.75,61.18 271.61,61.18 271.36,61.44 271.23,61.44 270.29,62.38 270.29,62.39 270.78,62.88 270.78,63 272.82,65.05 272.95,65.05
GND on IN2 (solid shape): 290.1,23.99 290.1,21.07 289.97,20.94 287.94,20.94 287.31,20.31 286.93,20.31 286.29,20.94 286.29,23.87 286.42,23.99 288.45,23.99 289.08,24.63 289.47,24.63
GND on IN2 (solid shape): 230.03,92.77 230.03,92.13 229.52,91.63 229.52,90.1 229.39,89.97 225.24,89.97 224.82,90.39 224.82,90.77 225.58,91.53 225.58,92.9 225.71,93.02 229.78,93.02
GND on IN2 (solid shape): 340.14,124.8 340.14,121.76 340.01,121.63 337.85,121.63 337.22,120.99 336.71,120.99 336.58,121.12 336.58,121.5 336.33,121.76 336.33,124.42 336.58,124.68 338.49,124.68 339.12,125.31 339.63,125.31
GND on IN2 (solid shape): 200.53,7.46 201.2,7.46 204.5,4.15 204.5,3.17 206.15,1.52 208.35,1.52 210.73,3.9 212.12,3.9 213.01,3.01 213.01,1.49 213.39,1.11 229.65,1.11 230.66,2.12 230.66,3.14 231.17,3.65 232.32,3.65 233.85,2.11 264.71,2.11 265.03,1.89 265.32,1.64 265.44,1.52 268.17,1.52 268.29,1.64 268.58,1.89 268.9,2.11 272.79,2.11 273.21,2.52 295.18,2.52 296.34,2.29 297.32,1.64 297.44,1.52 336.93,1.52 337.09,1.36 337.09,0.76 336.84,0.51 297.43,0.51 297.05,0.58 296.73,0.8 296.6,0.92 295.95,1.36 295.18,1.51 270.43,1.51 269.66,1.35 269.01,0.92 268.89,0.8 268.56,0.58 268.18,0.51 265.43,0.51 265.05,0.58 264.73,0.8 264.6,0.92 263.95,1.36 263.18,1.51 235.88,1.51 235.3,1.42 234.77,1.17 234.03,0.67 233.76,0.55 233.48,0.51 197.21,0.51 196.86,0.65 196.72,1 196.72,10.34 196.88,10.5 197.48,10.5
GND on IN2 (solid shape): 341.15,73.63 345.99,73.63 346.61,74.25 347.08,74.25 347.18,74.15 347.18,65.5 346.63,64.95 346.05,64.95 346.04,64.98 345.83,65.15 345.57,65.08 345.5,65.05 345.23,65.15 344.96,65.05 344.89,65.07 344.69,65.15 344.48,65.07 344.41,65.04 344.34,65.07 344.14,65.15 343.93,65.07 343.85,65.05 343.78,65.08 343.5,65.19 343.27,64.99 343.26,64.95 341.41,64.95 341.18,64.95 341.16,64.98 340.89,65.18 340.61,64.98 340.6,64.95 340.29,64.95 340.27,64.96 340.25,64.98 340.12,64.98 339.91,65.05 339.69,64.97 339.62,64.96 339.55,64.99 339.33,65.1 339.11,65.01 339.04,64.97 338.96,65 338.7,65.07 338.43,64.84 338.34,64.86 337.77,64.52 338.43,64.5 338.5,64.57 338.59,64.55 338.7,64.5 338.86,64.5 339.38,63.98 339.4,63.94 339.38,63.91 339.17,63.69 336.59,63.69 336.59,63.69 332.63,63.69 331.93,64.38 331.93,66.78 331.76,66.95 331.76,73.04 332.98,74.26 340.52,74.26
GND on IN2 (solid shape): outline of 101 points within 0.51,67.76 126.19,161.49
GND on IN2 (solid shape): outline of 190 points within 327.62,16.25 369.97,155.2
GND on IN2 (solid shape): outline of 156 points within 175.83,65.95 334.39,161.49
GND on IN2 (solid shape): outline of 907 points within 0.51,0.51 186.44,117.58
GND on IN2 (solid shape): outline of 1375 points within 137.01,142.48 176.54,156.02
GND on IN3 (solid shape): 22.64,131.92 22.64,131.41 22.13,130.9 22.13,129.25 21.88,129 17.81,129 17.43,129.38 17.43,130.01 18.07,130.65 18.07,132.17 18.19,132.3 22.26,132.3
GND on IN3 (solid shape): 230.03,92.77 230.03,92.13 229.52,91.63 229.52,90.1 229.39,89.97 225.24,89.97 224.82,90.39 224.82,90.77 225.58,91.53 225.58,92.9 225.71,93.02 229.78,93.02
GND on IN3 (solid shape): 290.1,23.99 290.1,21.07 289.97,20.94 287.94,20.94 287.31,20.31 286.93,20.31 286.29,20.94 286.29,23.87 286.42,23.99 288.45,23.99 289.08,24.63 289.47,24.63
GND on IN3 (solid shape): 340.14,124.8 340.14,121.76 340.01,121.63 337.85,121.63 337.22,120.99 336.71,120.99 336.58,121.12 336.58,121.5 336.33,121.76 336.33,124.42 336.58,124.68 338.49,124.68 339.12,125.31 339.63,125.31
GND on IN3 (solid shape): 272.77,64.99 272.8,65.01 272.84,64.99 274.16,63.67 274.18,63.63 274.16,63.6 271.68,61.12 271.55,61.12 270.28,62.39 270.28,62.51
GND on IN3 (solid shape): outline of 219 points within 331.63,63.69 347.04,76.06
GND on IN3 (solid shape): outline of 516 points within 136.25,140.22 145.35,158.76
GND on IN3 (solid shape): outline of 601 points within 145.09,140.32 153.96,157.16
GND on IN3 (solid shape): outline of 623 points within 153.14,141.06 161.32,157.32
GND on IN3 (solid shape): outline of 114 points within 0.51,67.78 137.69,161.49
GND on IN3 (solid shape): outline of 936 points within 162.54,140.17 189.39,158.79
GND on IN3 (solid shape): outline of 1150 points within 0.51,0.51 337.09,117.58
GND on IN3 (solid shape): outline of 389 points within 169.42,16.25 369.97,161.49
GND on GND1 (solid shape): outline of 239104 points within 0.51,0.51 369.97,161.49
GND on IN4 (solid shape): 274.22,63.78 274.22,63.66 272.01,61.45 271.83,61.45 270.56,62.72 270.55,62.75 270.56,62.79 272.82,65.05 272.95,65.05
GND on IN4 (solid shape): 290.1,23.99 290.1,21.07 289.97,20.94 287.94,20.94 287.31,20.31 286.93,20.31 286.29,20.94 286.29,23.87 286.42,23.99 288.45,23.99 289.08,24.63 289.47,24.63
GND on IN4 (solid shape): 229.79,92.56 229.79,91.89 229.52,91.63 229.52,90.1 229.39,89.97 225.84,89.97 225.82,89.99 225.09,89.99 224.82,90.26 224.82,90.77 225.58,91.53 225.58,92.9 225.7,93.01 229.34,93.01
GND on IN4 (solid shape): 340.14,124.8 340.14,121.76 340.01,121.63 337.85,121.63 337.22,120.99 336.71,120.99 336.58,121.12 336.58,121.5 336.33,121.76 336.33,124.42 336.58,124.68 338.49,124.68 339.12,125.31 339.63,125.31
GND on IN4 (solid shape): 22.64,131.92 22.64,131.41 22.13,130.9 22.13,129.25 21.88,129 17.81,129 17.6,129.21 17.6,130.18 18.07,130.65 18.07,131.93 18.08,131.97 18.12,131.98 18.89,131.98 19.21,132.3 22.26,132.3
GND on IN4 (solid shape): outline of 104 points within 233.2,74.64 239.68,81.02
GND on IN4 (solid shape): outline of 116 points within 240.52,65.95 333.58,161.49
GND on IN4 (solid shape): outline of 184 points within 327.62,16.25 369.97,155.2
GND on IN4 (solid shape): outline of 743 points within 331.76,63.59 349.28,76.06
GND on IN4 (solid shape): outline of 99 points within 0.51,67.78 138.13,161.49
GND on IN4 (solid shape): outline of 1146 points within 0.51,0.51 337.09,117.58
GND on IN4 (solid shape): outline of 3208 points within 137.11,132.68 192.67,158.28
GND on GND2 (solid shape): outline of 237976 points within 0.51,0.51 369.97,161.49
VCC1_RST# on TOP (solid shape): 267.72,30.66 268.42,30.66 268.53,30.54 268.53,29.78 268.36,29.6 267.94,29.6 267.85,29.65 267.84,29.75 267.69,30.13 267.32,29.94 267.32,29.92 267.3,29.91 267.27,29.89 267.23,29.91 267.22,29.92 267.21,29.95 267.21,30.22 266.74,30.69 266.74,30.72 266.86,30.85 267.53,30.85
VDD_SUPPLY_2P on TOP (solid shape): outline of 81 points within 339.5,95.57 343.97,101.94
2260BST1.35V on BOTTOM (solid shape): 239.04,146.62 239.17,146.75 239.3,146.62 239.3,145.22 239.17,145.09 239.17,144.58 238.89,144.31 238.18,144.31 238.03,144.46 238.03,145.25 239.04,146.26
2260LX1.35V on BOTTOM (solid shape): 247.3,152.24 247.3,145.35 247.05,145.09 240.8,145.09 240.3,145.6 240.3,146.06 240.04,146.32 240.04,146.93 239.83,147.14 239.29,147.14 239.29,147.4 241.12,147.4 241.12,147.64 240.51,147.64 240.51,147.4 239.29,147.4 239.29,150.47 239.54,150.73 240.13,150.73 240.28,150.57 240.28,150.29 240.22,150.22 240.22,148.2 240.51,147.9 242.06,147.9 243.23,149.07 243.23,149.64 243.49,149.9 245.83,149.9 246.03,150.1 246.03,152.24 246.29,152.49 247.05,152.49
2261_LX_5V on BOTTOM (solid shape): 214.66,38.95 218.73,38.95 219.36,38.32 219.36,34.25 218.73,33.62 216.31,33.62 216.06,33.87 216.06,34.89 215.68,35.27 215.68,35.65 216.03,36.01 216.03,36.97 215.7,37.3 214.28,37.3 214.23,37.25 214.23,36.62 214.15,36.54 210.85,36.54 210.73,36.67 210.73,37.43 210.85,37.56 213.27,37.56 213.33,37.62 213.34,37.63 213.45,37.74 213.97,37.74 213.97,38.2 213.72,38.2 213.72,37.74 213.47,37.74 213.47,37.76 213.52,37.81 213.52,38.44 212.76,39.21 212.76,39.71 212.88,39.84 213.77,39.84
2263_BST_1.05V on TOP (solid shape): 303.19,64.62 303.31,64.74 303.44,64.62 303.44,64.18 303.44,64.18 303.44,63.39 303.18,63.13 303.18,61.66 303.16,61.64 302.06,61.64 302.04,61.66 302.04,62.8 302.64,63.4 302.67,63.4 302.95,63.51 303.06,63.79 303.06,63.81 303.19,63.93 303.19,64.18
2263_BST_1.05V_R on TOP (solid shape): 301.81,62.47 301.85,62.46 301.86,62.42 301.86,61.38 301.65,61.17 301.4,61.06 301.29,60.81 301.15,60.67 300.9,60.67 300.83,60.74 300.76,61.01 300.52,61.16 299.99,61.69 299.99,62.31 300.15,62.46 300.94,62.46 300.96,62.47
2263_LX_1.05V on TOP (solid shape): 302.92,68.58 302.93,68.57 302.94,68.54 302.94,68.11 303.17,68.1 303.18,68.08 303.19,68.05 303.19,65.06 303.18,65.03 303.17,65.01 303.14,65 302.65,65 302.44,64.79 302.44,64.79 302.44,64.18 302.13,63.88 302.13,63.81 300.9,62.57 297.97,62.57 297.59,62.96 297.59,65.26 301.97,65.26 301.97,65.51 301.36,65.51 301.36,65.26 297.59,65.26 297.59,67.15 297.85,67.4 300.26,67.4 300.39,67.27 300.39,66 300.63,65.76 301.36,65.76 301.97,65.76 302.24,66.04 302.24,68.05 302.25,68.08 302.26,68.1 302.29,68.11 302.68,68.11 302.68,68.54 302.69,68.57 302.71,68.58
8693_VCORE_HG1 on BOTTOM (solid shape): 137.07,150.15 137.07,149.44 136.43,148.81 135.8,148.81 135.48,149.13 135.48,150.4 135.53,150.45 136.77,150.45
8693_VCORE_HG1_R on BOTTOM (solid shape): 137.88,151.67 137.88,150.96 137.78,150.86 135.57,150.86 135.46,150.96 135.46,151.7 135.57,151.8 137.75,151.8
8693_VCORE_HG2 on BOTTOM (solid shape): 145.96,149.75 145.96,149.44 145.37,148.86 144.56,148.86 144.3,149.11 144.3,150.26 144.43,150.38 145.32,150.38
8693_VCORE_HG2_R on BOTTOM (solid shape): 146.77,151.67 146.77,150.96 146.67,150.86 144.38,150.86 144.28,150.96 144.28,151.62 144.46,151.8 146.64,151.8
8693_VCORE_HG3 on BOTTOM (solid shape): 154.45,150.26 154.45,149.07 154.17,148.78 153.24,148.78 153.12,148.91 153.12,149.56 153.19,149.64 153.19,150.38 153.27,150.45 154.26,150.45
8693_VCORE_HG3_R on BOTTOM (solid shape): 155.66,151.67 155.66,150.96 155.56,150.86 153.27,150.86 153.17,150.96 153.17,151.62 153.35,151.8 155.53,151.8
8693_VCORE_HG4 on BOTTOM (solid shape): 163.63,150.07 163.63,149.11 163.36,148.83 162.52,148.83 162.34,149.01 162.34,150.38 162.41,150.45 163.25,150.45
8693_VCORE_HG4_R on BOTTOM (solid shape): 164.8,151.67 164.8,150.96 164.7,150.86 162.41,150.86 162.31,150.96 162.31,151.62 162.49,151.8 164.67,151.8
8693_VCORE_LG1 on TOP (solid shape): 142.27,154.52 142.27,153.89 142.02,153.63 141.26,153.63 141,153.89 141,154.52 141.13,154.65 142.15,154.65
8693_VCORE_LG1 on BOTTOM (solid shape): 137.8,147.28 137.8,144.89 137.67,144.76 137.22,144.76 137.09,144.89 137.09,147.28 137.17,147.35 137.73,147.35
8693_VCORE_LG2 on TOP (solid shape): 150.28,153.9 149.85,153.9 149.31,153.35 149.05,153.35 148.95,153.46 148.95,154.34 149.22,154.61 150.28,154.61
8693_VCORE_LG2 on BOTTOM (solid shape): 146.69,147.25 146.69,144.86 146.56,144.74 146.11,144.74 145.98,144.86 145.98,147.25 146.06,147.33 146.62,147.33
8693_VCORE_LG3 on TOP (solid shape): 158.16,153.9 157.72,153.9 157.21,153.38 156.85,153.38 156.72,153.51 156.72,154.27 157.07,154.61 158.16,154.61
8693_VCORE_LG3 on BOTTOM (solid shape): 155.58,147.28 155.58,144.89 155.45,144.76 155,144.76 154.87,144.89 154.87,147.28 154.95,147.35 155.51,147.35
8693_VCORE_LG4 on TOP (solid shape): 166.29,153.9 165.78,153.9 165.26,153.38 164.95,153.38 164.85,153.48 164.85,154.25 165.22,154.61 166.29,154.61
8693_VCORE_LG4 on BOTTOM (solid shape): 164.73,147.28 164.73,144.89 164.6,144.76 164.14,144.76 164.01,144.89 164.01,147.28 164.09,147.35 164.65,147.35
8693_VCORE_SW1 on TOP (solid shape): 143.03,154.25 143.16,154.38 143.28,154.25 143.28,153.9 143.58,153.6 144.76,153.6 145.52,154.36 146.16,154.36 146.23,154.29 146.23,153.51 145.87,153.14 143.19,153.14 143.03,153.31
8693_VCORE_SW1 on BOTTOM (solid shape): 142.07,145.81 143.36,145.81 144.3,144.87 144.3,142.46 144.15,142.3 142.4,142.3 142.27,142.43 142.27,143.09 142.17,143.19 141.33,143.19 141.26,143.12 141.26,142.58 140.97,142.3 138.21,142.3 138.08,142.43 138.08,146.24 138.21,146.36 141.52,146.36
8693_VCORE_SW2 on TOP (solid shape): 151.03,154.25 151.16,154.38 151.28,154.25 151.28,153.9 151.58,153.6 152.76,153.6 153.52,154.36 154.16,154.36 154.24,154.29 154.24,153.32 154.06,153.14 151.19,153.14 151.03,153.31
8693_VCORE_SW2 on BOTTOM (solid shape): 152.43,144.98 152.43,142.46 152.27,142.3 149.77,142.3 149.64,142.43 149.64,143.09 149.56,143.17 148.93,143.17 148.88,143.12 148.88,142.43 148.75,142.3 147.35,142.3 147.23,142.43 147.23,146.24 147.35,146.36 151.05,146.36
8693_VCORE_SW3 on TOP (solid shape): 158.9,154.25 159.03,154.38 159.16,154.25 159.16,153.9 159.45,153.6 160.64,153.6 161.4,154.36 162.03,154.36 162.11,154.29 162.11,153.32 161.93,153.14 159.07,153.14 158.9,153.31
8693_VCORE_SW3 on BOTTOM (solid shape): 161.44,144.86 161.44,142.46 161.28,142.3 158.66,142.3 158.53,142.43 158.53,143.12 158.48,143.17 157.79,143.17 157.77,143.14 157.77,142.43 157.64,142.3 156.24,142.3 156.12,142.43 156.12,146.24 156.24,146.36 159.94,146.36
8693_VCORE_SW4 on TOP (solid shape): 167.03,154.25 167.16,154.38 167.29,154.25 167.29,153.9 167.58,153.6 168.76,153.6 169.53,154.36 170.16,154.36 170.24,154.29 170.24,153.32 170.06,153.14 167.19,153.14 167.03,153.31
8693_VCORE_SW4 on BOTTOM (solid shape): 170.69,144.75 170.69,142.56 170.43,142.3 167.8,142.3 167.67,142.43 167.67,143.14 167.65,143.17 166.96,143.17 166.91,143.12 166.91,142.43 166.78,142.3 165.13,142.3 165.01,142.43 165.01,146.24 165.13,146.36 169.09,146.36
8813BOOT1 on BOTTOM (solid shape): 211.74,55.33 211.74,54.67 211.57,54.5 209.65,54.5 209.5,54.65 209.65,54.8 210.22,54.8 210.88,55.46 211.61,55.46
8813BOOT2 on BOTTOM (solid shape): 205.61,54.79 205.61,54.5 204.97,54.5 204.97,54.5 203.63,54.5 203.44,54.69 203.44,55.48 203.56,55.61 204.79,55.61
8813LGAT1 on BOTTOM (solid shape): 208.69,66.48 208.69,64.45 208.31,64.07 207.8,64.07 207.68,64.19 207.68,66.48 207.93,66.73 208.44,66.73
8813LGAT1 on BOTTOM (solid shape): 214.15,66.48 214.15,64.45 213.77,64.07 213.27,64.07 213.14,64.19 213.14,66.48 213.39,66.73 213.9,66.73
8813LGAT2 on BOTTOM (solid shape): 195.61,66.48 195.61,64.45 195.23,64.07 194.72,64.07 194.6,64.19 194.6,66.48 194.85,66.73 195.36,66.73
8813LGAT2 on BOTTOM (solid shape): 201.07,66.48 201.07,64.45 200.69,64.07 200.18,64.07 200.06,64.19 200.06,66.48 200.31,66.73 200.82,66.73
8813PHASE1 on BOTTOM (solid shape): 211.74,56.7 211.74,55.94 211.64,55.84 211,55.84 210.17,55 208.65,55 208.65,55.99 210.19,55.99 210.65,56.45 210.65,56.75 210.73,56.83 211.61,56.83
8813PHASE1 on BOTTOM (solid shape): 211.61,70.81 211.61,67.76 212.88,66.49 212.88,65.21 212.76,65.08 209.07,65.08 208.95,65.21 208.95,66.73 208.69,66.99 207.8,66.99 207.42,66.61 207.42,65.21 207.3,65.08 203.99,65.08 203.87,65.21 203.87,67.43 202.42,68.87 202.42,69.92 202.17,70.17 201.23,70.17 201.02,70.37 201.02,71.11 201.15,71.24 202.97,71.24 202.98,71.24 211.18,71.24
8813PHASE2 on BOTTOM (solid shape): 206.15,55.99 206.45,55.99 206.45,55 205.86,55 204.86,56 202.78,56 202.65,56.13 202.65,56.76 202.85,56.95 205.19,56.95
8813PHASE2 on BOTTOM (solid shape): 199.15,71.34 199.17,71.33 199.18,71.32 199.42,71.05 199.42,67.14 199.55,67.01 199.55,66.48 199.8,66.23 199.8,65.21 199.68,65.08 196.27,65.08 196.12,65.08 195.99,65.21 195.99,66.48 195.49,66.99 194.72,66.99 194.34,66.61 194.34,65.21 194.22,65.08 190.91,65.08 190.79,65.21 190.79,68.22 190.83,68.31 190.93,68.31 191.46,68.65 190.93,68.98 190.83,68.98 190.79,69.07 190.79,69.18 190.28,69.69 190.28,71.08 190.53,71.34
8813PVCC on BOTTOM (solid shape): 208.82,57.84 208.82,57.08 208.77,57.03 207.75,57.03 207.42,56.7 207.42,56.22 207.43,56.22 207.45,56.19 207.45,55.5 207.3,55.35 207.15,55.5 207.15,56.72 206.92,56.95 206.92,58.26 207.17,58.51 208.15,58.51
8813UGATE1 on BOTTOM (solid shape): 213.32,55.38 213.32,54.39 212.92,54 209.65,54 209.5,54.15 209.65,54.3 211.76,54.3 212.19,54.73 212.19,55.34 212.33,55.48 213.21,55.48
8813UGATE1_1 on BOTTOM (solid shape): 213.27,57.46 213.27,55.94 213.14,55.81 212.38,55.81 212.25,55.94 212.25,57.46 212.38,57.59 213.14,57.59
8813UGATE1_1 on BOTTOM (solid shape): 214.03,60.18 214.03,58.99 213.9,58.86 213.14,58.86 213.01,58.99 213.01,60.26 213.14,60.38 213.82,60.38
8813UGATE1_1 on BOTTOM (solid shape): 209.07,59.67 209.07,58.99 208.95,58.86 208.31,58.86 207.55,59.62 207.55,60.26 207.68,60.38 208.36,60.38
8813UGATE2 on BOTTOM (solid shape): 205.45,54.3 205.6,54.15 205.45,54 204.34,54 203.61,53.27 202.98,53.27 202.85,53.4 202.85,54.16 202.99,54.3
8813UGATE2_1 on BOTTOM (solid shape): 200.95,60.18 200.95,58.99 200.82,58.86 200.06,58.86 199.93,58.99 199.93,60.26 200.06,60.38 200.74,60.38
8813UGATE2_1 on BOTTOM (solid shape): 195.99,59.67 195.99,58.99 195.87,58.86 195.23,58.86 194.47,59.62 194.47,60.26 194.6,60.38 195.28,60.38
8813UGATE2_1 on BOTTOM (solid shape): 202.44,55.03 202.44,53.36 202.37,53.3 202.35,53.29 202.31,53.29 202.24,53.29 202.17,53.27 201.65,53.27 201.62,53.28 201.61,53.29 201.54,53.35 201.46,53.39 201.45,53.4 201.45,54.36 201.52,54.55 201.47,54.76 201.46,54.77 201.47,54.81 201.84,55.18 202.28,55.18
9610BOOT3 on BOTTOM (solid shape): 217.11,51.95 216.58,51.42 216.22,51.42 216.11,51.53 216.11,51.92 216.51,52.32 216.51,52.83 216.81,53.12 217.11,53.12
9610LGATE3 on BOTTOM (solid shape): 221.77,66.48 221.77,64.45 221.39,64.07 220.89,64.07 220.76,64.19 220.76,66.48 221.01,66.73 221.52,66.73
9610LGATE3 on BOTTOM (solid shape): 227.24,66.48 227.24,65.51 227.23,65.48 227.21,65.46 227.02,65.14 227.21,64.82 227.23,64.8 227.24,64.77 227.24,64.45 226.85,64.07 226.35,64.07 226.22,64.19 226.22,66.48 226.47,66.73 226.98,66.73
9610PHASE3 on BOTTOM (solid shape): 219.8,71.31 221.76,70.67 223.78,71.03 224.35,71.03 225.84,69.55 225.84,68.25 225.76,68.01 225.84,67.77 225.84,65.34 225.58,65.08 222.28,65.08 222.03,65.34 222.03,66.61 221.77,66.86 220.76,66.86 220.5,66.61 220.5,65.34 220.25,65.08 217.08,65.08 216.95,65.21 216.95,65.84 216.53,66.26 216.11,66.26 215.91,66.46 215.91,67.3 215.6,67.6 212.93,67.6 212.35,68.19 212.35,71.08 212.58,71.31
9610UGATE3 on BOTTOM (solid shape): 217.31,52.65 217.46,52.81 217.61,52.65 217.61,51.46 217.84,51.24 217.84,50.43 217.76,50.35 217.08,50.35 217,50.43 217,51.34 217.31,51.65
9610UGATE3_1 on BOTTOM (solid shape): 227.01,60.28 227.01,59.18 226.69,58.86 226.22,58.86 226.09,58.99 226.09,60.26 226.22,60.38 226.9,60.38
9610UGATE3_1 on BOTTOM (solid shape): 219.96,51.19 219.96,50.48 219.81,50.33 218.42,50.33 218.32,50.43 218.32,51.19 218.5,51.37 219.78,51.37
9610UGATE3_1 on BOTTOM (solid shape): 222.16,59.67 222.16,58.99 222.03,58.86 221.52,58.86 220.63,59.75 220.63,60.26 220.76,60.38 221.44,60.38
86903C_VCCGT_PWM1 on BOTTOM (solid shape): 120.03,127 120.5,127 120.72,126.77 120.72,125.16 120.03,125.16 120.03,125.67 120.02,125.72 119.62,126.13 119.62,126.3 119.87,126.56 119.87,126.94 119.95,127.01 120.03,127.01
86903C_VCCGT_PWM2 on BOTTOM (solid shape): 120.62,114.93 121.04,114.93 121.2,114.78 121.2,114.66 121.61,114.25 121.61,113.1 120.91,113.1 120.91,113.12 120.43,113.61 120.43,114.82 120.54,114.94 120.62,114.94
86903C_VCCGT_SW1 on BOTTOM (solid shape): 128.56,126.71 128.56,119.47 128.3,119.22 123.6,119.22 123.48,119.34 123.48,120.11 123.6,120.23 124.87,120.23 125.13,120.49 125.13,121.5 124.15,122.48 122.02,122.48 122.02,124.34 124.91,124.34 125,124.42 125,124.98 125.13,125.11 126.17,125.11 126.35,125.29 126.35,126.15 126.22,126.28 125.3,126.28 125.2,126.38 125.2,126.79 125.37,126.95 128.31,126.95
86903C_VCCGT_SW2 on BOTTOM (solid shape): 129.06,114.64 129.06,112.61 128.93,112.48 128.93,112.46 128.77,112.3 128.55,112.3 128.41,112.17 128.41,111.55 129.06,110.9 129.06,107.28 128.81,107.02 128.05,107.02 127.92,107.15 127.92,108.04 127.67,108.29 125.76,108.29 125.64,108.42 125.64,109.4 124.62,110.42 122.91,110.42 122.91,112.27 125.8,112.27 125.89,112.36 125.89,113.01 126.35,113.47 127,113.47 127.13,113.6 127.13,114.24 127.03,114.34 126.32,114.34 126.27,114.39 126.27,114.95 126.32,115 128.71,115
86903C_VCCSA_PWM on BOTTOM (solid shape): 179.26,151.03 179.26,150.6 179.2,150.55 178.88,150.55 178.36,150.02 178.36,149.82 177.56,149.82 177.56,150.52 178.12,151.09 179.2,151.09
86903C_VCCSA_SW on BOTTOM (solid shape): 176.74,145.76 177.07,145.43 177.48,145.43 177.65,145.25 177.65,144.49 177.86,144.29 178.39,144.29 178.68,144.57 178.68,145.43 178.77,145.52 179.38,145.52 179.48,145.42 179.48,143.44 179.23,143.19 172.5,143.19 172.24,143.44 172.24,146.24 172.37,146.36 173.39,146.36 173.64,146.62 173.64,147.51 173.9,147.76 174.78,147.76 175.55,148.53 176.74,148.53
+BAT_DIS on BOTTOM (solid shape): 222.59,25.41 222.59,23.92 225.03,21.48 227.9,21.48 228.05,21.32 228.05,15.53 227.3,14.78 221.7,14.78 221,15.48 221,16.14 220.56,16.59 219.93,16.59 219.69,16.83 219.69,17.95 218.74,18.9 218.74,18.91 217.48,20.17 217.48,25.36 217.76,25.64 222.36,25.64
+BATCHG on BOTTOM (solid shape): outline of 204 points within 209.28,6.4 218.37,19.3
+G_SEN_PW on TOP (solid shape): 188.96,21.78 188.96,21.02 188.94,21 188.94,20.59 188.96,20.57 188.96,19.49 188.94,19.47 188.94,19.06 188.96,19.04 188.96,18.99 189.36,18.58 190.41,18.58 190.46,18.64 190.48,18.64 190.97,19.14 190.97,19.15 191.06,19.23 191.33,19.23 191.33,19.81 191.4,19.88 191.78,19.88 191.9,19.76 191.9,18.04 191.75,17.9 189.26,17.9 188.65,18.51 188.65,20.54 188.63,20.56 188.63,21 188.44,21 188.44,20.56 187.87,20.56 187.76,20.66 187.76,21.66 187.99,21.88 188.86,21.88
+PSWOUT on TOP (solid shape): 282.58,12.82 284.77,12.82 286.19,11.39 286.19,10.08 286.15,10 286.07,9.98 285.65,9.71 285.87,9.27 285.94,9.2 285.91,9.11 285.88,9.08 281.9,9.08 281.82,9.16 281.82,10.02 281.83,10.1 281.82,10.18 281.82,10.45 281.11,11.17 281.11,12.82 280.8,13.12 280.8,13.45 280.96,13.61 281.79,13.61
+PSWOUT on BOTTOM (solid shape): 282.3,13.98 282.3,13.51 282.3,13.5 282.26,13.35 282.3,13.2 282.3,13.19 282.3,10.58 282.28,10.56 281.95,10.56 281.92,10.58 281.92,12.23 281.77,12.38 281.21,12.38 281.13,12.46 281.13,12.84 280.93,13.04 280.85,13.04 280.7,13.2 280.7,14.04 280.83,14.16 282.12,14.16
+SD_VDD2_1.8 on TOP (solid shape): 36.76,62.65 36.76,61.18 36.71,61.13 35.87,61.13 35.41,61.58 33.71,61.58 33.68,61.6 33.66,61.64 33.66,62.35 33.69,62.37 35.31,62.37 35.87,62.93 36.48,62.93
+SD_VDD2_1.8 on BOTTOM (solid shape): 29.24,67.73 29.24,66.47 29.08,66.31 29.08,65.86 28.94,65.72 28.58,65.72 28.44,65.86 28.44,66.07 28.96,66.58 29.04,66.66 29.04,66.76 29.04,66.76 29.04,67.71 29.09,67.76 29.22,67.76

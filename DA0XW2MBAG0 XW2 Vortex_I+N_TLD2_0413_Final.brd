# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Nets (continued)
GND0: CON400.1(GND0) R405.1
GND_DDR: PC14000.2 PC14008.2 PC14014.2 PC14015.2 PQ14000.1(S) PR14001.2 PR14015.1 PU14000.4(AGND)
P1V5S_PG: PR16018.1 TP16000.1
VCC1_RST#: R6056.2 R9010.2 RV6001.1 U6001.K6(V\C\C\1\_\R\S\T\/GPO77)
VCC1_RST#_R1: JCN9000.16(VCC1_RST#) R9010.1
VCC3V3_ANA: C8090.2 U8001.E16(VCC3P3_ANA)
VCC3V3_ANA_PCIE: C8089.2 R8047.2 U8001.L16(VCC3P3_ANA_PCIE)
VCC3V3_ANA_USB2: C8088.2 U8001.H18(VCC3P3_ANA_USB2)
VCC_BOOST: C9501.1 CON9500.12 R9503.1
VCCD_DP: C8506.2 U8500.B10(VCCD)
VCCGPPA_1P8V: C9305.1 R9341.2 U9002.AN32(VCCPGPPA)
VCCGT_CS: PR19022.1 PR21004.1 PR21009.1 PU19000.1(CS5)
VCCGT_CS_SUM: PR19022.2 PU19000.19(CS_SUMB)
VCCGT_PWM: PR21000.1 PR21005.1 PU19000.39(PWM5)
VCCGT_VDIFF: PR19038.1 PU19000.10(VDIFFB)
VCCGT_VFB: PR19038.2 PR19039.1 PU19000.11(VFBB)
VCCGT_VORTN: PR19044.1 PU19000.13(VORTNB)
VCCGT_VOSEN: PR19042.1 PU19000.12(VOSENB)
VCCIO_PG: PR17016.1 PR25000.1 R9128.1 R9129.2 U9000.1(INB)
VCCIO_VCCSENSE: PR17018.2 U9001.H14(VCCIO_SENSE)
VCCIO_VSSSENSE: PR17019.2 U9001.J14(VSSIO_SENSE)
VCCMPHY_SENSE: PR18012.2 U9002.K47(VCCMPHY_SENSE)
VCCPRIM_1P05_AE17: R17910.1 U9002.AE17(VCCPRIM_1P0515)
VCCSA_CS: PR19024.2 PR21014.1 PU19000.48(CS6)
VCCSA_CS_SUM: PR19024.1 PU19000.20(CS_SUMC)
VCCSA_PWM: PR21010.1 PU19000.38(PWM6)
VCCSA_VCCSENSE: PR19047.1 PR19048.2 U9001.M38(VCCSA_SENSE)
VCCSA_VDIFF: PR19053.1 PU19000.14(VDIFFC)
VCCSA_VFB: PR19053.2 PR19054.1 PU19000.15(VFBC)
VCCSA_VORTN: PR19049.1 PU19000.17(VORTNC)
VCCSA_VOSEN: PR19048.1 PU19000.16(VOSENC)
VCCSA_VSSSENSE: PR19049.2 PR19050.1 U9001.M37(VSSSA_SENSE)
VCCSENSE: PR19032.1 PR19033.2 R9047.1 U9001.AG37(VCC_SENSE)
VCCST_PWRGD: R9340.1 U9001.H13(VCCST_PWRGD)
VDD_SIM: CON9500.10 R9504.2
VDD_SUPPLY_2P: C8502.2 C8613.1 R7140.1 R7153.1 R7199.1 R8505.1 R8507.2 R8551.1 R8570.2 R8588.1 U8500.C10(VDDIO) U8500.D10(VDDD)
VIN1N: PC9801.1 PR9803.2 PU9802.12(SEN1-)
VIN1N_R: PR9803.1 TP98006.1
VIN1P: PC9801.2 PC9807.2 PR9802.2 PU9802.11(SEN1+)
VIN1P_R: PR9802.1 TP98005.1
VIN2N: PC9802.1 PR9808.2 PU9802.14(SEN2-)
VIN2N_R: PR9808.1 TP98008.1
VIN2P: PC9802.2 PC9806.1 PR9807.2 PU9802.13(SEN2+)
VIN2P_R: PR9807.1 TP98007.1
VSS_GPU_SENSE: PR9026.2 PR9028.1 U2000.L5(GND_SENSE)
VSS_GPU_SENSE_S: U2000.U2(GNDS_SENSE)
VSSMPHY_SENSE: PR18013.2 U9002.K46(VSSMPHY_SENSE)
VSSSENSE: PR19035.2 PR19037.1 R9048.1 U9001.AG38(VSS_SENSE)
2260BST1.35V: PR8002.1 PU8001.20(BST)
2260EN1.35V: PC8015.1 PR8007.2 PU8001.2(EN)
2260FB1.35V: PR8008.1 PR8009.1 PR8013.1 PU8001.5(FB)
2260FB1.35V_S: PR8006.1 PR8008.2 PR8023.1
2260LX1.35V: PC8007.2 PL8001.1 PR8004.1 PU8001.10(LX#1) PU8001.11(LX#5) PU8001.16(LX#2) PU8001.17(LX#3) PU8001.18(LX#4)
2260PFM1.35V: PR8005.2 PU8001.3(P\F\M\)
2260PG1.35V: PR8003.2 PU8001.1(PGOOD)
2260SS1.35V: PC8016.1 PU8001.23(SS)
2261_BST_5V: PR13017.2 PU13002.20(BST)
2261_EN_5V: PC13043.2 PR13022.2 PR13025.2 PR13026.1 PU13002.2(EN)
2261_FB_5V: PR13023.1 PR13024.2 PU13002.5(FB)
2261_FB_5V_S: PR13020.1 PR13023.2
2261_LX_5V: PC13036.2 PL13005.1 PR13019.2 PU13002.10(LX#1) PU13002.16(LX#2) PU13002.17(LX#3) PU13002.18(LX#4)
2261_PFM_5V: PR13021.1 PU13002.3(P\F\M\)
2261_PG_5V: PR13018.2 PU13002.1(PGOOD)
2261_SS_5V: PC13044.1 PU13002.23(SS)
2263_BST_1.05V: PR18002.2 PU18000.20(BST)
2263_BST_1.05V_R: PC18006.1 PR18002.1
2263_EN_1.05V: PC18014.2 PR18008.2 PR18011.2 PU18000.2(EN)
2263_FB_1.05V: PR18009.1 PR18010.2 PU18000.5(FB)
2263_FB_1.05V_S: PR18006.1 PR18009.2 PR18012.1
2263_LX_1.05V: PC18006.2 PL18001.1 PR18004.2 PU18000.10(LX#1) PU18000.11(LX#5) PU18000.16(LX#2) PU18000.17(LX#3) PU18000.18(LX#4)
2263_PFM_1.05V: PR18005.1 PU18000.3(P\F\M\)
2263_PG_1.05V: PR18003.2 PU18000.1(PGOOD)
2263_SS_1.05V: PC18015.1 PU18000.23(SS)
8051_RX_CAPS_LED#: JCN9000.14(8051_RX_CAPS_LED#) R6100.2 R6182.2 R6185.1 U6001.J7(GPIOB7/PWM5_LED1) U6003.3(A2)
8051_TX_LED_PWRSTBY#: JCN9000.13(8051_TX_LED_PWRSTBY#) R6068.2 R6181.2 R6186.1 U6001.H8(GPIOC0/PWM6_LED2) U6003.1(A1)
8693_VCORE_BST1: PC20009.1 PU20000.1(BST)
8693_VCORE_BST2: PC20019.1 PU20001.1(BST)
8693_VCORE_BST3: PC20033.1 PU20002.1(BST)
8693_VCORE_BST4: PC20043.1 PU20003.1(BST)
8693_VCORE_CS1: PR20002.2 PU20000.5(CS)
8693_VCORE_CS2: PR20020.2 PU20001.5(CS)
8693_VCORE_CS3: PR20032.2 PU20002.5(CS)
8693_VCORE_CS4: PR20047.2 PU20003.5(CS)
8693_VCORE_HG1: PR20000.1 PU20000.12(HGATE)
8693_VCORE_HG1_R: PQ20000.1(G1) PR20000.2
8693_VCORE_HG2: PR20015.1 PU20001.12(HGATE)
8693_VCORE_HG2_R: PQ20001.1(G1) PR20015.2
8693_VCORE_HG3: PR20030.1 PU20002.12(HGATE)
8693_VCORE_HG3_R: PQ20002.1(G1) PR20030.2
8693_VCORE_HG4: PR20046.1 PU20003.12(HGATE)
8693_VCORE_HG4_R: PQ20003.1(G1) PR20046.2
8693_VCORE_ISENN1: PR20014.2 PU20000.6(ISENN)
8693_VCORE_ISENN2: PR20029.2 PU20001.6(ISENN)
8693_VCORE_ISENN3: PR20044.2 PU20002.6(ISENN)
8693_VCORE_ISENN4: PR20059.2 PU20003.6(ISENN)
8693_VCORE_ISENP1: PR20011.2 PU20000.7(ISENP)
8693_VCORE_ISENP2: PR20026.2 PU20001.7(ISENP)
8693_VCORE_ISENP3: PR20041.2 PU20002.7(ISENP)
8693_VCORE_ISENP4: PR20056.2 PU20003.7(ISENP)
8693_VCORE_LG1: PQ20000.8(G2) PU20000.9(LGATE)
8693_VCORE_LG2: PQ20001.8(G2) PU20001.9(LGATE)
8693_VCORE_LG3: PQ20002.8(G2) PU20002.9(LGATE)
8693_VCORE_LG4: PQ20003.8(G2) PU20003.9(LGATE)
8693_VCORE_PWM1: PR20001.2 PU20000.3(PWM)
8693_VCORE_PWM2: PR20016.2 PU20001.3(PWM)
8693_VCORE_PWM3: PR20031.2 PU20002.3(PWM)
8693_VCORE_PWM4: PR20045.2 PU20003.3(PWM)
8693_VCORE_SW1: PC20009.2 PL20000.1 PQ20000.5(D2/S1#1) PQ20000.6(D2/S1#2) PQ20000.7(D2/S1#3) PR20003.1 PR20004.2 PU20000.11(SW)
8693_VCORE_SW2: PC20019.2 PL20001.1 PQ20001.5(D2/S1#1) PQ20001.6(D2/S1#2) PQ20001.7(D2/S1#3) PR20017.1 PR20018.2 PU20001.11(SW)
8693_VCORE_SW3: PC20033.2 PL20002.1 PQ20002.5(D2/S1#1) PQ20002.6(D2/S1#2) PQ20002.7(D2/S1#3) PR20033.1 PR20034.2 PU20002.11(SW)
8693_VCORE_SW4: PC20043.2 PL20003.1 PQ20003.5(D2/S1#1) PQ20003.6(D2/S1#2) PQ20003.7(D2/S1#3) PR20048.1 PR20049.2 PU20003.11(SW)
8693_VCORE_SYNC1: PR20007.2 PU20000.4(SYNC)
8693_VCORE_SYNC2: PR20022.2 PU20001.4(SYNC)
8693_VCORE_SYNC3: PR20037.2 PU20002.4(SYNC)
8693_VCORE_SYNC4: PR20052.2 PU20003.4(SYNC)
8693_VCORE_VTEMP1: PR20006.2 PU20000.2(TEMP)
8693_VCORE_VTEMP2: PR20021.2 PU20001.2(TEMP)
8693_VCORE_VTEMP3: PR20036.2 PU20002.2(TEMP)
8693_VCORE_VTEMP4: PR20051.2 PU20003.2(TEMP)
8813BOOT1: PC9009.1 PU9001.1(BOOT1)
8813BOOT2: PC9020.1 PU9001.18(BOOT2)
8813DLIM: PR9220.1 PU9001.12(SS)
8813EN: PC9211.1 PD9005.2(ANODE) PR9222.2 PU9001.3(EN)
8813ISEN1: PC9015.1 PR9011.1 PR9040.1 PU9001.15(VCC/ISEN1)
8813ISEN2: PR9021.1 PU9001.14(T\A\L\E\R\T\/ISEN2)
8813ISEN3: PC9042.1 PR9037.1 PU9001.13(TSNS/ISEN3)
8813LGAT1: PQ9001.8(G2) PQ9006.8(G2) PU9001.23(LGATE1)
8813LGAT2: PQ9004.8(G2) PQ9007.8(G2) PU9001.20(LGATE2)
8813PHASE1: PC9009.2 PL9001.1 PQ9001.5(D2/S1#1) PQ9001.6(D2/S1#2) PQ9001.7(D2/S1#3) PQ9006.5(D2/S1#1) PQ9006.6(D2/S1#2) PQ9006.7(D2/S1#3) PR9005.1 PR9011.2 PU9001.24(PHASE1)
8813PHASE1_RC: PC9014.1 PR9005.2
8813PHASE2: PC9020.2 PL9004.1 PQ9004.5(D2/S1#1) PQ9004.6(D2/S1#2) PQ9004.7(D2/S1#3) PQ9007.5(D2/S1#1) PQ9007.6(D2/S1#2) PQ9007.7(D2/S1#3) PR9016.1 PR9021.2 PU9001.19(PHASE2)
8813PHASE2_RC: PC9030.1 PR9016.2
8813PSI: PR9013.2 PR9212.1 PR9213.2 PU9001.4(PSI)
8813PVCC: PC9002.1 PR9002.2 PR9040.2 PU9001.21(PVCC)
8813PWM3: PR9029.1 PR9041.2 PU9001.22(PWM3)
8813REFADJ_R: PC9031.1 PR9015.2 PR9017.1 PR9018.1
8813REFIN: PC9032.1 PR9018.2 PR9024.1 PU9001.7(REFIN)
8813REFIN_R: PR9024.2 PR9027.1
8813RGN: PC9034.2 PC9035.1 PR9026.1 PU9001.10(RGND)
8813TON: PR9004.2 PU9001.9(TON)
8813UGATE1: PR9003.1 PU9001.2(UGATE1)
8813UGATE1_1: PQ9001.1(G1) PQ9006.1(G1) PR9003.2
8813UGATE2: PR9012.1 PU9001.17(UGATE2)
8813UGATE2_1: PQ9004.1(G1) PQ9007.1(G1) PR9012.2
9610BOOT3: PC9041.1 PD9002.1(CATHODE) PU9002.4(BOOT)
9610EN: PR9032.2 PU9002.1(EN)
9610LGATE3: PQ9005.8(G2) PQ9008.8(G2) PU9002.7(LGATE)
9610PHASE3: PC9041.2 PL9005.1 PQ9005.5(D2/S1#1) PQ9005.6(D2/S1#2) PQ9005.7(D2/S1#3) PQ9008.5(D2/S1#1) PQ9008.6(D2/S1#2) PQ9008.7(D2/S1#3) PR9037.2 PR9038.1 PU9002.2(PHASE)
9610PHASE3_RC: PC9045.1 PR9038.2
9610PWM3: PR9029.2 PU9002.5(PWM)
9610UGATE3: PR9030.1 PU9002.3(UGATE)
9610UGATE3_1: PQ9005.1(G1) PQ9008.1(G1) PR9030.2
9661_1.5V_ADJ: PR16017.2 PR16019.2 PU16001.7(ADJ)
9661_1.5V_ADJ_S: PR16016.1 PR16017.1
9661_1.5V_EN: PC16017.2 PR16015.2 PU16001.2(VEN)
9661_1.5V_POK: PR16018.2 PU16001.1(POK)
86903C_VCCGT_CS1: PR21004.2 PU21000.18(CS)
86903C_VCCGT_CS2: PR21009.2 PU21001.18(CS)
86903C_VCCGT_PWM1: PR21000.2 PU21000.15(PWM)
86903C_VCCGT_PWM2: PR21005.2 PU21001.15(PWM)
86903C_VCCGT_SW1: PC21010.2 PL2100.1 PR21003.1 PU21000.2(SW#1) PU21000.3(SW#2) PU21000.4(SW#3)
86903C_VCCGT_SW2: PC21022.2 PL2101.1 PR21008.1 PU21001.2(SW#1) PU21001.3(SW#2) PU21001.4(SW#3)
86903C_VCCGT_SYNC1: PR21002.2 PU21000.16(SYNC)
86903C_VCCGT_SYNC2: PR21007.2 PU21001.16(SYNC)
86903C_VCCGT_VTEMP1: PR21001.2 PU21000.17(VTEMP/FLT)
86903C_VCCGT_VTEMP2: PR21006.2 PU21001.17(VTEMP/FLT)
86903C_VCCSA_CS: PR21014.2 PU21002.10(CS)
86903C_VCCSA_PWM: PR21010.2 PU21002.7(PWM)
86903C_VCCSA_SW: PC21030.2 PL2102.1 PR21013.1 PU21002.2(SW#1) PU21002.3(SW#2)
86903C_VCCSA_SYNC: PR21012.2 PU21002.8(SYNC)
86903C_VCCSA_VTEMP: PR21011.2 PU21002.9(VTEMP/FLT)
+BAT_DIS: PL11000.2 PQ11000.5(D) PQ11004.3(D) PR11011.1 PR11016.2 PR11022.2
+BATCHG: PC11017.1 PC11018.1 PC12004.1 PC12005.1 PD11003.2(ANODE) PD11004.1(CATHODE) PL12000.2 PL12001.2 PL12002.2 PR11011.2 PR11017.2
+G_SEN_PW: C9502.1 R9507.1 R9508.2 U9500.2(CS) U9500.9(VDD) U9500.10(VDD_IO)
+PCH_VCCPRIM_1P8: C12025.2 R9590.1 U9002.AF19(VCCPRIM_1P81) U9002.AF20(VCCPRIM_1P82)
+PCH_VCCPRIM_1P8_R: R9590.2 R9591.2 U9002.AG19(VCCPRIM_1P83) U9002.AG20(VCCPRIM_1P84)
+PSWOUT: C7301.1 C7302.1 C7305.1 CON7300.10 R7300.2 U7300.11(SCPWR0)
+PVT_VCC: C6202.1 C6204.1 R6204.1 R6205.1 R6221.2 R6222.1 U6203.8(VDD)
+SD_VDD2_1.8: C7328.1 C7329.2 CON7301.14(NA/VDD2) EC9019.1 EC9020.2 U7301.13(SD_VDD2)
+SMDDR_VREF_CHA_DIMM_R: R1002.2 R1003.1 R1007.1
+SMDDR_VREF_CHB_DIMM_R: R1030.2 R1031.1 R1037.1
+SPI_VCC: C6201.1 C6203.1 C6500.2 C6502.2 R409.2 R6001.1 R6201.1 R6202.2 R6203.1 R6210.1 R6215.1 R6228.2 R6229.1 R6500.2 R6501.2 R6502.1 R6503.2 R6510.1 R6514.2 U6202.8(VCC) U6204.8(VCC) U6500.8(VDD#2) U6500.22(VDD#3)
+SPI_VCC_14: C6504.2 R6514.1 U6500.14(NC#8)
+TBT_SVR_IND: L8001.1 U8001.K1(SVR_IND#1) U8001.K2(SVR_IND#2) U8001.L1(SVR_IND#3) U8001.L2(SVR_IND#4)
+UIM_PWR: C4204.1 C4211.2 C4216.1 CON4200.9(VCC) CON4201.36(SIM_PWR) ESD4200.5 R4204.2 R4212.2
+VAC: PC10002.2 PC10003.2 PC10004.1 PCN10000.1(V+#1) PCN10000.2(V+#2) PD1.1 PQ10006.1(S1) PQ10006.2(S2) PQ10006.3(S3) PQ10007.1(S1) PQ10007.2(S2) PQ10007.3(S3) PQ10009.1(S) PR10010.1 PR10011.1 PR10012.1 PR12025.1
+VHIF: C6003.1 C6006.1 R6097.2 R6098.2 U6001.F1(VHIF)
+VREFCA_CHA_DIMM: C1018.2 C1020.2 C1029.1 C1048.2 C1050.2 JDIM1000.164(VREF_CA) JDIM1001.164(VREF_CA) R1003.2 R1012.2
+VREFCA_CHB_DIMM: C1081.2 C1083.1 C1087.1 C1112.2 C1114.1 JDIM1002.164(VREF_CA) JDIM1003.164(VREF_CA) R1031.2 R1039.2
+VSPI: C6001.1 C6002.2 R6029.2 U6001.H12(VSPI)
A_DE: R630.1 R631.2 U603.9(A_DE)
A_EQ1: R619.1 R620.2 U603.18(A_EQ1)
A_EQ2: R622.1 R623.2 U603.19(A_EQ2)
A_SD#: D3600.1 R3620.2 R6008.2
AC_DC#_ALERT: R2142.2 R17879.2 U6001.J8(GPIO85/I2C4_SCL0/RXD)
AC_GATE: PC10004.2 PQ10006.4(G) PQ10007.4(G) PQ10009.3(D) PR10011.2 PR10016.1
ACCEL_CLK: Q9032.1(S) R6090.1 U9500.1(SCL/SPC)
ACCEL_DATA: Q9032.4(S) R6091.1 U9500.4(SDA/SDI/SDO)
ACCEL_INT#: R9224.1 U9002.AW21(GPP_C22/UART2_RTS#) U9500.12(INT1)
ACE_I2C_SCL2: R6011.2 TP8523.1 U8500.L6(I2C_SCL_SCB1_EC/GPIO_P6.1)
ACE_I2C_SDA2: R6000.2 TP8522.1 U8500.K6(I2C_SDA_SCB1_EC/GPIO_P6.0)
ACZ_BCLK: C9186.1 R9080.2 R9603.1 U9002.BD11(HDA_BCLK/I2S0_SCLK)
ACZ_RST#: R9081.2 R9604.1 U9002.BE10(HDA_RST#/I2S1_SCLK)
ACZ_RST#_AUDIO: C3600.2 D3600.2 R9081.1 U3600.2(HDA_RESET#)
ACZ_SDIN0: R3605.1 R9083.1
ACZ_SDIN0_R: R9083.2 U9002.BE11(HDA_SDI0/I2S0_RXD)
ACZ_SDO: Q9007.3 R9084.2 R9086.1 U9002.BF12(HDA_SDO/I2S0_TXD)
ACZ_SDOUT_AUDIO: R9084.1 U3600.1(HDA_SDO)
ACZ_SYNC: R9088.2 U9002.BG13(HDA_SYNC/I2S0_SFRM)
ACZ_SYNC_AUDIO: R9088.1 U3600.59(HDA_SYNC)
ADP_A_ID: PR12024.1 PR12027.2 R6240.2
ADP_A_ID_R: C6039.2 R6240.1 U6001.E2(GPIO43/ADC2)
ADP_DET: PR11025.1 PR11027.1 PU11000.5(ACOK) U6001.M5(GPIO71/PS2_DAT3/TB2)
ADP_ID_CHK: PQ12008.2(G) PR12026.2 R6407.2
ADP_PRES_OUT: R2143.2 R6017.2 R9090.1 U9002.BG42(GPD1/ACPRESENT)
ADP_PRES_OUT_R: R6017.1 U6001.F7(GPIO02)
ALS_DET#: CON3002.10 R9380.1 R9382.1 U9002.AF47(GPP_H13/SML3CLK)
ALS_INT#: CON3002.9 R3093.2 R3094.1 U3011.2(A)
AMBER_BATLED#: R6095.1 U6001.L9(GPIOB6/PWM4_LED0) VC6001.1
AMP_BEEP: C3621.2 U3600.48(PC BEEP)
AMP_BEEP_L: C3621.1 C3626.2 R3630.1 R3631.2
AMP_CLK: R3639.2 U3601.7(TEST2) U3601.8(TEST1)
AMP_DATA_A: R3652.1 R3678.2 U3606.1(B1)
AMP_DATA_B: R3679.2 U3606.3(B0)
AMP_DATAO_BOT_LEFT: R3679.1 TP3608.1 U3603.A3(DATAO/MICDAT)
AMP_DATAO_TOP_RIGHT: R3678.1 TP3607.1 U3602.A3(DATAO/MICDAT)
AMP_LINEOUT_L: R3636.2 R3641.2
AMP_LINEOUT_R: R3637.2 R3642.2
AOZ1331_1V8AON_PWREN: PC9509.1 PR9501.1 PU9501.5(ON2)
AOZ1331_1V8MAIN_PWREN: PC9508.1 PD9501.2(ANODE) PR9504.2 PR26018.2 PU9501.3(ON1)
AUD_AZACPU_SCLK: R9091.2 U9001.G27(PROC_AUDIO_CLK)
AUD_AZACPU_SCLK_R: R9091.1 U9002.AM3(HDACPU_SCLK)
AUD_AZACPU_SDI: R9039.2 U9002.AN3(HDACPU_SDI)
AUD_AZACPU_SDI_R: R9039.1 U9001.G29(PROC_AUDIO_SDO)
AUD_AZACPU_SDO: R9087.1 U9002.AM2(HDACPU_SDO)
AUD_AZACPU_SDO_R: R9087.2 U9001.G25(PROC_AUDIO_SDI)
AUDIOAMPS_CLK: Q3602.3(D) R3681.1 R6130.2 U6001.L6(GPIOE4/I2C6_SCL1)
AUDIOAMPS_DAT: Q3602.6(D) R3680.1 R6131.2 U6001.L7(GPIOE3/I2C6_SDA1)
B/I: PCN12000.3 PR12013.1 PR12014.2
B_DE: R632.1 R633.2 U603.8(B_DE)
B_EQ1: R626.2 R628.1 U603.20(B_EQ1)
B_EQ2: R627.2 R629.1 U603.17(B_EQ2)
BARREL_ADP_DET: PQ10010.3(COLLECTOR) PR10017.1 PR10021.1 U6001.H5(GPIO74)
BARREL_ADP_EN: PQ26006.1(S) PR10023.2 U6001.F4(GPIOE0)
BAT_WHITELED#: R6094.1 U6001.M11(GPIO94/PVT_DIO2) VC6002.1
BATLOW#: Q6001.3(D) R8023.2 R9092.1 U6001.E11(GPIO93/TA1_TACH1/SHD_DIO2) U9002.BF44(GPD0/BATLOW#)
BATT+: PC12003.1 PCN12000.7 PCN12000.8 PL12000.1 PL12001.1 PL12002.1
BIOS_WP#: R6221.1 U6203.3(WP#)
BIT_CLK_AUDIO: R3608.2 R9080.1
BIT_CLK_AUDIO_R: C3610.1 R3608.1 U3600.58(HDA_BCLK)
BKL_PWM_GFX: R2152.1 R2233.2 U2011.4(OUT Y) U3010.3(B0)
BKL_PWM_GFX_R: R2112.2 R2233.1 U2000.N8(GPIO7) U2011.1(INB) U2011.2(INA)
BKL_PWM_PCH: R3051.2 R9330.1 U3010.1(B1) U9002.AU48(GPP_F21/EDP_BKLTCTL)
BLON_CON: CON3000.22 Q3009.6(D) R3007.1 R3025.2
BODY_SAR: CON4201.25(BODYSAR_DET) R4205.1
BOOT_SPI#: R9322.1 R17958.1 U9002.BA26(GPP_B22/GSPI1_MOSI)
BQACDET: PC11013.1 PD11005.1(CATHODE) PR11008.2 PR11013.1 PR11027.2 PU11000.6(ACDET)
BQACDRV: PU11000.4(ACDRV) TP11000.1
BQACN: PR11005.2 PR11006.1 PU11000.1(ACN)
BQACP: PR11004.2 PU11000.2(ACP)
BQBATDRV: PU11000.18(BATDRV) TP11002.1
BQBATPRES: PR11021.2 PR11023.2 PU11000.15(B\A\T\P\R\E\S\)
BQBATSRC: PR11022.1 PU11000.17(BATSRC)
BQBTST: PR11010.2 PU11000.25(BTST)
BQCMPIN: PC11027.2 PR11035.2 PR11036.1 PR11038.1 PU11000.13(CMPIN)
BQCMPOUT: PR11034.1 PR11036.2 PR11037.1 PU11000.14(CMPOUT)
BQCMSRC: PR11009.1 PU11000.3(CMSRC)
BQHIDRV: PQ11001.4(G) PU11000.26(HIDRV)
BQIADP: PC11023.1 PR11028.2 PU11000.7(IADP)
BQIDCHG: PC11025.1 PR11029.2 PU11000.8(IDCHG)
BQILIM: PQ11003.3(D) PR11031.1 PU11000.21(ILIM)
BQLODRV: PQ11002.4(G) PU11000.23(LODRV)
BQPHASE: PC11012.2 PL11000.1 PQ11001.1(S1) PQ11001.2(S2) PQ11001.3(S3) PQ11002.5(D) PR11014.2 PU11000.27(PHASE)
BQPMON: PR11032.1 PR11033.1 PU11000.9(PMON)
BQPROCHOT: PR11020.2 PU11000.10(P\R\O\C\H\O\T\)
BQSCL: PR11019.1 PU11000.12(SCL)
BQSDA: PR11018.1 PU11000.11(SDA)
BQSRN: PR11026.1 PU11000.19(SRN)
BQSRP: PR11024.1 PU11000.20(SRP)
BQTB_STAT: PU11000.16(T\B\_\S\T\A\T\) TP11001.1
BQVCC: PC11011.1 PR11007.2 PU11000.28(VCC)
BRD_ID1: R9071.1 R9072.2 U9002.AV47(GPP_F15/USB2_OC4#)
BRD_ID2: R9073.1 R9074.2 U9002.AR35(GPP_F16/USB2_OC5#)
BRD_ID3: R9075.1 R9076.2 U9002.AR37(GPP_F17/USB2_OC6#)
BRD_ID4: R9077.1 R9078.2 U9002.AV43(GPP_F18/USB2_OC7#)
BT_DEV_EN_L: R4115.2 U4100.63(W_DISABLE2#/W_DISABLE2#)
BT_OFF: Q4105.5(G) R9236.1 U9002.AW18(GPP_D7/I2S2_RXD)
BT_OFF#: Q4105.3(D) Q4105.6(D) R4115.1 R4118.1
C1A: R601.2 R602.1 U601.12(C1)
C2A: R613.2 R9531.1 U601.6(C2)
C3A: R603.2 R604.1 U600.12(C1)
C4A: R614.2 R615.1 U600.6(C2)
C_C10#: PR26005.2 PR26006.2 R6020.1 R17911.1 U6001.A11(GPIOE2/JTAG_TDI1)
C_IN_CLK#_R: C586.2 C594.2 U12006.48(IN_CKN)
C_IN_CLK#_R_R: CON3200.12(CK-) R3207.2 U12006.13(OUT_CKN)
C_IN_CLK_R: C585.2 C593.2 U12006.47(IN_CKP)
C_IN_CLK_R_R: CON3200.10(CK+) R3207.1 U12006.14(OUT_CKP)
C_PEG_TXN0: C9005.2 U9001.B10(PEG_TXN_15)
C_PEG_TXN1: C9007.2 U9001.B11(PEG_TXN_14)
C_PEG_TXN2: C9009.2 U9001.B12(PEG_TXN_13)
C_PEG_TXN3: C9011.2 U9001.B13(PEG_TXN_12)
C_PEG_TXN4: C9013.2 U9001.B14(PEG_TXN_11)
C_PEG_TXN5: C9015.2 U9001.B15(PEG_TXN_10)
C_PEG_TXN6: C9017.2 U9001.B16(PEG_TXN_9)
C_PEG_TXN7: C9019.2 U9001.B17(PEG_TXN_8)
C_PEG_TXN8: C9021.2 U9001.C18(PEG_TXN_7)
C_PEG_TXN9: C9023.2 U9001.A19(PEG_TXN_6)
C_PEG_TXN10: C9025.2 U9001.C20(PEG_TXN_5)
C_PEG_TXN11: C9027.2 U9001.A21(PEG_TXN_4)
C_PEG_TXN12: C9029.2 U9001.C22(PEG_TXN_3)
C_PEG_TXN13: C9031.2 U9001.A23(PEG_TXN_2)
C_PEG_TXN14: C9033.2 U9001.C24(PEG_TXN_1)
C_PEG_TXN15: C9035.2 U9001.A25(PEG_TXN_0)
C_PEG_TXP0: C9004.2 U9001.C10(PEG_TXP_15)
C_PEG_TXP1: C9006.2 U9001.A11(PEG_TXP_14)
C_PEG_TXP2: C9008.2 U9001.C12(PEG_TXP_13)
C_PEG_TXP3: C9010.2 U9001.A13(PEG_TXP_12)
C_PEG_TXP4: C9012.2 U9001.C14(PEG_TXP_11)
C_PEG_TXP5: C9014.2 U9001.A15(PEG_TXP_10)
C_PEG_TXP6: C9016.2 U9001.C16(PEG_TXP_9)
C_PEG_TXP7: C9018.2 U9001.A17(PEG_TXP_8)
C_PEG_TXP8: C9020.2 U9001.B18(PEG_TXP_7)
C_PEG_TXP9: C9022.2 U9001.B19(PEG_TXP_6)
C_PEG_TXP10: C9024.2 U9001.B20(PEG_TXP_5)
C_PEG_TXP11: C9026.2 U9001.B21(PEG_TXP_4)
C_PEG_TXP12: C9028.2 U9001.B22(PEG_TXP_3)
C_PEG_TXP13: C9030.2 U9001.B23(PEG_TXP_2)
C_PEG_TXP14: C9032.2 U9001.B24(PEG_TXP_1)
C_PEG_TXP15: C9034.2 U9001.B25(PEG_TXP_0)
C_TX0_HDMI+_R: C587.2 C595.2 U12006.44(IN_D0P)
C_TX0_HDMI+_R_R: CON3200.7(D0+) R3206.1 U12006.17(OUT_D0P)
C_TX0_HDMI-_R: C588.2 C596.2 U12006.45(IN_D0N)
C_TX0_HDMI-_R_R: CON3200.9(D0-) R3206.2 U12006.16(OUT_D0N)
C_TX1_HDMI+_R: C589.2 C597.2 U12006.41(IN_D1P)
C_TX1_HDMI+_R_R: CON3200.4(D1+) R3205.1 U12006.20(OUT_D1P)
C_TX1_HDMI-_R: C590.2 C598.2 U12006.42(IN_D1N)
C_TX1_HDMI-_R_R: CON3200.6(D1-) R3205.2 U12006.19(OUT_D1N)
C_TX2_HDMI+_R: C591.2 C599.2 U12006.38(IN_D2P)
C_TX2_HDMI+_R_R: CON3200.1(D2+) R3204.1 U12006.23(OUT_D2P)
C_TX2_HDMI-_R: C592.2 C600.2 U12006.39(IN_D2N)
C_TX2_HDMI-_R_R: CON3200.3(D2-) R3204.2 U12006.22(OUT_D2N)
CALL_ANSWER_LED: Q6801.2(G) R6810.1 U6001.J10(GPIOB3/I2C7_SCL0/D\C\D\)
CALL_ANSWER_LED_CNTR: Q6801.3(D) R6804.2 R6812.1
CALL_DECLINE_END_LED: Q6802.2(G) R6823.1 U6001.K10(GPIOB2/I2C7_SDA0/D\S\R\)
CALL_DECLINE_END_LED_CNTR: Q6802.3(D) R6805.2 R6809.1
CAMERA_ON: CON3000.29 R9225.1 U9002.AW26(GPP_B19/GSPI1_CS0#)
CAPS_LED#: Q9039.5(G) R6184.1 R6185.2 R18103.1 U6003.4(Y2)
CAPS_LED#_R: Q9039.6(D) R6821.1 R17967.1 R18103.2
CARD_CLK_REQ4#: R9187.1 U7301.2(CLK_REQ#) U9002.BA30(GPP_B9/SRCCLKREQ4#)
CATERR#: Q9001.5(G) R9000.1 TP9004.1 U9001.BM30(CATERR#)
CCG5_AR_RST#_DP: JCN9000.25(SWD_IO) R8680.1 U8500.B2(SWD_IO/TBT_RST#/GPIO_P1.6)
CCG5_I2C_INT_EC_DP: D6001.1(CATHODE) R8508.2 TP8526.1 U8500.L5(I2C_INT_EC/GPIO_P2.5)
CCG5_RST#: R106.2 R6238.2 U6001.H3(GPOD6/J\E\N\1\)
CCG5_SWD_CLK_DP: JCN9000.26(SWD_CLK) R8570.1 R8571.2 U8500.C2(SWD_CLK/I2C_CFG_EC/GPIO_P1.0)
CCG5_VBUS_C_CTRL_P1: PQ10004.2(G) PR26013.1 PR26014.2 R7199.2 U8500.K4(VBUS_C_CTRL_P1)
CCG5_VBUS_C_CTRL_P2: PQ10005.2(G) PR26015.1 PR26016.2 R8551.2 U8500.B5(VBUS_C_CTRL_P2)
CCG5_VBUS_CSN_P1_R: R18021.1 U8500.B3(CSN_P1)
CCG5_VBUS_CSN_P2_R: R18020.1 U8500.K8(CSN_P2)
CCG5_VBUS_P_CTRL_P1: Q7120.2(G) R7140.2 U8500.K3(VBUS_P_CTRL_P1)
CCG5_VBUS_P_CTRL_P2: Q7146.2(G) R7153.2 U8500.B4(VBUS_P_CTRL_P2)
CCG5_XRES_DP: JCN9000.27(SWD_XRES) R106.1 R8502.1
CCG5_XRES_DP_Q: C8513.1 R8502.2 R8588.2 U8500.H6(XRES)
CFG0: CON400.9(OBSDATA_A0) R400.1 U9001.BN25(CFG_0)
CFG1: CON400.11(OBSDATA_A1) U9001.BN27(CFG_1)
CFG2: CON400.15(OBSDATA_A2) R9011.1 U9001.BN26(CFG_2)
CFG3: CON400.17(OBSDATA_A3) R405.2 U9001.BN28(CFG_3)
CFG4: CON400.27(OBSDATA_B0) R9013.1 U9001.BR20(CFG_4)
CFG5: CON400.29(OBSDATA_B1) R9014.1 U9001.BM20(CFG_5)
CFG6: CON400.33(OBSDATA_B2) R9015.1 U9001.BT20(CFG_6)
CFG7: CON400.35(OBSDATA_B3) U9001.BP20(CFG_7)
CFG8: CON400.10(OBSDATA_C0) U9001.BR23(CFG_8)
CFG9: CON400.12(OBSDATA_C1) U9001.BR22(CFG_9)
CFG10: CON400.16(OBSDATA_C2) U9001.BT23(CFG_10)
CFG11: CON400.18(OBSDATA_C3) U9001.BT22(CFG_11)
CFG12: CON400.28(OBSDATA_D0) U9001.BM19(CFG_12)
CFG13: CON400.30(OBSDATA_D1) U9001.BR19(CFG_13)
CFG14: CON400.34(OBSDATA_D2) U9001.BP19(CFG_14)
CFG15: CON400.36(OBSDATA_D3) U9001.BT19(CFG_15)
CFG16: CON400.6(OBSFN_C1) U9001.BP23(CFG_16)
CFG17: CON400.4(OBSFN_C0) U9001.BN23(CFG_17)
CFG18: CON400.24(OBSFN_D1) U9001.BN22(CFG_18)
CFG19: CON400.22(OBSFN_D0) U9001.BP22(CFG_19)
CFG_RCOMP: R9310.1 U9001.BT25(CFG_RCOMP)
CFLH4_CFLH6: R6001.2 R6003.2 U6001.K11(GPIOA5/A20M/P\V\T\_\C\S\1\)
CHA_DIMM0_SA0: JDIM1001.256(SA0) R1021.2 R1024.1
CHA_DIMM0_SA1: JDIM1001.260(SA1) R1020.2 R1023.1
CHA_DIMM0_SA2: JDIM1001.166(SA2) R1019.2 R1022.1
CHA_DIMM1_SA0: JDIM1000.256(SA0) R1006.2 R1010.1
CHA_DIMM1_SA1: JDIM1000.260(SA1) R1005.2 R1009.1
CHA_DIMM1_SA2: JDIM1000.166(SA2) R1004.2 R1008.1
CHB_DIMM0_SA0: JDIM1002.256(SA0) R1029.2 R1036.1
CHB_DIMM0_SA1: JDIM1002.260(SA1) R1028.2 R1035.1
CHB_DIMM0_SA2: JDIM1002.166(SA2) R1027.2 R1034.1
CHB_DIMM1_SA0: JDIM1003.256(SA0) R1047.2 R1050.1
CHB_DIMM1_SA1: JDIM1003.260(SA1) R1046.2 R1049.1
CHB_DIMM1_SA2: JDIM1003.166(SA2) R1045.2 R1048.1
CK_XDP_N: CON400.42(ITPCLK#/HOOK5) U9002.Y3(C\L\K\O\U\T\_\I\T\P\X\D\P\)
CK_XDP_P: CON400.40(ITPCLK/HOOK4) U9002.Y4(CLKOUT_ITPXDP_P)
CL_CLK: U4100.42(CLINK_CLK/NC) U9002.AR2(CL_CLK)
CL_DATA: U4100.43(CLINK_DATA/NC) U9002.AT5(CL_DATA)
CL_RST: U4100.44(CLINK_RESET/NC) U9002.AU4(CL_RST#)
CLICKPAD_INT#: CON6351.5 R9208.2 U9002.AK47(GPP_E2/SATAXPCIE2/SATAGP2)
CLK_CPU_BCLKN: U9001.A32(BCLKN) U9002.C8(C\L\K\O\U\T\_\C\P\U\B\C\L\K\)
CLK_CPU_BCLKP: U9001.B31(BCLKP) U9002.B8(CLKOUT_CPUBCLK_P)
CLK_DEBUG_KBC: TP9009.1 U9002.BB34(GPP_A10/CLKOUT_LPC1)
CLK_DPLL_NSCCLKN: U9001.D31(CLK24N) U9002.C6(C\L\K\O\U\T\_\C\P\U\N\S\S\C\)
CLK_DPLL_NSCCLKP: U9001.E31(CLK24P) U9002.D7(CLKOUT_CPUNSSC_P)
CLK_PCIE_GFXN: U2000.AK13(PEX_REFCLK*) U9002.AH9(CLKOUT_PCIE_N1)
CLK_PCIE_GFXP: U2000.AL13(PEX_REFCLK) U9002.AH10(CLKOUT_PCIE_P1)
CLK_PCIE_LANN: U4000.45(PE_CLKN) U9002.AE14(CLKOUT_PCIE_N2)
CLK_PCIE_LANP: U4000.44(PE_CLKP) U9002.AE15(CLKOUT_PCIE_P2)
CLK_PCIE_SDN: U7301.6(REFCLKN) U9002.AC2(CLKOUT_PCIE_N4)
CLK_PCIE_SDP: U7301.5(REFCLKP) U9002.AC3(CLKOUT_PCIE_P4)
CLK_PCIE_SSD1N: CON5100.53(REFCLKN) U9002.AJ6(CLKOUT_PCIE_N0)
CLK_PCIE_SSD1P: CON5100.55(REFCLKP) U9002.AJ7(CLKOUT_PCIE_P0)
CLK_PCIE_SSD2N: CON5101.53(REFCLKN) U9002.W4(CLKOUT_PCIE_N6)
CLK_PCIE_SSD2P: CON5101.55(REFCLKP) U9002.W3(CLKOUT_PCIE_P6)
CLK_PCIE_TBTN: U8001.T19(REFCLK_100_IN_N) U9002.AB2(CLKOUT_PCIE_N5)
CLK_PCIE_TBTP: U8001.V19(REFCLK_100_IN_P) U9002.AB3(CLKOUT_PCIE_P5)
CLK_PCIE_WLANN: TP4104.1 U4100.33(REFCLKN0/NC) U9002.AE6(CLKOUT_PCIE_N3)
CLK_PCIE_WLANP: TP4105.1 U4100.34(REFCLKP0/NC) U9002.AE7(CLKOUT_PCIE_P3)
CLK_PCIE_WWANN: CON4201.53(NC_53) U9002.AC14(CLKOUT_PCIE_N8)
CLK_PCIE_WWANP: CON4201.55(NC_55) U9002.AC15(CLKOUT_PCIE_P8)
CLKIN_XTAL_LCP: C12042.2 R4121.2 R17963.1 U9002.R6(CLKIN_XTAL)
CLKIN_XTAL_LCP_R: R17963.2 U4100.A44(REFCLK0/REFCLK0)
CLKOUT_SRC_N15: R9345.2 U9002.V2(CLKOUT_PCIE_N15)
CLKOUT_SRC_P15: R9346.2 R9348.1 U9002.V3(CLKOUT_PCIE_P15)
CNV_BRI_DT: R9372.2 R9377.1 R9545.2 U4100.54(LPSS_UART_RTS/BRI_DT/NC) U4100.A38(BRI_DT/BRI_DT)
CNV_BRI_RSP: R4129.2 R17948.2 U9002.AY2(GPP_J5/CNV_BRI_RSP/UART0_RXD)
CNV_BRI_RSP_R: R4129.1 U4100.55(LPSS_UART_RXD/BRI_RSP/NC) U4100.A39(BRI_RSP/BRI_RSP)
CNV_RCOMP: R9299.1 U9002.BA1(CNV_WT_RCOMP)
CNV_RF_RESET#: R4131.1 R9606.1 U9002.BE16(GPP_D5/I2S2_SFRM/CNV_RF_RESET#)
CNV_RF_RESET#_R: R4133.1 U4103.4(Y)
CNV_RGI_DT: R9378.1 U4100.56(LPSS_UART_TXD/RGI_DT/NC) U4100.A40(RGI_DT/RGI_DT)
CNV_RGI_RSP: R4130.2 R17947.2 U9002.AV3(GPP_J7/CNV_RGI_RSP/UART0_CTS#)
CNV_RGI_RSP_R: R4130.1 U4100.57(LPSS_UART_CTS/RGI_RSP/NC) U4100.A41(RGI_RSP/RGI_RSP)
CNV_WR_CLKN: U4100.A33(WGR_CLKN/WGR_CLKN) U9002.BD4(CNV_WR_CLKN)
CNV_WR_CLKP: U4100.A32(WGR_CLKP/WGR_CLKP) U9002.BE3(CNV_WR_CLKP)
CNV_WRXN0: U4100.A35(WGR_D0N/WGR_D0N) U9002.BB3(CNV_WR_D0N)
CNV_WRXN1: U4100.A37(WGR_D1N/WGR_D1N) U9002.BA3(CNV_WR_D1N)
CNV_WRXP0: U4100.A34(WGR_D0P/WGR_D0P) U9002.BB4(CNV_WR_D0P)
CNV_WRXP1: U4100.A36(WGR_D1P/WGR_D1P) U9002.BA2(CNV_WR_D1P)
CNV_WT_CLKN: U4100.A20(WT_CLKN/WT_CLKN) U9002.BC5(CNV_WT_CLKN)
CNV_WT_CLKP: U4100.A19(WT_CLKP/WT_CLKP) U9002.BB6(CNV_WT_CLKP)
CNV_WTXN0: U4100.A22(WT_D0N/WT_D0N) U9002.BE6(CNV_WT_D0N)
CNV_WTXN1: U4100.A24(WT_D1N/WT_D1N) U9002.BG6(CNV_WT_D1N)
CNV_WTXP0: U4100.A21(WT_D0P/WT_D0P) U9002.BD7(CNV_WT_D0P)
CNV_WTXP1: U4100.A23(WT_D1P/WT_D1P) U9002.BF6(CNV_WT_D1P)
CNVI_EN#: R4135.2 R18043.1 U9002.BE29(GPP_B0/GSPI0_CS1#)
CNVI_EN#_R: Q4106.2(G) R4135.1 R4137.1 R4138.1 U12005.1(INB)
COLOR_DET#: CON10002.2 R9379.1 R9381.1 U9002.AD48(GPP_H14/SML3DATA)
CORE_PLLVDD: C2046.1 C2051.1 C2052.2 C2053.1 C2133.2 C2151.2 C2153.1 C2221.1 L2010.2 U2000.AB8(IFPEF_PLLVDD) U2000.AD7(VID_PLLVDD) U2000.AD8(XS_PLLVDD) U2000.AE8(SP_PLLVDD) U2000.AF7(IFPCD_PLLVDD) U2000.H26(GPCPLL_AVDD)
CP_VNEG: C3615.1 U3600.31(CP_VNEG)
CP_VPOS: C3614.1 U3600.32(CP_VPOS)
CPPWR_EN: U6001.L11(GPIOB0/PVT_DIO3) U7005.8(CTL3)
CPU_2_PCH_TRIG: U9001.J23(PROC_TRIGOUT) U9002.AK2(TRIGGER_IN)
CPU_EDP_HPD: R3041.1 R3055.2 U9002.AN6(GPP_I4/EDP_HPD/DISP_MISC4)
CPU_PCI_BCLKN: U9001.C36(PCI_BCLKN) U9002.B6(C\L\K\O\U\T\_\C\P\U\P\C\I\B\C\L)
CPU_PCI_BCLKP: U9001.D35(PCI_BCLKP) U9002.A6(CLKOUT_CPUPCIBCLK_P)
CPU_PLTRST#: R9165.1 U9002.AG5(PLTRST_CPU#)
CPU_PLTRST#R: R9165.2 U9001.BP35(RESET#)
CPU_PROCHOT#: C9003.1 PR12009.2 PR12010.2 PR19004.2 PR19019.1 Q6301.1(EMITTER) R9033.1 R9320.2 R9321.1
CPU_PROCHOT#_R: R9321.2 U9001.BR30(PROCHOT#)
CPU_VCCIO_PWR_GATE#: Q9035.1(EMITTER) R17906.1 U9002.AY3(GPP_J1/CPU_VCCIO_PWR_GATE#)
CR_RST#: TP9028.1 U9002.BD29(GPP_B17/GSPI0_MISO)
CR_WAKE#: TP9040.1 U9002.BF29(GPP_B16/GSPI0_CLK)
CTRL_1P0: L4000.1 U4000.7(CTRL_1P0)
DCPRTC: C9221.2 U9002.BF47(DCPRTC1) U9002.BG47(DCPRTC2)
DDI1_AUX_SRCN: C522.2 U500.59(IN2_AUXN)
DDI1_AUX_SRCP: C521.2 U500.60(IN2_AUXP)
DDI1_AUXN: C522.1 U9001.E27(DDI1_AUXN)
DDI1_AUXP: C521.1 U9001.D27(DDI1_AUXP)
DDI1_TXN0: C514.1 U9001.K37(DDI1_TXN_0)
DDI1_TXN0_C: C514.2 U500.15(IN2_D0N)
DDI1_TXN1: C516.1 U9001.J34(DDI1_TXN_1)
DDI1_TXN1_C: C516.2 U500.18(IN2_D1N)
DDI1_TXN2: C520.1 U9001.H36(DDI1_TXN_2)
DDI1_TXN2_C: C520.2 U500.21(IN2_D2N)
DDI1_TXN3: C519.1 U9001.J38(DDI1_TXN_3)
DDI1_TXN3_C: C519.2 U500.23(IN2_D3N)
DDI1_TXP0: C500.1 U9001.K36(DDI1_TXP_0)
DDI1_TXP0_C: C500.2 U500.14(IN2_D0P)
DDI1_TXP1: C515.1 U9001.J35(DDI1_TXP_1)
DDI1_TXP1_C: C515.2 U500.17(IN2_D1P)
DDI1_TXP2: C517.1 U9001.H37(DDI1_TXP_2)
DDI1_TXP2_C: C517.2 U500.20(IN2_D2P)
DDI1_TXP3: C518.1 U9001.J37(DDI1_TXP_3)
DDI1_TXP3_C: C518.2 U500.22(IN2_D3P)
DDI2_AUX_SRCN: C554.2 U501.59(IN2_AUXN)
DDI2_AUX_SRCP: C553.2 U501.60(IN2_AUXP)
DDI2_AUXN: C554.1 U9001.E26(DDI2_AUXN)
DDI2_AUXP: C553.1 U9001.F26(DDI2_AUXP)
DDI2_TXN0: C555.1 U9001.H33(DDI2_TXN_0)
DDI2_TXN0_C: C555.2 U501.15(IN2_D0N)
DDI2_TXN1: C548.1 U9001.G38(DDI2_TXN_1)
DDI2_TXN1_C: C548.2 U501.18(IN2_D1N)
DDI2_TXN2: C550.1 U9001.F35(DDI2_TXN_2)
DDI2_TXN2_C: C550.2 U501.21(IN2_D2N)
DDI2_TXN3: C552.1 U9001.E36(DDI2_TXN_3)
DDI2_TXN3_C: C552.2 U501.23(IN2_D3N)
DDI2_TXP0: C546.1 U9001.H34(DDI2_TXP_0)
DDI2_TXP0_C: C546.2 U501.14(IN2_D0P)
DDI2_TXP1: C547.1 U9001.F37(DDI2_TXP_1)
DDI2_TXP1_C: C547.2 U501.17(IN2_D1P)
DDI2_TXP2: C549.1 U9001.F34(DDI2_TXP_2)
DDI2_TXP2_C: C549.2 U501.20(IN2_D2P)
DDI2_TXP3: C551.1 U9001.E37(DDI2_TXP_3)
DDI2_TXP3_C: C551.2 U501.22(IN2_D3P)
DDI3_TXN0: C600.1 U9001.D34(DDI3_TXN_0)
DDI3_TXN1: C598.1 U9001.B34(DDI3_TXN_1)
DDI3_TXN2: C596.1 U9001.E33(DDI3_TXN_2)
DDI3_TXN3: C594.1 U9001.B33(DDI3_TXN_3)
DDI3_TXP0: C599.1 U9001.C34(DDI3_TXP_0)
DDI3_TXP1: C597.1 U9001.B36(DDI3_TXP_1)
DDI3_TXP2: C595.1 U9001.F33(DDI3_TXP_2)
DDI3_TXP3: C593.1 U9001.C33(DDI3_TXP_3)
DDPB_CTRL_CLK: R9246.1 U9002.AL13(GPP_I5/DDPB_CTRLCLK)
DDPB_CTRL_DATA: R9247.1 U9002.AR8(GPP_I6/DDPB_CTRLDATA)
DDPC_CTRL_CLK: R9244.1 U9002.AN13(GPP_I7/DDPC_CTRLCLK)
DDPC_CTRL_DATA: R9245.1 U9002.AL10(GPP_I8/DDPC_CTRLDATA)
DDR0_ALERT#: JDIM1000.116(ALERT#) JDIM1001.116(ALERT#) U9001.AU5(NC/DDR0_ALERT#)
DDR0_PAR: JDIM1000.143(PARITY) JDIM1001.143(PARITY) U9001.AG3(NC/DDR0_PAR)
DDR1_ALERT#: JDIM1002.116(ALERT#) JDIM1003.116(ALERT#) U9001.AR8(NC/DDR1_ALERT#)
DDR1_PAR: JDIM1002.143(PARITY) JDIM1003.143(PARITY) U9001.AJ7(NC/DDR1_PAR)
DDR_DRAMRST#: C1001.2 C1031.2 C1059.2 C1093.2 C9187.1 JDIM1000.108(RESET#) JDIM1001.108(RESET#) JDIM1002.108(RESET#) JDIM1003.108(RESET#) R9085.1 R9089.2
DDR_DRAMRST#_L: R9089.1 U9002.BB46(DRAM_RESET#)
DDR_PG_CNTL: R9316.2 U9001.BT13(DDR_VTT_CNTL)
DDR_VTT_PG_CTRL: PQ14001.2(G) Q9003.3(D) R9282.1 R9312.2 R9315.1
DDR_VTTREF: PC14014.1 PR14005.1
DDRA_ACT#: JDIM1000.114(ACT#) JDIM1001.114(ACT#) U9001.AU3(DDR0_CAA_8/DDR0_ACT#)
DDRB_ACT#: JDIM1002.114(ACT#) JDIM1003.114(ACT#) U9001.AT9(DDR1_CAA_8/DDR1_ACT#)
DDSP_1_HPD0: R9249.2 U500.19(IN2_HPD) U9002.AT6(GPP_I0/DDPB_HPD0/DISP_MISC0)
DDSP_1_HPD1: R9250.2 U501.19(IN2_HPD) U9002.AN10(GPP_I1/DDPC_HPD1/DISP_MISC1)
DEBUG_DP0_AUXN: C10009.2 R10052.1 TP22057.1
DEBUG_DP0_AUXN_R: C10009.1 R10008.2 R10051.2
DEBUG_DP0_AUXP: C10008.2 R10050.1 TP22058.1
DEBUG_DP0_AUXP_R: C10008.1 R10008.1 R10049.2
DEBUG_DP0_HPD: R2140.2 R10000.1 R10001.1 TP22065.1
DEBUG_DP0_TXN0: C10001.2 TP22042.1
DEBUG_DP0_TXN0_R: C10001.1 R10004.2
DEBUG_DP0_TXN1: C10003.2 TP22044.1
DEBUG_DP0_TXN1_R: C10003.1 R10005.2
DEBUG_DP0_TXN2: C10005.2 TP22046.1
DEBUG_DP0_TXN2_R: C10005.1 R10006.2
DEBUG_DP0_TXN3: C10007.2 TP22055.1
DEBUG_DP0_TXN3_R: C10007.1 R10007.2
DEBUG_DP0_TXP0: C10000.2 TP22041.1
DEBUG_DP0_TXP0_R: C10000.1 R10004.1
DEBUG_DP0_TXP1: C10002.2 TP22043.1
DEBUG_DP0_TXP1_R: C10002.1 R10005.1
DEBUG_DP0_TXP2: C10004.2 TP22045.1
DEBUG_DP0_TXP2_R: C10004.1 R10006.1
DEBUG_DP0_TXP3: C10006.2 TP22056.1
DEBUG_DP0_TXP3_R: C10006.1 R10007.1
DEBUG_DP1_AUXN: C10022.2 R10055.1 TP22063.1
DEBUG_DP1_AUXN_R: C10022.1 R10017.2 R10056.2
DEBUG_DP1_AUXP: C10021.2 R10053.1 TP22064.1
DEBUG_DP1_AUXP_R: C10021.1 R10017.1 R10054.2
DEBUG_DP1_HPD: R2141.2 R10011.1 R10012.1 TP22067.1
DEBUG_DP1_TXN1: C10017.2 TP22048.1
DEBUG_DP1_TXN1_R: C10017.1 R10013.2
DEBUG_DP1_TXN2: C10020.2 TP22050.1
DEBUG_DP1_TXN2_R: C10020.1 R10014.2
DEBUG_DP1_TXN3: C10023.2 TP22052.1
DEBUG_DP1_TXN3_R: C10023.1 R10015.2
DEBUG_DP1_TXN4: C10015.2 TP22061.1
DEBUG_DP1_TXN4_R: C10015.1 R10016.2
DEBUG_DP1_TXP1: C10014.2 TP22047.1
DEBUG_DP1_TXP1_R: C10014.1 R10013.1
DEBUG_DP1_TXP2: C10019.2 TP22049.1
DEBUG_DP1_TXP2_R: C10019.1 R10014.1
DEBUG_DP1_TXP3: C10018.2 TP22051.1
DEBUG_DP1_TXP3_R: C10018.1 R10015.1
DEBUG_DP1_TXP4: C10016.2 TP22062.1
DEBUG_DP1_TXP4_R: C10016.1 R10016.1
DEVSLP1_SSD1: CON5100.38(DEVSLP) R9327.1 U9002.AH35(GPP_E5/SATA_DEVSLP1)
DEVSLP3_HDD: CON5000.12(GND#2) R9360.1 U9002.AP48(GPP_F5/SATA_DEVSLP3)
DEVSLP4_SSD2: CON5101.38(DEVSLP) R9361.1 U9002.AR47(GPP_F6/SATA_DEVSLP4)
DGPU_HOLD_RST#: R2228.1 R9055.2 U2001.1(INB) U9002.AH36(GPP_E9/USB2_OC0#)
DGPU_INTR#: Q2022.3(D) Q2023.3(D) Q2023.6(D) R9326.2 U9002.BD21(GPP_C15/UART1_CTS#/ISH_UART1_CT)
DGPU_OVT#: Q2015.3(D) R2133.1
DGPU_PRSNT#: Q3003.2(G) R2226.1 R9053.2 U9002.AL40(GPP_E10/USB2_OC1#)
DGPU_PWR_EN: R2127.2 R9052.2 U2004.2(I0) U9002.AJ44(GPP_E11/USB2_OC2#)
DGPU_PWROK: Q2011.3(D) R9054.1 U9002.AL41(GPP_E12/USB2_OC3#)
DGPU_PWROK_Q: Q2000.3(D) Q2011.1(S) Q2012.2(G) R2089.2
DGPU_SELECT#: Q3001.1(S) R3043.1 R9300.1
DGPU_SELECT#_R: R9300.2 U9002.AM48(GPP_F4/SATAXPCIE7/SATAGP7)
DIGITAL_CLK1: L3005.1 R3618.1
DIGITAL_CLK2: L3003.1 R3629.1
DIGITAL_D1: C3027.2 EC3600.2 R3013.2 U3600.12(PORTC_DATA/GPIO3)
DIGITAL_D2: C3022.2 EC3604.2 R3011.2 U3600.9(PORTH_DATA/SPKR_MUTE#/SPDIF/GPI)
DIMM0_CHA_EVENT_N: JDIM1001.134(EVENT#) R1017.2 R1018.2
DIMM0_CHB_EVENT_N: JDIM1002.134(EVENT#) R1025.2 R1026.2
DIMM1_CHA_EVENT_N: JDIM1000.134(EVENT#) R1000.1 R1001.2
DIMM1_CHB_EVENT_N: JDIM1003.134(EVENT#) R1043.2 R1044.2
DMI_RXN0: U9001.E8(DMI_RXN_0) U9002.C33(DMI0_TXN)
DMI_RXN1: U9001.F6(DMI_RXN_1) U9002.C32(DMI1_TXN)
DMI_RXN2: U9001.E5(DMI_RXN_2) U9002.C31(DMI2_TXN)
DMI_RXN3: U9001.J9(DMI_RXN_3) U9002.C29(DMI3_TXN)
DMI_RXP0: U9001.D8(DMI_RXP_0) U9002.B33(DMI0_TXP)
DMI_RXP1: U9001.E6(DMI_RXP_1) U9002.B32(DMI1_TXP)
DMI_RXP2: U9001.D5(DMI_RXP_2) U9002.B31(DMI2_TXP)
DMI_RXP3: U9001.J8(DMI_RXP_3) U9002.B29(DMI3_TXP)
DMI_TXN0: U9001.A8(DMI_TXN_0) U9002.K34(DMI0_RXN)
DMI_TXN1: U9001.B6(DMI_TXN_1) U9002.G33(DMI1_RXN)
DMI_TXN2: U9001.A5(DMI_TXN_2) U9002.K32(DMI2_RXN)
DMI_TXN3: U9001.B4(DMI_TXN_3) U9002.G30(DMI3_RXN)
DMI_TXP0: U9001.B8(DMI_TXP_0) U9002.J35(DMI0_RXP)
DMI_TXP1: U9001.C6(DMI_TXP_1) U9002.F34(DMI1_RXP)
DMI_TXP2: U9001.B5(DMI_TXP_2) U9002.J32(DMI2_RXP)
DMI_TXP3: U9001.D4(DMI_TXP_3) U9002.F30(DMI3_RXP)
DMIC_3_CLK1_R: C3028.1 CON3000.37 L3005.2 R9615.1 R18046.2
DMIC_3_CLK2_R: C3025.1 CON3000.33 L3003.2 R9617.1 R18045.2 U3607.6(S)
DMIC_3_D1_R: CON3000.36 R3013.1 R9614.1 U3607.3(B0)
DMIC_3_D2_L: R3011.1 R3682.1 U3607.4(A)
DMIC_3_D2_R: CON3000.34 R3682.2 R9616.1 U3607.1(B1)
DMIC_CLK1_R: EC3603.2 R3618.2 U3600.14(PORTC_CLK/GPIO2)
DMIC_CLK2_R: EC3605.2 R3629.2 U3600.8(PORTH_CLK/MUSIC_REQ/SPDIF/GPIO0)
DMUX_EDP_PD_SEL: Q3004.3(D) R3058.1
DP0_CFG1: R10002.2 TP22053.1
DP0_CFG2: R10003.2 TP22054.1
DP1_CFG1: R10010.2 TP22060.1
DP1_CFG2: R10009.2 TP22059.1
DPSNK0_AUX_N: C8027.2 U8001.N2(DPSNK1_AUX_N)
DPSNK0_AUX_P: C8025.2 U8001.N1(DPSNK1_AUX_P)
DPSNK0_ML0_N: C8014.2 U8001.AB7(DPSNK1_ML0_N)
DPSNK0_ML0_P: C8008.2 U8001.AC7(DPSNK1_ML0_P)
DPSNK0_ML1_N: C8010.2 U8001.AC9(DPSNK1_ML1_N)
DPSNK0_ML1_P: C8016.2 U8001.AB9(DPSNK1_ML1_P)
DPSNK0_ML2_N: C8019.2 U8001.AB11(DPSNK1_ML2_N)
DPSNK0_ML2_P: C8018.2 U8001.AC11(DPSNK1_ML2_P)
DPSNK0_ML3_N: C8023.2 U8001.AC13(DPSNK1_ML3_N)
DPSNK0_ML3_P: C8021.2 U8001.AB13(DPSNK1_ML3_P)
DPSNK1_AUX_N: C8042.2 U8001.P2(DPSNK2_AUX_N)
DPSNK1_AUX_P: C8040.2 U8001.P1(DPSNK2_AUX_P)
DPSNK1_ML0_N: C8029.2 U8001.B5(DPSNK2_ML0_N)
DPSNK1_ML0_P: C8028.2 U8001.A5(DPSNK2_ML0_P)
DPSNK1_ML1_N: C8031.2 U8001.A3(DPSNK2_ML1_N)
DPSNK1_ML1_P: C8030.2 U8001.B3(DPSNK2_ML1_P)
DPSNK1_ML2_N: C8035.2 U8001.C1(DPSNK2_ML2_N)
DPSNK1_ML2_P: C8033.2 U8001.C2(DPSNK2_ML2_P)
DPSNK1_ML3_N: C8039.2 U8001.E1(DPSNK2_ML3_N)
DPSNK1_ML3_P: C8037.2 U8001.E2(DPSNK2_ML3_P)
DPSRC_HPD: R8013.1 U8001.R5(DPSRC_HPD)
DPWROK: PR25023.1 PU25001.4 R6061.2 R9107.2
DPWROK_EC: R6061.1 U6001.E7(GPIO00)
DPWROK_R: R9107.1 R9139.2 U9002.AW41(DSW_PWROK)
EARP_L1: C3639.2 CON3601.1 L3605.2 VC3601.1
EARP_R1: C3640.2 CON3601.2 L3606.2 VC3600.1
EC_HID_INTR: R9196.2 U9002.BE36(GPP_A11/PME#/SD_VDD2_PWR_EN#)
EC_RST#: R9009.2 R9026.1 R9376.1 U9002.BF38(GPP_A14/SUS_STAT#/ESPI_RESET#)
EDP_AUXN_OUT: C3015.2 R3060.1 U3007.31(OUT_AUXN_SDA)
EDP_AUXN_OUT_R: C3015.1 CON3000.19 R3039.1
EDP_AUXP_OUT: C3014.2 R3061.1 U3007.32(OUT_AUXP_SCL)
EDP_AUXP_OUT_R: C3014.1 CON3000.18 R3037.1
EDP_DISP_UTIL: TP9005.1 U9001.A33(EDP_DISP_UTIL)
EDP_HPD: CON3000.21 Q3005.2(G) R3001.2 R3056.1
EDP_RCOMP: R9038.2 U9001.D37(DISP_RCOMP)
EDP_TXN0_OUT: C3012.2 U3007.45(OUT_D0N)
EDP_TXN0_OUT_R: C3012.1 CON3000.15
EDP_TXN1_OUT: C3010.2 U3007.42(OUT_D1N)
EDP_TXN1_OUT_R: C3010.1 CON3000.12
EDP_TXN2_OUT: C3009.2 U3007.39(OUT_D2N)
EDP_TXN2_OUT_R: C3009.1 CON3000.9
EDP_TXN3_OUT: C3002.2 U3007.36(OUT_D3N)
EDP_TXN3_OUT_R: C3002.1 CON3000.6
EDP_TXP0_OUT: C3013.2 U3007.46(OUT_D0P)
EDP_TXP0_OUT_R: C3013.1 CON3000.16
EDP_TXP1_OUT: C3011.2 U3007.43(OUT_D1P)
EDP_TXP1_OUT_R: C3011.1 CON3000.13
EDP_TXP2_OUT: C3001.2 U3007.40(OUT_D2P)
EDP_TXP2_OUT_R: C3001.1 CON3000.10
EDP_TXP3_OUT: C3003.2 U3007.37(OUT_D3P)
EDP_TXP3_OUT_R: C3003.1 CON3000.7
EN: C634.1 R634.2 U603.7(EN)
EN_1V05A: C9250.2 PR18008.1 R9286.1 R9287.2 R9288.2
EN_1V8: PR16013.1 R9275.2
EN_2V5: PR15002.1 R9280.2 R9281.2
EN_3V: PR13014.2 R9274.2
EN_5V: PR13006.1 PR13022.1 R9273.2
EN_5V_3V: PR18011.1 R6174.2 R6177.1 R6403.2 R9273.1 R9274.1 R9275.1 R9277.2 U6402.3(O\T\)
EN_P1V5S: C9251.2 PR16015.1 R9285.2
EN_PVCCIO: PR17010.1 R9283.2
EN_USB5V: PR13025.1 U6001.D2(GPIOF0/ADC9)
EN_VRPVDDQ: D9001.2(ANODE2) PR14009.1 R9279.2
EN_VRPVTT: PR14007.1 R9282.2
ENABLT: R3036.2 R3050.1 U49.2(INA) U3009.4(A)
ENAVDD: R3010.2 R3024.2 R3049.1 U3000.3(EN) U3008.4(A)
ENVDD_GFX: R2151.1 R2234.2 U2009.4(OUT Y) U3008.3(B0)
ENVDD_GFX_R: R2113.2 R2234.1 U2000.M5(GPIO11) U2009.1(INB) U2009.2(INA)
ENVDD_PCH: R3049.2 R9328.1 U3008.1(B1) U9002.AV44(GPP_F19/EDP_VDDEN)
ESPI_CLK_EC: R6134.2 R9008.2 R9066.1
ESPI_CLK_EC_R: R9066.2 U9002.BB36(GPP_A9/CLKOUT_LPC0/ESPI_CLK)
ESPI_CS#: R6004.2 R9003.2 U9002.BE38(GPP_A5/LFRAME#/ESPI_CS0#)
ESPI_CS#_L: R6004.1 U6001.L2(L\F\R\A\M\E\/E\S\P\I\_\C\S\/GPI)
ESPI_CS#_L_R: JCN9000.6(LFRAM#) R9003.1
ESPI_EC_IO0: R9061.2 U9002.BB39(GPP_A1/LAD0/ESPI_IO0)
ESPI_EC_IO0_L: R6138.2 R9007.2 R9061.1
ESPI_EC_IO0_R: R6138.1 U6001.H1(LAD0/ESPI_IO0/GPIO46)
ESPI_EC_IO0_R_R: JCN9000.10(LPC_ESPI_(0)) R9007.1
ESPI_EC_IO1: R9062.2 U9002.AW37(GPP_A2/LAD1/ESPI_IO1)
ESPI_EC_IO1_L: R6137.2 R9006.2 R9062.1
ESPI_EC_IO1_R: R6137.1 U6001.J1(LAD1/ESPI_IO1/GPIO47)
ESPI_EC_IO1_R_R: JCN9000.9(LPC_ESPI_(1)) R9006.1
ESPI_EC_IO2: R9063.2 U9002.AV37(GPP_A3/LAD2/ESPI_IO2)
ESPI_EC_IO2_L: R6136.2 R9005.2 R9063.1
ESPI_EC_IO2_R: R6136.1 U6001.K1(LAD2/ESPI_IO2/GPIO51)
ESPI_EC_IO2_R_R: JCN9000.8(LPC_ESPI_(2)) R9005.1
ESPI_EC_IO3: R9064.2 U9002.BA38(GPP_A4/LAD3/ESPI_IO3)
ESPI_EC_IO3_L: R6135.2 R9004.2 R9064.1
ESPI_EC_IO3_R: R6135.1 U6001.L1(LAD3/ESPI_IO3/GPIO52)
ESPI_EC_IO3_R_R: JCN9000.7(LPC_ESPI_(3)) R9004.1
EXP_CLK_REQ7#: R9184.1 U9002.AC48(GPP_H1/SRCCLKREQ7#)
EXT_DPC_HPD: C2166.2 Q2023.2(G) R2059.2 R18089.2
EXT_DPC_SCL: Q2024.6(D) R18090.2
EXT_DPC_SDA: Q2024.3(D) R18088.2
EXT_DPC_TXN0: C592.1 U2000.AJ1(IFPC_L0*)
EXT_DPC_TXN1: C590.1 U2000.AJ2(IFPC_L1*)
EXT_DPC_TXN2: C588.1 U2000.AH4(IFPC_L2*)
EXT_DPC_TXN3: C586.1 U2000.AG4(IFPC_L3*)
EXT_DPC_TXP0: C591.1 U2000.AK1(IFPC_L0)
EXT_DPC_TXP1: C589.1 U2000.AJ3(IFPC_L1)
EXT_DPC_TXP2: C587.1 U2000.AH3(IFPC_L2)
EXT_DPC_TXP3: C585.1 U2000.AG5(IFPC_L3)
EXT_DPE_AUX_SRCN: C532.2 U500.61(IN1_AUXN)
EXT_DPE_AUX_SRCP: C531.2 U500.62(IN1_AUXP)
EXT_DPE_AUXN: C532.1 R10040.2 U2000.AB4(IFPE_AUX_SDA*)
EXT_DPE_AUXP: C531.1 R10041.2 U2000.AB3(IFPE_AUX_SCL)
EXT_DPE_HPD: C2218.2 Q2022.2(G) R2118.2 U500.16(IN1_HPD)
EXT_DPE_TXN0: C524.1 U2000.AD3(IFPE_L0*)
EXT_DPE_TXN0_C: C524.2 U500.5(IN1_D0N)
EXT_DPE_TXN1: C526.1 U2000.AC1(IFPE_L1*)
EXT_DPE_TXN1_C: C526.2 U500.8(IN1_D1N)
EXT_DPE_TXN2: C528.1 U2000.AC3(IFPE_L2*)
EXT_DPE_TXN2_C: C528.2 U500.11(IN1_D2N)
EXT_DPE_TXN3: C530.1 U2000.AC5(IFPE_L3*)
EXT_DPE_TXN3_C: C530.2 U500.13(IN1_D3N)
EXT_DPE_TXP0: C523.1 U2000.AD2(IFPE_L0)
EXT_DPE_TXP0_C: C523.2 U500.4(IN1_D0P)
EXT_DPE_TXP1: C525.1 U2000.AD1(IFPE_L1)
EXT_DPE_TXP1_C: C525.2 U500.7(IN1_D1P)
EXT_DPE_TXP2: C527.1 U2000.AC2(IFPE_L2)
EXT_DPE_TXP2_C: C527.2 U500.10(IN1_D2P)
EXT_DPE_TXP3: C529.1 U2000.AC4(IFPE_L3)
EXT_DPE_TXP3_C: C529.2 U500.12(IN1_D3P)
EXT_DPF_AUX_SRCN: C565.2 U501.61(IN1_AUXN)
EXT_DPF_AUX_SRCP: C564.2 U501.62(IN1_AUXP)
EXT_DPF_AUXN: C565.1 R10042.2 U2000.AF2(IFPF_AUX_SDA*)
EXT_DPF_AUXP: C564.1 R10043.2 U2000.AF3(IFPF_AUX_SCL)
EXT_DPF_HPD: C2220.2 Q2023.5(G) R2123.2 U501.16(IN1_HPD)
EXT_DPF_TXN0: C557.1 U2000.AE4(IFPF_L0*)
EXT_DPF_TXN0_C: C557.2 U501.5(IN1_D0N)
EXT_DPF_TXN1: C559.1 U2000.AF5(IFPF_L1*)
EXT_DPF_TXN1_C: C559.2 U501.8(IN1_D1N)
EXT_DPF_TXN2: C561.1 U2000.AD5(IFPF_L2*)
EXT_DPF_TXN2_C: C561.2 U501.11(IN1_D2N)
EXT_DPF_TXN3: C563.1 U2000.AF1(IFPF_L3*)
EXT_DPF_TXN3_C: C563.2 U501.13(IN1_D3N)
EXT_DPF_TXP0: C556.1 U2000.AE3(IFPF_L0)
EXT_DPF_TXP0_C: C556.2 U501.4(IN1_D0P)
EXT_DPF_TXP1: C558.1 U2000.AF4(IFPF_L1)
EXT_DPF_TXP1_C: C558.2 U501.7(IN1_D1P)
EXT_DPF_TXP2: C560.1 U2000.AD4(IFPF_L2)
EXT_DPF_TXP2_C: C560.2 U501.10(IN1_D2P)
EXT_DPF_TXP3: C562.1 U2000.AG1(IFPF_L3)
EXT_DPF_TXP3_C: C562.2 U501.12(IN1_D3P)
EXT_EDP_AUXN: C3057.2 R2103.1 U2000.AK2(IFPD_AUX_SDA*)
EXT_EDP_AUXN_C: C3057.1 R2102.1 U3007.27(IN1_AUXN)
EXT_EDP_AUXP: C3056.2 R2105.1 U2000.AK3(IFPD_AUX_SCL)
EXT_EDP_AUXP_C: C3056.1 R2104.1 U3007.28(IN1_AUXP)
EXT_EDP_HPD: C2216.2 R2111.2 R3054.2
EXT_EDP_TXN0: C3069.2 U2000.AM2(IFPD_L0*)
EXT_EDP_TXN0_C: C3069.1 U3007.2(IN1_D0N)
EXT_EDP_TXN1: C3071.2 U2000.AM4(IFPD_L1*)
EXT_EDP_TXN1_C: C3071.1 U3007.5(IN1_D1N)
EXT_EDP_TXN2: C3073.2 U2000.AL4(IFPD_L2*)
EXT_EDP_TXN2_C: C3073.1 U3007.7(IN1_D2N)
EXT_EDP_TXN3: C3075.2 U2000.AK5(IFPD_L3*)
EXT_EDP_TXN3_C: C3075.1 U3007.10(IN1_D3N)
EXT_EDP_TXP0: C3068.2 U2000.AM1(IFPD_L0)
EXT_EDP_TXP0_C: C3068.1 U3007.1(IN1_D0P)
EXT_EDP_TXP1: C3070.2 U2000.AM3(IFPD_L1)
EXT_EDP_TXP1_C: C3070.1 U3007.4(IN1_D1P)
EXT_EDP_TXP2: C3072.2 U2000.AL3(IFPD_L2)
EXT_EDP_TXP2_C: C3072.1 U3007.6(IN1_D2P)
EXT_EDP_TXP3: C3074.2 U2000.AK4(IFPD_L3)
EXT_EDP_TXP3_C: C3074.1 U3007.9(IN1_D3P)
EXT_HPD_PIN3: R3054.1 U3007.3(IN1_HPD)
EXT_MIC_L: C3611.1 C3641.1 CON3601.4 U3600.37(SGNDB) U3600.38(HGNDB) VC3602.1
EXT_SMI#: R9067.2 U9002.T48(GPP_K19/SMI#)
FAN1_PWM: U6001.G8(GPIOC4/PWM2_TACH2PWM_OUT) U6301.1(I1)
FAN1_PWM_Y: C6305.1 CON6300.4 U6301.4(O)
FAN2_PWM: U6001.G9(GPIOC3/PWM0) U6300.1(I1)
FAN2_PWM_Y: C6309.1 CON6301.4 U6300.4(O)
FB_CAL_PD_VDDQ: R2010.2 U2000.J27(FB_CAL_PD_VDDQ)
FB_CAL_PU_GND: R2011.2 U2000.H27(FB_CAL_PU_GND)
FB_CAL_TERM_GND: R2012.2 U2000.H25(FB_CAL_TERM_GND)
FB_GND_SENSE: TP2005.1 U2000.F2(PROBE_FB_GND)
FBA_CMD0: U2000.U30(FBA_CMD0) VRAM2501.G12(CS# | WE#)
FBA_CMD1: U2000.T31(FBA_CMD1) VRAM2501.H10(A3/BA3 | A5/BA1)
FBA_CMD2: U2000.U29(FBA_CMD2) VRAM2501.H11(A2 /BA0 | A4/BA2)
FBA_CMD3: U2000.R34(FBA_CMD3) VRAM2501.K11(A4/BA2 | A2/BA0)
FBA_CMD4: U2000.R33(FBA_CMD4) VRAM2501.K10(A5/BA1 | A3/BA3)
FBA_CMD5: U2000.U32(FBA_CMD5) VRAM2501.L12(WE# | CS#)
FBA_CMD6: U2000.U33(FBA_CMD6) VRAM2501.K4(A7/A8 | A0/A10)
FBA_CMD7: U2000.U28(FBA_CMD7) VRAM2501.K5(A6/A11 | A1/A9)
FBA_CMD8: U2000.V28(FBA_CMD8) VRAM2501.J4(ABI#)
FBA_CMD9: U2000.V29(FBA_CMD9) VRAM2501.J5(RFU/A12/NC)
FBA_CMD10: U2000.V30(FBA_CMD10) VRAM2501.H4(A0/A10 | A7/A8)
FBA_CMD11: U2000.U34(FBA_CMD11) VRAM2501.H5(A1/A9 | A6/A11)
FBA_CMD12: U2000.U31(FBA_CMD12) VRAM2501.G3(RAS# | CAS#)
FBA_CMD13: R2062.1 U2000.V34(FBA_CMD13) VRAM2501.J2(RESET#)
FBA_CMD14: R2064.2 U2000.V33(FBA_CMD14) VRAM2501.J3(CKE#)
FBA_CMD15: U2000.Y32(FBA_CMD15) VRAM2501.L3(CAS# | RAS#)
FBA_CMD16: U2000.AA31(FBA_CMD16) VRAM2500.L12(WE# | CS#)
FBA_CMD17: U2000.AA29(FBA_CMD17) VRAM2500.K10(A5/BA1 | A3/BA3)
FBA_CMD18: U2000.AA28(FBA_CMD18) VRAM2500.K11(A4/BA2 | A2/BA0)
FBA_CMD19: U2000.AC34(FBA_CMD19) VRAM2500.H11(A2 /BA0 | A4/BA2)
FBA_CMD20: U2000.AC33(FBA_CMD20) VRAM2500.H10(A3/BA3 | A5/BA1)
FBA_CMD21: U2000.AA32(FBA_CMD21) VRAM2500.G12(CS# | WE#)
FBA_CMD22: U2000.AA33(FBA_CMD22) VRAM2500.H4(A0/A10 | A7/A8)
FBA_CMD23: U2000.Y28(FBA_CMD23) VRAM2500.H5(A1/A9 | A6/A11)
FBA_CMD24: U2000.Y29(FBA_CMD24) VRAM2500.J4(ABI#)
FBA_CMD25: U2000.W31(FBA_CMD25) VRAM2500.J5(RFU/A12/NC)
FBA_CMD26: U2000.Y30(FBA_CMD26) VRAM2500.K4(A7/A8 | A0/A10)
FBA_CMD27: U2000.AA34(FBA_CMD27) VRAM2500.K5(A6/A11 | A1/A9)
FBA_CMD28: U2000.Y31(FBA_CMD28) VRAM2500.L3(CAS# | RAS#)
FBA_CMD29: R2063.1 U2000.Y34(FBA_CMD29) VRAM2500.J2(RESET#)
FBA_CMD30: R2001.2 U2000.Y33(FBA_CMD30) VRAM2500.J3(CKE#)
FBA_CMD31: U2000.V31(FBA_CMD31) VRAM2500.G3(RAS# | CAS#)
FBA_DBI0: U2000.P30(FBA_DQM0) VRAM2501.D2(DBI0# | DBI3#)
FBA_DBI1: U2000.F31(FBA_DQM1) VRAM2501.D13(DBI1# | DBI2#)
FBA_DBI2: U2000.F34(FBA_DQM2) VRAM2501.P13(DBI2 #| DBI1#)
FBA_DBI3: U2000.M32(FBA_DQM3) VRAM2501.P2(DBI3# | DBI0#)
FBA_DBI4: U2000.AD31(FBA_DQM4) VRAM2500.P2(DBI3# | DBI0#)
FBA_DBI5: U2000.AL29(FBA_DQM5) VRAM2500.P13(DBI2 #| DBI1#)
FBA_DBI6: U2000.AM32(FBA_DQM6) VRAM2500.D13(DBI1# | DBI2#)
FBA_DBI7: U2000.AF34(FBA_DQM7) VRAM2500.D2(DBI0# | DBI3#)
FBA_DEBUG0: TP2000.1 U2000.R32(FBA_CMD34)
FBA_DEBUG1: TP2001.1 U2000.AC32(FBA_CMD35)
FBA_EDC0: U2000.M31(FBA_DQS_WP0) VRAM2501.C2(EDC0 | EDC3)
FBA_EDC1: U2000.G31(FBA_DQS_WP1) VRAM2501.C13(EDC1 | EDC2)
FBA_EDC2: U2000.E33(FBA_DQS_WP2) VRAM2501.R13(EDC2 | EDC1)
FBA_EDC3: U2000.M33(FBA_DQS_WP3) VRAM2501.R2(EDC3 | EDC0)
FBA_EDC4: U2000.AE31(FBA_DQS_WP4) VRAM2500.R2(EDC3 | EDC0)
FBA_EDC5: U2000.AK30(FBA_DQS_WP5) VRAM2500.R13(EDC2 | EDC1)
FBA_EDC6: U2000.AN33(FBA_DQS_WP6) VRAM2500.C13(EDC1 | EDC2)
FBA_EDC7: U2000.AF33(FBA_DQS_WP7) VRAM2500.C2(EDC0 | EDC3)
FBA_PLL_AVDD: C2008.2 C2056.2 C2064.1 C2105.2 L2001.1 U2000.H17(FBB_PLL_AVDD) U2000.K27(FB_REFPLL_AVDD) U2000.U27(FBA_PLL_AVDD)
FBA_VREFC: C2513.1 C2515.1 R2505.2 R2507.2 R2508.2 VRAM2500.J14(VREFC) VRAM2501.J14(VREFC)
FBB_CMD0: U2000.D13(FBB_CMD0) VRAM2503.G12(CS# | WE#)
FBB_CMD1: U2000.E14(FBB_CMD1) VRAM2503.H10(A3/BA3 | A5/BA1)
FBB_CMD2: U2000.F14(FBB_CMD2) VRAM2503.H11(A2 /BA0 | A4/BA2)
FBB_CMD3: U2000.A12(FBB_CMD3) VRAM2503.K11(A4/BA2 | A2/BA0)
FBB_CMD4: U2000.B12(FBB_CMD4) VRAM2503.K10(A5/BA1 | A3/BA3)
FBB_CMD5: U2000.C14(FBB_CMD5) VRAM2503.L12(WE# | CS#)
FBB_CMD6: U2000.B14(FBB_CMD6) VRAM2503.K4(A7/A8 | A0/A10)
FBB_CMD7: U2000.G15(FBB_CMD7) VRAM2503.K5(A6/A11 | A1/A9)
FBB_CMD8: U2000.F15(FBB_CMD8) VRAM2503.J4(ABI#)
FBB_CMD9: U2000.E15(FBB_CMD9) VRAM2503.J5(RFU/A12/NC)
FBB_CMD10: U2000.D15(FBB_CMD10) VRAM2503.H4(A0/A10 | A7/A8)
FBB_CMD11: U2000.A14(FBB_CMD11) VRAM2503.H5(A1/A9 | A6/A11)
FBB_CMD12: U2000.D14(FBB_CMD12) VRAM2503.G3(RAS# | CAS#)
FBB_CMD13: R2068.1 U2000.A15(FBB_CMD13) VRAM2503.J2(RESET#)
FBB_CMD14: R2069.2 U2000.B15(FBB_CMD14) VRAM2503.J3(CKE#)
FBB_CMD15: U2000.C17(FBB_CMD15) VRAM2503.L3(CAS# | RAS#)
FBB_CMD16: U2000.D18(FBB_CMD16) VRAM2502.L12(WE# | CS#)
FBB_CMD17: U2000.E18(FBB_CMD17) VRAM2502.K10(A5/BA1 | A3/BA3)
FBB_CMD18: U2000.F18(FBB_CMD18) VRAM2502.K11(A4/BA2 | A2/BA0)
FBB_CMD19: U2000.A20(FBB_CMD19) VRAM2502.H11(A2 /BA0 | A4/BA2)
FBB_CMD20: U2000.B20(FBB_CMD20) VRAM2502.H10(A3/BA3 | A5/BA1)
FBB_CMD21: U2000.C18(FBB_CMD21) VRAM2502.G12(CS# | WE#)
FBB_CMD22: U2000.B18(FBB_CMD22) VRAM2502.H4(A0/A10 | A7/A8)
FBB_CMD23: U2000.G18(FBB_CMD23) VRAM2502.H5(A1/A9 | A6/A11)
FBB_CMD24: U2000.G17(FBB_CMD24) VRAM2502.J4(ABI#)
FBB_CMD25: U2000.F17(FBB_CMD25) VRAM2502.J5(RFU/A12/NC)
FBB_CMD26: U2000.D16(FBB_CMD26) VRAM2502.K4(A7/A8 | A0/A10)
FBB_CMD27: U2000.A18(FBB_CMD27) VRAM2502.K5(A6/A11 | A1/A9)
FBB_CMD28: U2000.D17(FBB_CMD28) VRAM2502.L3(CAS# | RAS#)
FBB_CMD29: R2066.1 U2000.A17(FBB_CMD29) VRAM2502.J2(RESET#)
FBB_CMD30: R2067.2 U2000.B17(FBB_CMD30) VRAM2502.J3(CKE#)
FBB_CMD31: U2000.E17(FBB_CMD31) VRAM2502.G3(RAS# | CAS#)
FBB_DBI0: U2000.E11(FBB_DQM0) VRAM2503.D2(DBI0# | DBI3#)
FBB_DBI1: U2000.E3(FBB_DQM1) VRAM2503.D13(DBI1# | DBI2#)
FBB_DBI2: U2000.A3(FBB_DQM2) VRAM2503.P13(DBI2 #| DBI1#)
FBB_DBI3: U2000.C9(FBB_DQM3) VRAM2503.P2(DBI3# | DBI0#)
FBB_DBI4: U2000.F23(FBB_DQM4) VRAM2502.P2(DBI3# | DBI0#)
FBB_DBI5: U2000.F27(FBB_DQM5) VRAM2502.P13(DBI2 #| DBI1#)
FBB_DBI6: U2000.C30(FBB_DQM6) VRAM2502.D13(DBI1# | DBI2#)
FBB_DBI7: U2000.A24(FBB_DQM7) VRAM2502.D2(DBI0# | DBI3#)
FBB_DEBUG0: TP2003.1 U2000.C12(FBB_CMD34)
FBB_DEBUG1: TP2002.1 U2000.C20(FBB_CMD35)
FBB_EDC0: U2000.D10(FBB_DQS_WP0) VRAM2503.C2(EDC0 | EDC3)
FBB_EDC1: U2000.D5(FBB_DQS_WP1) VRAM2503.C13(EDC1 | EDC2)
FBB_EDC2: U2000.C3(FBB_DQS_WP2) VRAM2503.R13(EDC2 | EDC1)
FBB_EDC3: U2000.B9(FBB_DQS_WP3) VRAM2503.R2(EDC3 | EDC0)
FBB_EDC4: U2000.E23(FBB_DQS_WP4) VRAM2502.R2(EDC3 | EDC0)
FBB_EDC5: U2000.E28(FBB_DQS_WP5) VRAM2502.R13(EDC2 | EDC1)
FBB_EDC6: U2000.B30(FBB_DQS_WP6) VRAM2502.C13(EDC1 | EDC2)
FBB_EDC7: U2000.A23(FBB_DQS_WP7) VRAM2502.C2(EDC0 | EDC3)
FBB_VREFC: C2535.1 C2558.1 R2523.2 R2524.2 R2525.2 VRAM2502.J14(VREFC) VRAM2503.J14(VREFC)
FBVDD_EN: PQ8003.2(G) PR8007.1 U2005.4(O)

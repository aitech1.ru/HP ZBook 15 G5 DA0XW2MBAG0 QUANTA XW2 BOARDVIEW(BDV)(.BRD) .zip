# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND0: length 8.3
  BOTTOM w0.114: CON400.1 91.23,61.65 90.45,60.87 89.9,60.87 88.22,59.2 88.22,58.82 87.79,58.38 87.28,58.38 87.15,58.26 v1(86.77,58.26) 86.52,58.51 R405.1
GND_DDR: length 14
  TOP w0.254: PU14000.4 v1(95.74,64.34)
  TOP w0.508: v1(95.74,64.34) 95.03,64.34 PC14000.2 94.24,64.34 PC14008.2 93.5,65.08 93.5,65.75 v1(93.43,65.83) 93.43,67.35 92.88,67.9 PR14015.1 92.12,67.9 91.85,68.16 PQ14000.1 ; PC14015.2 v1(93.38,62.32) 93.37,62.33 PC14014.2
  BOTTOM w0.508: v1(93.38,62.32) 93.38,62.7 95.02,64.34 v1(95.74,64.34) 95.94,64.34 PR14001.2
P1V5S_PG: length 0.9
  TOP w0.114: TP16000.1 99.9,21.02 PR16018.1
VCC1_RST#: length 12.8
  IN2 w0.305: v1(266.91,19.22) 266.83,19.29 266.83,20 267.37,20.54 267.37,21.13 268.41,22.17 268.41,24.05 268.71,24.35 268.71,29.4 v3(268.24,29.87)
  BOTTOM w0.254: U6001.K6 v3(268.24,29.87)
  BOTTOM w0.508: R9010.2 267.39,19 267.13,19 v1(266.91,19.22)
VCC1_RST#_R1: length 2.4
  BOTTOM w0.114: R9010.1 267.49,17.58 v1(267.77,17.31) 267.74,17.29 JCN9000.16
VCC3V3_ANA: length 2.1
  TOP w0.254: C8090.2 342.89,118.67 v3(342.89,117.82)
  BOTTOM w0.114: U8001.E16 v3(342.89,117.82)
VCC3V3_ANA_PCIE: length 2
  TOP w0.254: v3(342.94,115.22) 342.45,115.22 342.37,115.14 R8047.2 C8089.2
  BOTTOM w0.254: v3(342.94,115.22) 343.21,114.95 U8001.L16
VCC3V3_ANA_USB2: length 3.5
  TOP w0.254: v3(342.24,116.52) 342.7,116.99 342.7,117.36 342.3,117.77 C8088.2 v1(341.42,118.37)
  BOTTOM w0.254: U8001.H18 v3(342.24,116.52)
VCC_BOOST: length 4.4
  BOTTOM w0.305: CON9500.12 256.43,8.91 C9501.1
  BOTTOM w0.508: R9503.1 253.88,8.6 254.56,9.28 C9501.1
VCCD_DP: length 6.5
  BOTTOM w0.089: U8500.B10 341.18,97.34 341.18,97.75 341.37,97.94 341.37,98.68 340.96,99.08
  BOTTOM w0.114: 340.7,99.26 340.78,99.26 340.96,99.08
  BOTTOM w0.254: 340.7,99.26 340.28,99.26 340.01,99.53 338.23,99.53 v1(337.98,99.28) 337.8,99.46 C8506.2
VCCGPPA_1P8V: length 2.8
  TOP w0.114: v1(256.95,69.26) 257.46,69.26 C9305.1 R9341.2
  BOTTOM w0.254: v1(256.95,69.26) 256.93,69.24 U9002.AN32
VCCGT_CS: length 47.8
  IN2 w0.203: v1(123.25,117.08) 123.22,117.11 123.22,117.26 122.79,117.69 122.18,117.69 121.42,116.93 120.78,116.93 118.19,119.53 118.19,127.03 118.56,127.41 121.57,127.41 v1(123.03,128.87) 122.59,129.31 122.59,134.96 130.72,143.09 v1(133,143.09)
  BOTTOM w0.203: PR21009.1 123.22,117.06 v1(123.25,117.08) ; v1(133,143.09) 133.1,143.19 PR19022.1 133.64,143.85 133.19,144.3 131.43,144.3 130.57,145.16 129.97,145.16 129.49,145.64 PU19000.1 ; v1(123.03,128.87) 123,128.87 PR21004.1
VCCGT_CS_SUM: length 16.9
  IN1 w0.254: v1(122.46,149.2) 122.52,149.14 123.65,149.14 124.24,148.55 124.24,147.03 126.65,144.62 130.33,144.62 132.49,142.46 v1(133,142.46)
  BOTTOM w0.203: v1(133,142.46) 133.35,142.46 PR19022.2 ; v1(122.46,149.2) 122.53,149.13 123.67,149.13 123.68,149.13 PU19000.19
VCCGT_PWM: length 51.3
  IN1 w0.203: v1(131.16,150.4) 130.52,150.4 129.7,151.22 125.51,151.22 124.37,150.08 122.55,150.08 122.03,149.56 122.03,143.47 121.7,143.14 121.7,129.38 v1(121.19,128.87)
  IN3 w0.203: v1(121.19,128.87) 119.74,128.87 118,127.13 118,119.1 120.61,116.5 120.61,116.07 120.83,115.84 v1(121.06,115.84)
  BOTTOM w0.203: v1(131.16,150.4) 131.09,150.33 PU19000.39 ; v1(121.19,128.87) v1(120.3,127.98) PR21000.1 ; PR21005.1 120.89,115.66 v1(121.06,115.84)
VCCGT_VDIFF: length 1.8
  BOTTOM w0.203: PR19038.1 125.14,144.75 125.89,145.5 PU19000.10
VCCGT_VFB: length 3.8
  BOTTOM w0.203: PU19000.11 125.49,145.59 124.39,144.49 PR19038.2 124.36,144.05 v1(123.98,143.68) 124.37,143.3 PR19039.1
VCCGT_VORTN: length 3.5
  BOTTOM w0.203: PR19044.1 122.58,144.58 122.58,144.99 123.6,146.01 123.6,146.52 123.82,146.74 PU19000.13
VCCGT_VOSEN: length 3.4
  BOTTOM w0.203: PU19000.12 125.09,145.76 124.65,145.33 v1(123.96,145.33) 123.43,145.33 122.97,144.87 122.97,144.59 PR19042.1
VCCIO_PG: length 389.2
  TOP w0.127: R9128.1 274.28,70.06 274.76,70.06 R9129.2 275.13,69.69 275.78,69.69 U9000.1 276.89,68.57 276.89,68.12 277.84,67.18 277.84,66.29 277.51,65.96 277.51,64.69 276.87,64.04 276.87,62.91 v1(276.4,62.44) ; v1(167.93,12.54) 168.56,11.9 170.09,11.9 171,12.82 171,19.65 v1(170.77,19.88)
  IN1 w0.127: v1(301.12,30.06) 300.62,30.57 298.38,30.57 297.54,31.41 295.97,31.41 294.52,32.86 288.42,32.86 287.15,31.59 281.85,31.59 v1(281.21,32.22)
  IN2 w0.127: v1(167.93,12.54) 167.93,13.04 169.08,14.2 180.16,14.2 183.16,17.21 196.18,17.21 196.75,17.78 204.13,17.78 206.92,14.99 218.69,14.99 221.04,12.64 237.31,12.64 238.95,11 244.39,11 244.84,11.44 244.84,13.76 245.32,14.24 247.99,14.24 248.55,14.8 248.55,17.31 249.42,18.19 249.42,28.37 252.38,31.33 252.38,31.88 255.87,35.37 259.23,35.37 259.72,35.86 260.96,35.86 261.56,36.47 261.56,36.59 263.34,38.37 263.34,38.66 264.52,39.85 265.02,39.85 265.53,40.36 266.4,40.36 267.6,41.55 267.6,45.76 269.38,47.54 269.38,50.23 273.82,54.67 273.82,55.64 273.69,55.77 273.69,56.99 273.92,57.22 274.25,57.22 274.53,57.49 274.53,59.71 275.25,60.44 275.25,60.67 275.46,60.88 275.46,61.36 275.6,61.5 275.6,61.53 276.01,61.94 276.01,62.05 v1(276.4,62.44) ; v1(182.58,152.64) 183.39,151.83 184.61,151.83 186.62,149.82 186.62,149.6 189.1,147.12 189.1,132.94 189.7,132.34 189.7,128.71 191.27,127.14 191.27,122.97 190.87,122.57 190.38,122.57 188.96,121.15 188.96,102.37 186.96,100.37 186.96,99.01 184.39,96.44 183.28,96.44 182.71,97.01 182.36,97.01 182.09,96.74 182.09,96.58 181.68,96.17 181.57,96.17 178.85,93.45 178.85,89.22 180.76,87.31 180.76,69.48 184.75,65.48 184.75,48.95 183.5,47.7 183.5,34.55 v1(184.44,33.62)
  IN4 w0.127: v1(184.44,33.62) 184.84,33.21 184.84,32.58 184.46,32.2 182.3,32.2 179.66,29.55 175.71,29.55 170.85,24.69 170.85,19.95 v1(170.77,19.88)
  BOTTOM w0.127: v1(281.21,32.22) 279.13,34.3 279.13,35.82 278.57,36.39 278.57,45.26 276.4,47.43 276.4,51.79 275.72,52.47 275.72,55.97 275.99,56.24 275.99,56.95 275.28,57.66 275.28,60.46 275.43,60.61 275.43,61.87 275.98,62.41 276.37,62.41 v1(276.4,62.44) ; v1(182.58,152.64) 182.35,152.87 181.26,152.87 181,153.13 PR17016.1 ; PR25000.1 301.15,30.09 v1(301.12,30.06)
VCCIO_VCCSENSE: length 18.7
  IN1 w0.254: v1(173.73,109.79) 174.23,110.29 180.63,110.29 181.64,109.28 181.64,106.39 183.17,104.87 183.17,103.55 183.53,103.18 183.61,103.18 v1(183.61,103.23)
  BOTTOM w0.203: v1(173.73,109.79) 173.76,109.82 174.4,109.82 U9001.H14
  BOTTOM w0.254: v1(183.61,103.23) 183.77,103.07 183.77,103.01 184.23,102.55 PR17018.2
VCCIO_VSSSENSE: length 19.5
  IN1 w0.254: v1(184.27,103.21) 184.27,104.02 183.55,104.74 183.55,105.12 181.97,106.69 181.97,109.49 180.78,110.68 173.93,110.68 v1(173.02,109.77)
  BOTTOM w0.254: U9001.J14 173.99,109.28 173.51,109.28 v1(173.02,109.77) ; PR17019.2 184.84,103.21 v1(184.27,103.21)
VCCMPHY_SENSE: length 83.5
  TOP w0.114: v1(268.31,47.08) 270.16,45.23 270.16,44.34 273.05,41.45 275.58,41.45 276.94,42.81 276.94,44.27 282.26,49.6 287.32,49.6 289,51.28 289,55.2 294.16,60.35 296.78,60.35 297.63,61.2 299.42,61.2 299.75,60.87 299.75,60.58 300.7,59.63 302.8,59.63 303.26,59.17 305.72,59.17 306.23,59.68 v1(306.23,60.11) ; PR18012.2 310.47,65.93 v1(310.62,65.78)
  IN2 w0.089: v1(306.23,60.11) 308.39,62.27 311.13,62.27 311.44,62.57 311.44,64.96 v1(310.62,65.78)
  BOTTOM w0.114: v1(268.31,47.08) 267.8,46.57 v1(265.72,46.57) 265.39,46.9 262.27,46.9 260.44,48.73 259.42,48.73 258.15,50.01 258.15,50.46 256.01,52.59 256.01,54.3 255.69,54.62 255.21,54.62 U9002.K47
VCCPRIM_1P05_AE17: length 2.5
  TOP w0.381: v1(248.32,69.79) 248.43,69.9 R17910.1
  BOTTOM w0.254: v1(248.32,69.79) 248.83,70.3 248.83,70.9 U9002.AE17
VCCSA_CS: length 85.5
  IN2 w0.203: v1(180.32,148.66) 180.19,148.52 179.9,148.52 179.1,149.32 179.1,152.49 180.25,153.63 181.77,153.63 182.61,154.48 182.61,157.74 181.9,158.46 175.95,158.46 173.88,160.53 143.08,160.53 142.42,159.87 142.42,158.66 138.49,154.73 132.98,154.73 132.21,155.5 131.91,155.5 131.55,155.13 131.12,155.13 130.73,155.53 128.25,155.53 127.92,155.2 127.92,153.63 128.98,152.58 128.98,146.87 v1(130.22,145.63)
  BOTTOM w0.203: v1(130.22,145.63) 130.34,145.51 130.87,145.51 PR19024.2 130.66,145.97 130.66,146.31 PU19000.48 ; v1(180.32,148.66) 180.19,148.52 PR21014.1
VCCSA_CS_SUM: length 13.4
  IN1 w0.254: v1(131.48,145) 126.74,145 124.62,147.12 124.62,148.81 123.83,149.6 v1(123,149.6)
  BOTTOM w0.203: v1(131.48,145) 131.45,145.03 PR19024.1 ; v1(123,149.6) 123.06,149.53 PU19000.20
VCCSA_PWM: length 62
  IN1 w0.203: v1(179.58,151.4) 179.58,151.38 179.1,151.86 179.1,155.92 174.02,161 140.21,161 139.43,160.21 139.43,157.8 135.19,153.56 133.56,153.56 v1(131.04,151.03)
  BOTTOM w0.203: v1(131.04,151.03) 130.74,150.74 PU19000.38 ; PR21010.1 v1(179.58,151.4)
VCCSA_VCCSENSE: length 73.1
  IN1 w0.203: v1(171.76,129.62) 171.27,130.11 170.67,130.11 169.45,128.89 162.69,128.89 161.51,130.07 155.3,130.07 153.04,132.33 149.57,132.33 148.14,130.9 140.99,130.9 139.45,132.44 131.35,132.44 128.07,135.72 128.07,140.69 126.31,142.46 124.48,142.46 123.92,141.9 123.7,141.9 v1(123.48,142.12)
  BOTTOM w0.114: U9001.M38 171.86,127.22 171.86,129.52 v1(171.76,129.62) 172.65,130.52 PR19047.1
  BOTTOM w0.203: PR19048.2 121.45,147.86 121,147.86 120.81,147.66 120.81,146.78 120.3,146.27 120.3,143.88 v1(120.35,143.83) 120.3,143.78 120.3,142.58 120.94,141.95 123.3,141.95 v1(123.48,142.12)
VCCSA_VDIFF: length 3
  BOTTOM w0.203: PU19000.14 123.58,147.13 123.02,146.57 v1(123.02,146.34) 122.21,145.53 PR19053.1
VCCSA_VFB: length 3.7
  BOTTOM w0.203: PU19000.15 123.46,147.53 PR19053.2 PR19054.1
VCCSA_VORTN: length 2.1
  BOTTOM w0.203: PR19049.1 122.93,148.17 123.49,148.17 123.65,148.33 PU19000.17
VCCSA_VOSEN: length 2
  BOTTOM w0.203: PR19048.1 123.04,147.56 123.33,147.85 123.86,147.85 123.94,147.93 PU19000.16
VCCSA_VSSSENSE: length 74
  IN1 w0.203: v1(171.07,129.62) 171.04,129.66 170.61,129.66 169.57,128.61 162.57,128.61 161.41,129.78 155.18,129.78 152.91,132.04 149.74,132.04 148.32,130.62 140.88,130.62 139.34,132.16 131.24,132.16 127.79,135.6 127.79,140.58 126.19,142.18 124.59,142.18 124.03,141.62 123.65,141.62 v1(123.48,141.44)
  BOTTOM w0.114: U9001.M37 171.61,126.82 171.61,129.06 171.07,129.6 v1(171.07,129.62) 171.74,130.3 PR19050.1
  BOTTOM w0.203: PR19049.2 121.33,148.17 120.87,148.17 120.49,147.8 120.49,146.91 119.98,146.4 119.98,144.13 119.88,144.02 119.88,143.63 119.98,143.53 119.98,142.72 119.98,142.45 120.8,141.63 123.29,141.63 v1(123.48,141.44)
VCCSENSE: length 52.2
  IN1 w0.203: v1(159.86,126.69) 160.31,127.13 160.31,128.66 v1(160.23,128.74) 159.72,129.24 154.8,129.24 152.55,131.49 149.82,131.49 148.06,129.73 140.53,129.73 139.08,131.19 128.91,131.19 125.33,134.76 125.33,141.39 v1(125.51,141.57)
  BOTTOM w0.203: U9001.AG37 159.93,126.69 v1(159.86,126.69) ; v1(125.51,141.57) 126.14,142.2 PR19033.2 ; v1(160.23,128.74) 160.23,129.96 PR19032.1 160.69,130.17 160.91,130.39 R9047.1
VCCST_PWRGD: length 16
  IN2 w0.089: v1(175.17,109.03) 175.17,109 175.62,108.55 176.22,108.55 176.31,108.64 178.76,108.64 179.53,107.86 179.53,102.53 180.58,101.49 v1(182.84,101.49)
  BOTTOM w0.114: v1(182.84,101.49) 183.5,101.49 183.8,101.18 R9340.1
  BOTTOM w0.127: v1(175.17,109.03) 175.17,109.02 U9001.H13
VDD_SIM: length 3.7
  BOTTOM w0.114: CON9500.10 257.43,8.45 257.08,8.8 R9504.2 256.91,9.28 256.57,9.62 v1(256.57,11.01)
VDD_SUPPLY_2P: length 19.8
  TOP w0.508: R7153.1 v1(343.44,101.56) v1(341.92,101.56)
  IN4 w0.508: v1(341.43,96.36) 342.32,95.47 342.81,95.47 343.82,94.45 343.82,90.54 345.85,88.51 v1(345.85,88.23)
  BOTTOM w0.254: U8500.D10 341.01,96.09 341.28,96.36 v1(341.43,96.36) 341.2,96.59 U8500.C10
  BOTTOM w0.508: v1(345.85,88.23) 346.23,88.61 R7140.1 R7199.1 ; R7153.1 v1(343.44,101.56) ; R8505.1 v1(341.92,101.56) 341.82,101.67 v1(339.88,101.67) 339.87,101.65 339.73,101.65 339.34,101.26 R8507.2
  vias: v1(340.52,100.52)
VIN1N: length 11.7
  TOP w0.203: v1(191.04,48.78) 191.55,49.29 191.55,50.38 191.95,50.79 193.15,50.79 v1(193.5,51.14)
  BOTTOM w0.203: PU9802.12 194.39,53.14 194.01,52.76 194.01,52.59 193.5,52.08 v1(193.5,51.14) ; PR9803.2 188.41,50.54 PC9801.1 188.41,49.51 189.14,48.78 v1(189.39,48.78) v1(191.04,48.78)
VIN1N_R: length 0.9
  BOTTOM w0.203: TP98006.1 187.51,52.35 PR9803.1
VIN1P: length 9.6
  BOTTOM w0.203: PU9802.11 194.39,52.49 193.99,52.08 193.99,50.92 193.71,50.64 v1(193.07,50.64) 192.56,50.13 192.56,49.49 192.35,49.27 PC9807.2 189.99,49.27 189.61,49.66 PC9801.2 189.61,50.36 PR9802.2
VIN1P_R: length 1.1
  BOTTOM w0.203: PR9802.1 188.63,52.2 188.63,52.8 TP98005.1
VIN2N: length 10.4
  TOP w0.203: v1(196.12,54.83) 196.5,54.83 198.79,52.54 198.79,51.65 199.04,51.4 200.36,51.4 200.57,51.2 200.57,50.89 200.73,50.73 PC9802.1 202.09,50.73 v1(202.3,50.94) 202.43,51.07 PR9808.2
  BOTTOM w0.203: PU9802.14 196.18,54.77 v1(196.12,54.83)
VIN2N_R: length 1.5
  TOP w0.114: TP98008.1 204.88,50.76 204.63,50.51 204.51,50.51 PR9808.1
VIN2P: length 14.7
  TOP w0.203: PR9807.2 203.17,49.43 v1(202.6,48.86) 201.58,48.86 201.23,49.21 PC9802.2 PC9806.1 199.39,49.11 198.15,49.11 196.37,50.89 195.49,50.89 195.1,51.27 195.1,54.45 v1(195.49,54.83)
  BOTTOM w0.203: v1(195.49,54.83) 195.53,54.79 PU9802.13
VIN2P_R: length 1.5
  TOP w0.114: PR9807.1 204.41,50.26 204.65,50.26 204.88,50.03 TP98007.1
VSS_GPU_SENSE: length 89.8
  IN2 w0.254: v1(215.68,88.58) 215.68,88.3 216.92,87.05 218.27,87.05 219.27,86.05 219.27,83.41 221.48,81.2 221.48,80.02 225.41,76.09 225.41,69.63 227.03,68.01 227.66,68.01 229.02,66.65 229.02,53.59 224.39,48.95 216.64,48.95 215.59,47.91 211.32,47.91 210.76,47.35 210.76,46.59 209.48,45.3 206.25,45.3 v1(205.65,45.91)
  IN3 w0.254: v1(215.68,88.58) 215.81,88.7 215.81,89.47 217.32,90.98 217.32,95.23 217.63,95.54 217.63,97.63 218.38,98.39 218.38,100.5 v1(219.19,101.31)
  BOTTOM w0.203: v1(219.19,101.31) U2000.L5
  BOTTOM w0.254: PR9028.1 216.82,84.92 216.82,87.34 215.68,88.48 v1(215.68,88.58) ; PR9026.2 205.65,46.43 v1(205.65,45.91)
VSSMPHY_SENSE: length 70.8
  TOP w0.114: PR18013.2 303.13,59.63 302.89,59.86 300.79,59.86 299.98,60.68 299.98,60.97 299.52,61.43 297.54,61.43 296.68,60.58 294.06,60.58 292.41,58.93 292.41,58.92 288.77,55.29 288.77,51.43 287.17,49.82 282.09,49.82 276.71,44.45 276.71,42.9 275.49,41.68 273.15,41.68 270.42,44.41 270.42,45.68 v1(268.38,47.72)
  BOTTOM w0.102: 256.33,53.06 256.27,53.13 256.27,54.35 255.76,54.85 255.31,54.85 254.14,56.02 U9002.K46
  BOTTOM w0.114: v1(268.38,47.72) 267.14,47.72 v1(266.86,47.44) 262.06,47.44 260.51,48.99 259.49,48.99 258.38,50.1 258.38,50.61 256.33,52.66 256.33,53.06
VSSSENSE: length 51
  IN1 w0.203: v1(124.87,141.57) 125.05,141.39 125.05,134.65 128.79,130.91 138.96,130.91 140.42,129.45 148.32,129.45 150.07,131.2 152.43,131.2 154.67,128.96 159.24,128.96 v1(159.47,128.74) 159.86,128.34 v1(159.86,127.34)
  BOTTOM w0.203: v1(124.87,141.57) 125,141.7 125,141.77 125.25,142.03 PR19035.2 ; R9048.1 158.94,130.39 159.16,130.17 PR19037.1 159.47,130.12 v1(159.47,128.74) ; v1(159.86,127.34) 159.93,127.34 U9001.AG38
2260BST1.35V:
  vias: v1(239.05,145.66)
2260EN1.35V: length 3.5
  BOTTOM w0.254: PU8001.2 235.22,147.77 PC8015.1 PR8007.2
2260FB1.35V: length 4
  BOTTOM w0.254: PR8013.1 PR8008.1 PR8009.1 236.13,149.78 236.13,149.54 236.39,149.27 PU8001.5
2260FB1.35V_S: length 19.2
  TOP w0.254: v1(232.37,137.63) 233.43,137.63 233.85,138.05 PR8023.1
  IN4 w0.254: v1(235.11,151.7) 233.84,150.43 233.84,139.11 v1(232.37,137.63)
  BOTTOM w0.254: v1(235.11,151.7) 234.6,151.19 PR8008.2 ; PR8006.1 v1(232.37,137.63)
2260LX1.35V:
  vias: v1(246.67,152.24)
2260PFM1.35V: length 1.5
  BOTTOM w0.254: PR8005.2 235.77,148.27 PU8001.3
2260PG1.35V: length 1.3
  BOTTOM w0.254: PU8001.1 235.77,147.27 PR8003.2
2260SS1.35V: length 2.1
  BOTTOM w0.254: PC8016.1 236.14,146.62 PU8001.23
2261_BST_5V: length 2.2
  TOP w0.508: PR13017.2 215.39,36 v1(215.55,36.16)
  BOTTOM w0.254: PU13002.20 215.34,36.39 215.55,36.19 215.55,36.16 v1(215.55,36.16)
2261_EN_5V: length 8.1
  BOTTOM w0.114: v1(211.28,30.22) 211.41,30.09 212.58,30.09 212.89,30.4 PR13025.2
  BOTTOM w0.254: PR13022.2 212.76,32.48 213.16,32.48 ; PR13025.2 PR13026.1 213.15,31.31 213.15,32.48 213.16,32.48 ; 213.16,32.48 PC13043.2 213.59,32.54 PU13002.2
2261_FB_5V: length 4.5
  BOTTOM w0.114: v1(208.75,32.48) PR13023.1
  BOTTOM w0.254: PR13023.1 209.59,32.48 210.34,32.48 210.35,32.48 PR13024.2 210.6,32.83 211.59,33.82 211.94,33.82 212.09,33.98 PU13002.5
2261_FB_5V_S: length 20.1
  IN3 w0.203: v1(208.95,31.71) 215.55,31.71 216.34,30.93 221.67,30.93 224.36,33.62 225.52,33.62 225.89,33.99 v1(225.89,34.13)
  BOTTOM w0.254: PR13020.1 225.97,34.2 v1(225.89,34.13) ; PR13023.2 208.96,31.71 v1(208.95,31.71)
2261_LX_5V: length 1
  TOP w0.508: PC13036.2 216.45,34.88 v4(215.93,35.4)
  vias: v1(215.55,38.44)
2261_PFM_5V: length 3.3
  BOTTOM w0.254: PR13021.1 211.61,33.06 v1(211.84,33.29) 212.01,33.12 212.9,33.12 213.09,33.32 PU13002.3
2261_PG_5V: length 26.1
  TOP w0.254: PR13018.2 211.62,47.2 v1(211.87,46.95)
  IN2 w0.254: v1(214.09,33.31) 213.77,32.98 210.23,32.98 205.52,37.7 205.52,43.14 206.5,44.12 209.52,44.12 211.87,46.47 v1(211.87,46.95)
  BOTTOM w0.254: PU13002.1 v1(214.09,33.31)
2261_SS_5V: length 2.6
  BOTTOM w0.254: PU13002.23 214.67,34.51
  BOTTOM w0.381: PC13044.1 214.66,33.11 v1(214.92,33.36) 214.92,33.87 214.67,34.11 214.67,34.51
2263_BST_1.05V:
  vias: v1(302.93,63.08)
2263_BST_1.05V_R:
  vias: v1(301.05,61.05)
2263_EN_1.05V: length 8.5
  TOP w0.114: v1(307.97,59.88) PR18011.2 308.45,60.72 308.75,61.03 308.75,62.23 308.66,62.32 307.75,62.32 307.49,62.58 PR18008.2
  TOP w0.254: PU18000.2 305.84,65.63 307.49,63.98 PC18014.2 PR18008.2
2263_FB_1.05V: length 3.3
  TOP w0.254: PR18009.1 308.13,66.89 307.88,66.65 PR18010.2 306.91,66.65 v1(306.71,66.84) 306.38,66.84 306.09,67.13 PU18000.5
2263_FB_1.05V_S: length 28.7
  TOP w0.203: v1(309.91,66.77) 310.01,66.86 PR18012.1
  TOP w0.254: v1(309.91,66.77) 309.79,66.89 PR18009.2 ; PR18006.1 287.31,68.17 v1(287.31,68.42)
  IN4 w0.254: v1(309.91,66.77) 307.5,66.77 304,63.27 291.69,63.27 287.81,67.15 287.81,67.91 v1(287.31,68.42)
2263_LX_1.05V: length 0.8
  BOTTOM w0.508: v1(297.97,64.99) PR18004.2
  vias: v1(301.15,63.72)
2263_PFM_1.05V: length 2.6
  TOP w0.254: PR18005.1 307.32,64.86 v1(306.64,65.55) 306.51,65.55 305.92,66.13 PU18000.3
2263_PG_1.05V: length 4.8
  TOP w0.254: PU18000.1 305.75,65.13 306.97,63.92 306.97,62.57 v1(306.69,62.3) 307.17,61.81 PR18003.2
2263_SS_1.05V: length 2.9
  TOP w0.254: PU18000.23 304.81,63.82 304.79,63.8 v1(304.79,62.98) 305.76,62 PC18015.1
8051_RX_CAPS_LED#: length 27.8
  TOP w0.114: R6182.2 268.5,13.93 268.38,13.82 U6003.3 267.55,14.05 266.91,14.7 v1(266.73,14.7) 266.73,14.94 266.87,15.08 R6185.1 ; R6100.2 v1(271.69,33.65) 271.05,33.65 v1(270.14,32.75) 269.12,31.72 269.12,29.64 v3(269.54,29.22)
  IN2 w0.089: v3(269.54,29.22) 269.02,28.7 269.02,24.22 268.7,23.9 268.7,22.06 267.77,21.13 267.77,18.79 266.86,17.87 266.86,14.82 v1(266.73,14.7)
  BOTTOM w0.114: JCN9000.14 266.74,14.68 v1(266.73,14.7) ; U6001.J7 v3(269.54,29.22)
8051_TX_LED_PWRSTBY#: length 35.1
  TOP w0.076: 272.19,29.43 271.66,28.89 270.69,28.89
  TOP w0.114: 272.19,29.43 273.34,30.57 273.59,30.57 274.27,31.25 274.97,31.25 R6068.2 ; v1(266.73,14.06) 266.73,13.04 267.25,12.52 U6003.1 268.64,12.52 R6181.2 268.5,11.65 266.86,11.65 v1(266.1,10.89) 265.93,10.71 263.85,10.71 R6186.1 ; v3(270.19,28.57) 270.52,28.89 270.69,28.89
  IN2 w0.076: v3(270.19,28.57) 269.87,28.25 269.37,28.25 269.2,28.08 269.2,27.9
  IN2 w0.089: 269.2,27.9 269.2,24.14 268.88,23.83 268.88,21.98 267.95,21.06 267.95,18.71 267.14,17.9 267.14,14.47 v1(266.73,14.06)
  BOTTOM w0.114: U6001.H8 v3(270.19,28.57) ; JCN9000.13 266.24,14.55 v1(266.73,14.06)
8693_VCORE_BST1: length 0.9
  TOP w0.114: PC20009.1 v1(146.69,154.88)
8693_VCORE_BST2: length 0.8
  TOP w0.114: PC20019.1 v1(154.67,154.88)
8693_VCORE_BST3: length 0.9
  TOP w0.114: PC20033.1 v1(162.57,154.88)
8693_VCORE_BST4: length 0.9
  TOP w0.114: PC20043.1 v1(170.72,154.88)
8693_VCORE_CS1: length 2.7
  TOP w0.254: PR20002.2 143.03,158.18 v1(142.96,158.1) 142.66,157.8 PU20000.5
8693_VCORE_CS2: length 2.8
  TOP w0.254: PU20001.5 150.66,157.03 150.25,157.44 v1(150.25,158) 150.53,158.28 PR20020.2
8693_VCORE_CS3: length 2.7
  TOP w0.254: PR20032.2 158.4,158.05 v1(158.2,157.85) 158.2,157.37 158.53,157.03 PU20002.5
8693_VCORE_CS4: length 2.6
  TOP w0.254: PU20003.5 166.66,156.73 166.35,157.04 v1(166.35,157.93) 166.53,158.1 PR20047.2
8693_VCORE_HG1: length 9.8
  IN1 w0.889: v4(144.28,154.21) 144.25,154.21 144.05,154.01 144.05,153.35 141.76,151.07 138.21,151.07 v4(136.76,149.62)
  vias: v1(136.3,149.06)
8693_VCORE_HG1_R: length 0.8
  BOTTOM w0.114: PQ20000.1 v1(137.45,152.24)
8693_VCORE_HG2: length 8.8
  IN1 w0.889: v4(145.65,149.62) 147.12,151.09 149.56,151.09 152.28,153.81 v4(152.28,154.21)
  vias: v1(144.91,149.11)
8693_VCORE_HG3: length 8.5
  IN1 w0.889: v4(160.15,154.21) 159.65,153.7 159.65,153.05 157.82,151.22 156.05,151.22 v4(154.06,149.23)
  vias: v1(153.37,149.04)
8693_VCORE_HG4: length 7.4
  IN1 w0.889: v4(163.31,149.24) 163.94,149.24 168.28,153.58 v4(168.28,154.21)
  vias: v1(162.62,149.09)
8693_VCORE_ISENN1: length 2.8
  TOP w0.254: PU20000.6 142.16,157.55 PR20014.2 141.91,157.56 141.1,156.76 v1(140.95,156.76)
8693_VCORE_ISENN2: length 2.5
  TOP w0.254: v1(148.83,156.35) 149.13,156.66 PR20029.2 149.63,157.15 150.16,156.62 PU20001.6
8693_VCORE_ISENN3: length 2.5
  TOP w0.254: PU20002.6 158.03,156.54 157.43,157.15 PR20044.2 157,156.66 v1(156.67,156.33)
8693_VCORE_ISENN4: length 2.6
  TOP w0.254: PU20003.6 166.16,156.59 165.82,156.94 165.56,156.94 165.35,157.15 PR20059.2 165.13,156.66 v1(164.8,156.33)
8693_VCORE_ISENP1: length 3.8
  TOP w0.254: PR20011.2 140.89,157.56 140.29,156.96 140.29,156.63 140.19,156.53 v1(140.19,155.59) 140.28,155.5 PU20000.7
8693_VCORE_ISENP2: length 3.6
  TOP w0.254: PU20001.7 149.06,155.5 148.71,155.86 148.23,155.86 148.11,155.97 PR20026.2 147.41,157.15 v1(147.25,156.99)
8693_VCORE_ISENP3: length 3.6
  TOP w0.254: v1(155.15,157.06) 155.24,157.15 PR20041.2 155.99,155.95 156.24,155.69 156.85,155.69 157.04,155.5 PU20002.7
8693_VCORE_ISENP4: length 3.6
  TOP w0.254: v1(163.28,157.04) 163.39,157.15 PR20056.2 164.12,155.92 164.4,155.64 165.03,155.64 165.17,155.5 PU20003.7
8693_VCORE_LG1: length 14.6
  TOP w0.114: v4(137.45,145.09) v1(138.13,145.09)
  IN1 w0.889: v4(141.4,154.25) 141.4,152.79 140.65,152.03 137.73,152.03 135.69,150 135.69,146.85 v4(137.45,145.09)
8693_VCORE_LG2: length 13
  IN1 w0.889: v4(149.4,154.25) 149.37,154.25 147.48,152.36 146.59,152.36 143.92,149.7 143.92,147.51 v4(146.34,145.09)
  vias: v1(149.21,153.58)
8693_VCORE_LG3: length 12.7
  IN1 w0.889: v4(155.23,145.09) 152.43,147.89 152.43,150.08 154.97,152.62 155.64,152.62 v4(157.27,154.25)
  vias: v1(156.98,153.63)
8693_VCORE_LG4: length 11.6
  IN1 w0.889: v4(164.37,145.09) 161.96,147.51 161.96,150.81 v4(165.4,154.25)
  vias: v1(165.11,153.63)
8693_VCORE_PWM1: length 3.5
  TOP w0.254: PR20001.2 144.56,158.51 144.76,158.31 144.76,157.04 v1(144.53,156.81) 143.85,156.81 143.66,156.62 PU20000.3
8693_VCORE_PWM2: length 3.3
  TOP w0.254: PR20016.2 152.05,158.23 152.48,157.8 152.48,157.04 v1(152.46,157.01) 151.95,157.01 151.66,156.72 PU20001.3
8693_VCORE_PWM3: length 3.4
  TOP w0.254: PU20002.3 159.53,156.62 159.9,156.99 v1(160.41,156.99) 160.41,158.08 159.93,158.56 PR20031.2
8693_VCORE_PWM4: length 3.2
  TOP w0.254: PU20003.3 167.66,156.64 167.85,156.83 168.43,156.83 v1(168.46,156.86) 168.46,157.47 168.28,157.65 168.28,158.38 PR20045.2
8693_VCORE_SW1: length 12.9
  TOP w0.508: v1(143.03,145.51) 142.62,145.09 PR20003.1
  IN1 w0.889: v4(145.14,153.45) 145.14,152.81 142.02,149.7 142.02,146.27 140.62,144.87 v4(139.35,144.87)
  vias: v1(144.43,153.38)
8693_VCORE_SW2: length 10.5
  TOP w0.508: PR20017.1 v1(151.67,144.24)
  IN1 w0.889: v4(153.32,153.45) 153.32,152.95 150.91,150.54 150.91,146.03 v4(151.34,145.6)
  vias: v1(152.56,153.38)
8693_VCORE_SW3: length 9.7
  TOP w0.508: PR20033.1 v1(160.43,144.24)
  IN1 w0.889: v4(160.23,145.6) 159.93,145.91 159.93,151.47 161.01,152.56 v4(161.01,153.45)
  vias: v1(160.31,153.38)
8693_VCORE_SW4: length 9
  TOP w0.508: v1(169.58,144.24) PR20048.1
  IN1 w0.889: v4(169.37,153.46) v4(169.37,145.6)
  vias: v1(168.56,153.38)
8693_VCORE_SYNC1: length 3.2
  TOP w0.254: PR20007.2 143.8,158.51 143.82,158.51 v1(144.25,158.08) 143.16,156.98 PU20000.4
8693_VCORE_SYNC2: length 2.7
  TOP w0.254: PR20022.2 151.29,158.28 v1(151.54,158.03) 151.54,157.62 151.16,157.24 PU20001.4
8693_VCORE_SYNC3: length 2.8
  TOP w0.254: PU20002.4 159.03,156.93 159.49,157.39 v1(159.49,157.93) 159.16,158.26 PR20037.2
8693_VCORE_SYNC4: length 2.7
  TOP w0.254: PR20052.2 167.29,158.26 v1(167.65,157.9) 167.16,157.41 PU20003.4
8693_VCORE_VTEMP1: length 1.9
  TOP w0.254: PR20006.2 145.32,155.92 v1(145.45,155.79) 145.16,155.5 PU20000.2
8693_VCORE_VTEMP2: length 1.9
  TOP w0.254: PU20001.2 153.16,155.5 v1(153.45,155.79) 153.22,156.02 PR20021.2
8693_VCORE_VTEMP3: length 1.9
  TOP w0.254: PU20002.2 161.06,155.5 v1(161.32,155.77) 161.22,155.87 PR20036.2
8693_VCORE_VTEMP4: length 2
  TOP w0.254: PR20051.2 169.25,155.92 v1(169.45,155.72) 169.24,155.5 PU20003.2
8813BOOT2:
  vias: v1(204.88,55.39)
8813DLIM: length 1.9
  BOTTOM w0.254: PU9001.12 206.3,51.01 206.11,50.81 205.23,50.81 PR9220.1
8813EN: length 7
  TOP w0.254: v1(213.9,54.42) 213.65,54.42 213.18,53.95 PD9005.2
  BOTTOM w0.254: v1(213.9,54.42) 213.9,54.42 213.51,54.03 PR9222.2 213.51,53.35 v1(212.92,52.76) PC9211.1 211.61,52.76 210.72,53.65 PU9001.3
8813ISEN1: length 5.9
  BOTTOM w0.254: PR9011.1 202.61,48.99 202.76,49.14 PR9040.1 PC9015.1 202.76,51.02 204.89,53.15 PU9001.15
8813ISEN2: length 6.9
  BOTTOM w0.254: PR9021.1 202.61,47.72 203.24,48.36 203.24,50.99 204.91,52.65 PU9001.14
8813ISEN3: length 7.8
  BOTTOM w0.254: PR9037.1 203.11,46.57 ; 203.11,46.57 203.1,46.59 PC9042.1 203.1,47.63 203.61,48.15 203.61,50.83 204.93,52.15 PU9001.13 ; 203.11,46.57 v1(203.11,46.59)
8813LGAT1: length 17.1
  IN2 w1.016: v4(213.52,66.35) v4(208.06,66.35) 207.3,65.59 207.3,58.86 208.82,57.34 v4(208.82,56.57)
  BOTTOM w0.114: v1(212.88,67.02) 212.88,66.99 v4(213.52,66.35)
8813LGAT2: length 18.3
  IN4 w1.016: v4(206.41,56.57) 200.95,62.03 200.95,65.84 v4(200.44,66.35) v4(195.23,66.35)
  BOTTOM w0.114: v4(200.44,66.35) 199.93,66.86 v1(199.93,67.02)
8813PHASE1: length 41.8
  IN3 w1.016: v4(210.22,55.56) 213.27,55.56 215.17,57.46 215.17,66.73 214.41,67.5 211.31,67.5 v4(208.36,70.44)
  IN4 w0.254: v1(201.45,47.46) 202.6,48.6 203.23,48.6 204.5,49.87 210.6,49.87 211.87,51.14 211.87,53.91 v4(210.22,55.56)
  BOTTOM w0.254: v1(201.45,47.46) 201.45,47.98 201.83,48.35 PR9011.2
  vias: v1(206.15,67.02)
8813PHASE1_RC: length 2.1
  BOTTOM w0.114: v1(200.73,68.12) PC9014.1
  BOTTOM w0.508: PC9014.1 201.63,68.59 201.56,68.67 PR9005.2
8813PHASE2: length 30.6
  TOP w0.508: v4(193.33,66.61) 193.2,66.73 PR9016.1
  IN1 w0.254: v1(201.46,46.79) 202.72,48.05 202.72,50.35 203.87,51.49 203.87,55.56 v4(202.98,56.45)
  IN1 w1.016: v4(202.98,56.45) 202.18,57.24 195.71,57.24 194.34,58.61 194.34,64.83 193.33,65.84 v4(193.33,66.61)
  BOTTOM w0.254: v1(201.46,46.79) 201.62,46.95 PR9021.2
  vias: v1(198.03,67.02)
8813PHASE2_RC: length 1.3
  TOP w0.508: PC9030.1 192.47,65.5 PR9016.2
8813PSI: length 6.2
  BOTTOM w0.254: PU9001.4 210.52,53.15 v1(210.91,52.75) 211.48,52.19 PR9212.1 211.99,51.11 213.05,51.11 PR9013.2 PR9213.2
8813PVCC: length 11.1
  IN3 w0.508: v1(207.27,56.83) 207.17,56.73 207.17,55.94 206.6,55.37 205.33,55.37 204.63,54.67 204.63,52.41 202.19,49.98 v1(202.19,49.34)
  BOTTOM w0.508: v1(202.19,49.34) 201.98,49.55 PR9040.2
  vias: v1(207.42,58.31)
8813PWM3: length 13
  TOP w0.508: v1(207.8,56.45) 207.8,56.44 PR9041.2
  IN1 w0.254: v1(207.8,56.45) 207.8,56.05 210.45,53.4 210.6,53.4 211.23,52.76 213.77,52.76 214.79,53.78 v1(214.79,54.5)
  BOTTOM w0.254: PR9029.1 215.01,54.28 v1(214.79,54.5) ; PU9001.22 v1(207.8,56.45)
8813REFADJ_R: length 4.3
  BOTTOM w0.254: PR9018.1 211.61,47.58 v1(210.98,46.95) 210.86,47.07 PR9017.1 210.85,47.82 PC9031.1 PR9015.2
8813REFIN: length 7.2
  BOTTOM w0.254: PR9018.2 PR9024.1 212.76,48.74 212.76,49.22 PC9032.1 211.88,50.1 211.15,50.1 210.77,50.48 v1(210.34,50.48) 209.07,50.48 208.8,50.75 PU9001.7
8813REFIN_R: length 1.8
  BOTTOM w0.254: PR9024.2 213.89,47.58 v1(214.03,47.72) 214.15,47.84 PR9027.1
8813RGN: length 4.7
  BOTTOM w0.254: PR9026.1 205.78,47.53 PC9034.2 205.78,49.35 PC9035.1 206.4,49.97 206.62,49.97 207.3,50.65 PU9001.10
8813TON: length 1.7
  BOTTOM w0.254: PR9004.2 207.8,49.6 PU9001.9
8813UGATE1: length 1.2
  BOTTOM w0.114: v1(213.77,55.59) 213.27,55.08 PR9003.1
8813UGATE1_1: length 8.6
  IN4 w1.016: v4(212.76,57.21) 213.14,57.21 213.77,57.84 213.77,58.99 v4(213.52,59.24) 213.27,59.49 208.95,59.49 v4(208.69,59.24)
  BOTTOM w0.114: v1(213.52,58.49) v4(213.52,59.24)
8813UGATE2:
  vias: v1(204.25,54.07)
8813UGATE2_1: length 10.8
  IN2 w1.016: v4(201.96,54.85) 201.96,58.13 200.85,59.24 v4(200.44,59.24) v4(195.61,59.24)
  BOTTOM w0.114: v1(201.96,55.59) v4(201.96,54.85)
9610BOOT3: length 3.6
  TOP w0.114: v4(216.44,51.75) v1(216.44,52.54)
  TOP w0.508: PD9002.1 215.51,50.96 215.86,50.61 PC9041.1 v4(216.44,51.75)
9610EN: length 2.5
  BOTTOM w0.114: v1(220.38,52.54) 220.34,52.5 PR9032.2
  BOTTOM w0.305: PU9002.1 218.46,52.39 218.73,52.13 219.12,52.13 PR9032.2
9610LGATE3: length 18
  IN2 w1.016: v4(226.6,66.35) v4(221.14,66.35) 220.63,65.84 220.63,61.15 218.6,59.11 218.6,56.58 v4(217.96,55.94)
  BOTTOM w0.114: v4(226.6,66.35) v1(226.6,67.15)
9610PHASE3: length 43.7
  TOP w0.508: PC9041.2 217.47,49.83 218.12,50.48 v4(218.12,51.72)
  IN4 w0.254: v1(202.62,43.65) 202.62,43.68 203.61,44.67 208.57,44.67 210.22,46.32 212,46.32 213.14,47.46 214.66,47.46 218.12,50.92 v4(218.12,51.72)
  IN4 w1.016: v4(218.12,51.72) 217.08,52.76 217.08,54.57 216.24,55.41 216.24,66.44 216.92,67.11 v4(219.49,67.11)
  BOTTOM w0.254: v1(202.62,43.65) 202.62,43.88 202.33,44.17 PR9037.2
  vias: v1(218.35,67.15)
9610PHASE3_RC: length 2.5
  BOTTOM w0.114: v1(214.15,67.15) 214.51,66.79 PR9038.2
  BOTTOM w0.508: PR9038.2 215.15,66.06 214.91,65.82 PC9045.1
9610PWM3: length 2.3
  BOTTOM w0.254: PU9002.5 216.96,55.2 216.29,55.87 v1(216.06,55.87) 215.93,55.74 PR9029.2
9610UGATE3: length 1.3
  BOTTOM w0.114: PR9030.1 216.53,50.86 v1(216.31,50.64)
9610UGATE3_1: length 15
  IN1 w1.016: v4(221.77,59.24) v4(226.6,59.24)
  IN4 w1.016: v4(221.77,59.24) 220.89,58.35 220.89,52.13 v4(219.62,50.86)
  BOTTOM w0.114: v4(219.62,50.86) 220.09,50.86 v1(220.38,51.14)
9661_1.5V_ADJ: length 5.5
  TOP w0.114: v1(99.86,33.36) PR16019.2 ; PR16019.2 PR16017.2 ; PR16019.2 100.74,32.86 101,32.6 101.5,32.6 101.89,32.21 PU16001.7
9661_1.5V_ADJ_S: length 10.6
  TOP w0.254: v1(101.63,34.69) 101.96,34.69 102.27,34.38 PR16017.1 ; v1(101.56,38.9) 104.35,38.9 105.04,38.22 PR16016.1
  BOTTOM w0.254: v1(101.56,38.9) 101.63,38.83 v1(101.63,34.69)
9661_1.5V_EN: length 4.4
  TOP w0.114: v1(101.12,23.08) 100.92,22.87 PR16015.2 101.38,22.22 101.63,22.48 PC16017.2 101.94,23.38 101.89,23.43 PU16001.2
9661_1.5V_POK: length 2.9
  TOP w0.114: PR16018.2 99.73,22.66 v1(99.73,23.33) 99.98,23.33 100.62,23.97 PU16001.1
86903C_VCCGT_CS1: length 3.6
  BOTTOM w0.114: PR21004.2 122.67,127.88 122.97,128.18 v1(123.35,128.18)
  BOTTOM w0.203: PR21004.2 122.07,127.5 122.07,126.69 121.83,126.44 PU21000.18
86903C_VCCGT_CS2: length 2.9
  BOTTOM w0.203: PR21009.2 123.22,115.82 122.71,115.31 PU21001.18
86903C_VCCGT_PWM1:
  vias: v1(119.87,126.2)
86903C_VCCGT_PWM2:
  vias: v1(120.66,113.98)
86903C_VCCGT_SW1:
  vias: v1(124.49,123.66)
86903C_VCCGT_SW2:
  vias: v1(125.38,110.96)
86903C_VCCGT_SYNC1: length 1.3
  BOTTOM w0.203: PU21000.16 121.02,126.83 PR21002.2
86903C_VCCGT_SYNC2: length 2.7
  BOTTOM w0.203: PR21007.2 v1(121.75,114.67) 121.91,114.51 PU21001.16
86903C_VCCGT_VTEMP1: length 2.4
  BOTTOM w0.203: PU21000.17 121.42,126.63 121.7,126.9 PR21001.2
86903C_VCCGT_VTEMP2: length 2.7
  BOTTOM w0.203: PU21001.17 122.31,115.44 122.46,115.58 PR21006.2
86903C_VCCSA_CS: length 1.5
  BOTTOM w0.203: PU21002.10 179.18,148.73 PR21014.2
86903C_VCCSA_PWM:
  vias: v1(178.47,150.76)
86903C_VCCSA_SW:
  vias: v1(176.05,145.89)
86903C_VCCSA_SYNC: length 1.3
  BOTTOM w0.203: PR21012.2 178.61,149.53 PU21002.8
86903C_VCCSA_VTEMP: length 1.2
  BOTTOM w0.203: PU21002.9 178.97,149.13 PR21011.2
+BAT_DIS: length 20.4
  TOP w0.508: v1(223.7,21.96) 224.31,22.57 PQ11004.3
  IN4 w0.508: v1(238.92,7.51) 238.13,8.3 236.68,8.3 236.16,8.82 229.69,8.82 227.24,11.27 v1(227.24,15.33)
  BOTTOM w0.508: PR11022.2 239.32,7.11 v1(238.92,7.51)
  vias: v1(220.38,19.65)
+BATCHG: length 46.7
  TOP w0.381: PD11003.2 v1(251.92,16.05)
  IN2 w0.381: v1(251.92,16.05) 251.92,15.09 250.98,14.16 250.98,8.85 249.84,7.71 246.92,7.71 246.46,8.17 241.13,8.17 240.38,8.92 238.35,8.92 237.75,9.51 237.17,9.51 236.86,9.21 227.26,9.21 225.58,10.89 v1(215.3,10.89)
  vias: v1(212.68,11.11)
+G_SEN_PW:
  vias: v1(190.79,18.38)
+PCH_VCCPRIM_1P8: length 4.1
  TOP w0.381: R9590.1 249.15,71.92 249.05,71.83 v1(249.05,71.67) 249.05,71.6 248.71,71.25 C12025.2
  BOTTOM w0.254: v1(249.05,71.67) 249.1,71.67 249.88,70.89 U9002.AF19 249.88,70.41 250.22,70.07 U9002.AF20
+PCH_VCCPRIM_1P8_R: length 3.2
  TOP w0.381: v1(250.4,70.61) 249.88,71.13 R9591.2 249.88,71.99 249.93,72.03 R9590.2
  BOTTOM w0.254: U9002.AG19 250.43,70.64 v1(250.4,70.61) U9002.AG20
+PSWOUT: length 11.6
  TOP w0.508: v1(275.37,10.76) 275.5,10.89 278.29,10.89 279.85,9.32 C7305.1
  BOTTOM w0.305: CON7300.10 272.5,10.05
  BOTTOM w0.508: 272.5,10.05 273.21,10.76 v1(275.37,10.76)
  vias: v1(281.06,13.3) v1(281.39,12.66) v1(281.72,13.32) v1(282.02,12.69) v1(283.75,10.89)
+PVT_VCC: length 20.9
  TOP w0.381: v1(299.57,47.63) 299.92,47.63 300.77,48.48 300.77,53.43 v1(300.51,53.68)
  BOTTOM w0.305: C6204.1 298.62,58.88 297.85,59.65 R6222.1 297.73,58.87 297.03,58.17 U6203.8
  BOTTOM w0.381: R6205.1 299.57,47.01 v1(299.57,47.63)
  BOTTOM w0.508: R6204.1 301.28,58.89 299.76,58.89 C6202.1 ; R6221.2 v1(300.51,53.68) v1(300.51,54.55) 300.51,54.83 299.37,55.97 299.37,57.88 299.75,58.26 C6202.1 ; C6202.1 C6204.1
+SD_VDD2_1.8: length 12.2
  IN3 w0.508: v1(28.76,66) 30.03,64.73 31.1,64.73 33.76,62.07 v1(35.52,62.07)
  BOTTOM w0.508: EC9020.2 EC9019.1 38,62.45 v1(37.04,62.45) 35.9,62.45 v1(35.52,62.07)
+SMDDR_VREF_CHA_DIMM_R: length 3.5
  BOTTOM w0.114: R1002.2 R1007.1 v1(137.62,24.74) 138.46,25.58 R1003.1
+SMDDR_VREF_CHB_DIMM_R:
  vias: v1(156.34,24.78)
+SPI_VCC: length 160.7
  TOP w0.254: R6510.1 293.15,45.8 v1(293.15,46.32) R6501.2 ; R6502.1 296.2,46.95 v1(295.69,46.45) ; v1(274.61,30.82) 274.07,30.29 R6001.1 ; v1(294.8,55.72) 294.8,55.84 C6500.2 ; v1(294.8,55.72) 295.05,55.47 U6500.8 ; v1(294.8,55.72) 294.29,55.21 294.29,54.83 293.28,53.82 R6514.2 ; v1(297.71,48.6) 297.55,48.76 U6500.22 ; R6503.2 297.46,57.24 296.69,56.47 R6500.2 v1(296.45,55.76)
  TOP w0.381: v1(274.61,44.29) 274.17,44.72 274.17,46.47 272.38,48.26 272.38,51.06 272.98,51.65 272.98,52.57 271.84,53.71 270.38,53.71 R409.2
  TOP w0.508: v1(308.13,47.89) 308.14,47.89 308.98,48.73 R6202.2 308.98,50.81 309.09,50.92 309.09,56.75 308.66,57.18 v1(307.75,57.18)
  IN1 w0.508: v1(279.05,28.41) 279.03,28.41 277.88,29.55 275.88,29.55 v1(274.61,30.82) ; v1(291.58,30.16) 291.47,30.16 289.33,28.02 285.24,28.02 284.02,26.8 284.02,26.44 282,24.42 278.9,24.42 v1(278.85,24.47) ; v1(308.13,47.89) 308.11,47.87 303.4,47.87 302.58,47.05 298.99,47.05 297.71,48.32 v1(297.71,48.6)
  IN2 w0.381: v1(274.61,30.82) 274.61,33.16 275.5,34.05 275.5,35.7 276.07,36.28 276.07,37.86 274.1,39.83 274.1,43.14 274.61,43.65 v1(274.61,44.29)
  IN2 w0.508: v1(291.58,30.16) 291.58,34.97 297.21,40.6 297.21,42 298.86,43.65 298.86,45.18 298.36,45.68 298.36,47.08 297.71,47.73 v1(297.71,48.6) 297.56,48.6 296.96,48.01 296.96,47.72 v1(295.69,46.45) 295.69,46.7 295.31,47.08 293.91,47.08 v1(293.15,46.32) ; v1(279.05,28.41) 279.05,27.89 278.79,27.63 278.79,24.53 v1(278.85,24.47)
  IN3 w0.254: v1(296.45,55.76) 296.95,56.25 304.22,56.25 304.86,56.89 307.46,56.89 v1(307.75,57.18)
  BOTTOM w0.254: v1(297.71,48.6) 297.71,48.54 298.14,48.11 298.56,48.11 298.58,48.12 299.78,48.12 300.07,47.83 300.07,47.4 300.39,47.08 R6201.1
  BOTTOM w0.381: C6203.1 302.22,56.43 302.02,56.23 R6215.1 303.16,55.82 304.53,57.19 307.74,57.19 v1(307.75,57.18) ; C6502.2 R6203.1 308.53,46 308.76,46.23 308.76,46.92 309.22,47.39 310.6,47.39 311.56,48.35 313.06,48.35 314.59,49.88 314.59,49.91 314.82,50.14 C6201.1 R6210.1 315.2,51.14 315.04,51.3 U6202.8 313.51,51.3 U6204.8
  BOTTOM w0.457: C6502.2 307.5,47.41 307.98,47.89 v1(308.13,47.89)
  BOTTOM w0.508: R6229.1 278.93,28.29 v1(279.05,28.41) ; v1(294.8,55.72) 296.41,55.72 v1(296.45,55.76) ; v1(278.85,24.47) 278.72,24.35 R6228.2
+SPI_VCC_14: length 5.6
  TOP w0.114: U6500.14 294.07,51.33 293.91,51.17 293.91,51.07 293.47,50.64 292.49,50.64 292.35,50.77 C6504.2 v1(291.75,51.65) 292.39,52.29 R6514.1
+TBT_SVR_IND:
  vias: v1(351.59,115.1)
+UIM_PWR: length 55.5
  TOP w0.508: R4204.2 R4212.2 v1(306.36,11.9) ; v1(311.21,13.45) 311.24,13.42 C4216.1 C4211.2 C4204.1 311.21,10.12 ESD4200.5
  IN1 w0.508: v1(306.36,11.9) 310.24,11.9 311.21,12.87 v1(311.21,13.45)
  IN3 w0.508: v1(306.36,11.9) 306.83,11.9 306.95,11.77 315.37,11.77 315.81,12.21 318.12,12.21 318.82,12.92 319.74,12.92 320.28,12.38 321.11,12.38 321.65,12.92 323.37,12.92 325.79,15.33 328.38,15.33 329.25,16.21 333.27,16.21 333.69,16.63 337.51,16.63 338.17,15.97 338.21,15.97 v1(339.2,14.98)
  BOTTOM w0.254: v1(339.2,14.98) 339.5,15.28 CON4201.36
  BOTTOM w0.508: CON4200.9 303.64,13.61 305.34,11.9 v1(306.36,11.9)
+VAC: length 187.4
  TOP w0.508: v1(343.8,145.68) 343.87,145.68 344.46,146.28 PR10010.1 PC10004.1 345.46,146.85 345.13,147.18 PR10011.1 ; PR12025.1 302.12,33.45 v1(302.27,33.59)
  IN1 w0.508: 349.97,113.45 349.97,109.79 348.1,107.91 343.95,107.91 341.04,105.01 341.04,100.37 339.88,99.21 339.88,89.63 339.12,88.86 339.12,87.85 339.76,87.21 344.01,87.21 352.08,79.15 352.08,77.81 v1(351.67,77.41) ; v4(348.57,141.95) 338.31,141.95 336.79,140.43 336.79,138.25 338.06,136.98 338.06,134.25 340.77,131.54 340.77,126.46 343.5,123.73 343.5,121.19 343.95,120.74 348.01,120.74 348.27,120.49
  IN2 w0.508: v1(355.12,51.91) 354.15,52.88 354.15,56.06 353.35,56.86 353.35,59.91 352.16,61.09 352.16,71.63 351.67,72.13 v1(351.67,77.41)
  IN3 w0.508: 348.39,42.25 348.39,42.08 345.8,39.49 344.18,39.49 343.52,38.83 343.52,38.34 342.47,37.3 338.23,37.3 335.52,34.58 332.34,34.58 331.15,33.39 331.15,32.45 330.09,31.4 330.09,29.59 329.67,29.17 328.55,29.17 327.97,28.6 322.34,28.6 321.55,29.38 310.4,29.38 307.97,31.8 305.63,31.8 304.88,32.55 303.31,32.55 v1(302.27,33.59) ; v1(355.12,51.91) 355.12,46.32 352.71,43.91 351.82,43.91
  vias: v1(349.92,140.43) v1(355.51,142.33) v4(348.6,144.24) v4(348.6,143.47) v4(348.6,142.71) v4(348.6,141.19) v4(348.6,140.43) v4(349.23,144.62) v4(349.23,143.85) v4(349.23,143.09) v4(349.23,142.33) v4(349.23,141.57) v4(349.23,140.81)
+VHIF: length 10.1
  BOTTOM w0.254: U6001.F1 265.16,26.94 264.92,26.71 264.29,26.71 263.73,27.27 262.6,27.27 262.51,27.35 C6006.1 262.51,27.8 262.28,28.03 260.68,28.03 260.44,28.28 C6003.1 259.7,28.28 259.49,28.07 R6097.2 R6098.2 v1(257.33,27.01)
+VREFCA_CHA_DIMM: length 58.6
  TOP w0.254: JDIM1000.164 156.35,55.11 156.75,54.72 158.03,54.72 158.53,54.23 158.53,52.96 158.33,52.75 v1(157.95,52.75)
  IN3 w0.508: v1(138.46,27.42) 139.12,26.76 140.88,26.76 142.95,28.83 149.8,28.83 150.78,29.81 150.78,31.21 152.31,32.73 155.48,32.73 156.37,33.62 156.37,38.06 155.99,38.44 155.99,43.14 156.88,44.03 156.88,46.95 158.66,48.73 158.66,52.05 v1(157.95,52.75)
  BOTTOM w0.254: C1048.2 C1018.2 156.85,44.87 157.21,45.23 157.21,45.61 156.35,46.46 JDIM1001.164 156.35,49.69 157.46,50.8 157.46,52.29 157.92,52.75 v1(157.95,52.75)
+VREFCA_CHB_DIMM: length 14.1
  TOP w0.254: v1(155.54,35.13) 156.12,35.71 156.12,39.06 156.35,39.3 JDIM1003.164
  BOTTOM w0.254: v1(155.73,29.3) 155.99,29.55 155.99,30.79 156.35,31.15 JDIM1002.164 156.35,33.24 156.05,33.55 156.05,34.7 155.62,35.13 v1(155.54,35.13)
  BOTTOM w0.508: v1(155.73,29.3) 154.85,28.41 154.85,27.53
+VSPI: length 5
  TOP w0.254: v1(274.66,28.64) 274.73,28.56 C6002.2 275.11,28.13 275.21,28.03 C6001.1
  BOTTOM w0.254: R6029.2 274.81,28.79 v1(274.66,28.64) 274.47,28.83 273.75,28.83 273.25,28.33 273.13,28.24 U6001.H12
A_DE: length 5.4
  TOP w0.114: U603.9 59.22,49.37 58.5,48.66 v1(58.5,48.45) 58.5,48.43 58.2,48.13 58.2,48.12 R630.1 57.17,47.08 56.06,47.08 55.64,47.5 R631.2
A_EQ1: length 4
  TOP w0.114: U603.18 64.17,49.87 64.93,49.11 v1(64.93,48.78) 64.93,48.22 R619.1 R620.2
A_EQ2: length 3
  TOP w0.114: R623.2 65.81,49.34 R622.1 64.78,50.38 U603.19
A_SD#: length 85.9
  TOP w0.114: v1(333.97,30.32) 334.04,30.32 335.25,29.11 335.25,27.23 334.68,26.66 334.68,24.35 334.45,24.12 334.45,23.26 334.63,23.08 334.63,19.5 333.53,18.4 333.53,17.16 332.58,16.2 D3600.1 332.23,15.61 332.38,15.46 R3620.2
  IN3 w0.089: v1(271.96,35.27) 272.36,35.66 282.09,35.66 283.3,34.45 296.54,34.45 298.87,32.12 300.86,32.12 302.14,30.84 303.97,30.84 304.9,29.91 307.47,29.91 309.75,27.62 319.94,27.62 320.78,26.79 328.97,26.79 332.26,30.07 333.72,30.07 v1(333.97,30.32)
  BOTTOM w0.114: R6008.2 271.56,34.75 271.96,35.15 v1(271.96,35.27)
AC_DC#_ALERT: length 119.2
  IN4 w0.076: v1(227.82,77.05) 228.35,77.05 229,77.7 230.02,77.7 230.36,77.36 230.36,76.27 228.86,74.77 228.86,72.56 228.59,72.29 228.59,55.23 227.22,53.86 227.22,53.06 228,52.29 228,51.4 228.63,50.76 228.63,34.36 227.21,32.93 224.95,32.93 223.78,31.76 223.78,29.96 224.42,29.33 253.36,29.33 254.73,27.95 255.67,27.95 255.81,28.09 257.87,28.09 258.72,28.95 261.83,28.95 262.41,29.53 264.35,29.53 265.62,30.8 265.62,32.24 266.39,33.01 267.84,33.01 270.52,30.32 270.52,29.64 270.19,29.31 v3(270.19,29.22)
  BOTTOM w0.076: U6001.J8 v3(270.19,29.22)
  BOTTOM w0.114: v1(227.82,77.05) 227.62,76.85 225.99,76.85 223.96,78.88 223.32,78.88 222.49,79.72 221.9,79.72 221.41,80.21 R17879.2 R2142.2
AC_GATE: length 25.5
  TOP w0.508: v1(346.97,146.09) 346.54,146.52 PC10004.2 346.24,147.16 PR10011.2 ; v1(348.06,145.53) 347.54,145.01 PQ10007.4 ; v1(342.81,150.46) 342.81,148.6 342.55,148.34 v1(342.55,147.41) 342.69,147.28 PR10016.1
  IN4 w0.508: v1(342.81,150.46) 342.81,150.03 346.72,146.12 346.95,146.12 v1(346.97,146.09) 347.5,146.09 v1(348.06,145.53) 346.96,144.43 346.96,142.5 v1(344.66,140.2)
  BOTTOM w0.381: PQ10009.3 346.87,146.85 346.87,146.19 v1(346.97,146.09)
  BOTTOM w0.508: v1(344.66,140.2) 344.16,140.69 PQ10006.4
ACCEL_CLK: length 9.1
  TOP w0.114: Q9032.1 194.53,19.84 194.06,19.37 R6090.1 194.06,18.73 v1(193.45,18.12) 193.05,17.72 188.98,17.72 188.28,18.42 U9500.1
ACCEL_DATA: length 6.8
  TOP w0.114: U9500.4 190.13,19.27 190.38,19.52 190.38,22.21 190.74,22.57 v1(191.8,22.57) R6091.1 192.59,21.97 192.63,21.93 Q9032.4
ACCEL_INT#: length 169.9
  TOP w0.114: v1(195.98,22.58) 195.98,19.25 194.22,17.49 188.88,17.49 187.94,18.43 187.94,19.67 188.05,19.78 U9500.12 ; v1(254.7,74.56) 255.57,75.44 255.57,75.73 255.94,76.09 255.94,76.25 256.5,76.81 256.5,77.41 255.81,78.09 255.81,79.49 257.21,80.89 257.21,81.2 257.68,81.67 258.13,81.67 258.93,82.47 258.93,82.82 258.45,83.3 258.45,83.53 259.07,84.14 R9224.1
  IN1 w0.076: v1(253.84,25.78) 253.32,25.26 252.47,25.26 249.46,28.27 233.2,28.27 229.23,24.3 219.74,24.3 214.2,18.76 205.51,18.76 201.92,22.34 198.1,22.34 197.86,22.58 v1(195.98,22.58)
  IN2 w0.089: v1(254.7,74.56) 256.12,75.99 256.83,75.99 258.01,74.8 259.91,74.8 266.95,67.76 266.95,66.38 266.3,65.73 266.3,65.29 265.27,64.26 265.27,59.72 256.19,50.64 v1(256.19,46.32)
  BOTTOM w0.114: v1(253.84,25.78) 253.84,26.27 252.35,27.76 252.35,30.39 249.98,32.76 249.6,33.14 249.6,33.66 249.33,33.93 249.33,34.89 248.15,36.08 244.88,36.08 244.34,36.61 244.34,38.21 243.4,39.16 243.4,39.62 245.87,42.1 246.82,42.1 249.36,44.64 249.83,44.64 250.37,45.18 255.05,45.18 v1(256.19,46.32) ; U9002.AW21 254.82,74.68 v1(254.7,74.56)
ACE_I2C_SCL2: length 135.2
  TOP w0.114: v1(343.06,91.91) 342.43,91.91 340.75,90.24 339.96,90.24 339.4,89.68 TP8523.1 339.4,89.17 334.93,84.7 334.93,80.61 335.11,80.43 335.11,78.12 334.32,77.33 334.32,72.85 333.74,72.28 333.74,71.77 334.29,71.22 334.29,70.58 334.75,70.11 334.75,68.73 333.71,67.68 333.71,65.67 333.14,65.11 333.14,60.43 332.49,59.78 332.49,57.35 332.59,57.25 332.59,53.79 331.63,52.83 331.63,50.18 332.62,49.19 332.62,47.82 334.23,46.21 334.23,37.03 333.97,36.77 333,36.77 331.16,34.93 331.16,31.3 327.91,28.05 327.91,26.69 327.01,25.79 v1(327.01,24.86) ; v1(283.12,23.59) 283.12,25.62 283.5,26 283.5,26.76 282.76,27.5 278.58,27.5 R6011.2
  IN4 w0.076: v1(327.01,24.86) 326.93,24.78 324.46,24.78 323.83,24.14 320.51,24.14 319.41,25.24 316.13,25.24 315.68,24.78 305.54,24.78 303,27.32 300.72,27.32 300.36,26.96 291.18,26.96 290.87,26.66 289.52,26.66 288.83,25.97 286.34,25.97 285.76,25.39 285.51,25.39 285.29,25.17 285.29,25.02 283.85,23.59 v1(283.12,23.59)
  BOTTOM w0.114: U8500.L6 342.93,92.04 v1(343.06,91.91)
ACE_I2C_SDA2: length 135.5
  TOP w0.114: v1(343.06,91.28) 342.46,91.28 340.95,89.77 340.94,89.77 TP8522.1 340.44,89.27 340.16,89.27 335.4,84.51 335.4,80.8 335.58,80.63 335.58,77.92 334.78,77.13 334.78,72.65 334.76,72.63 334.76,70.77 335.22,70.31 335.22,68.53 334.68,67.99 334.68,65.98 333.76,65.06 333.76,60.64 333.89,60.52 333.89,57.44 333.06,56.6 333.06,53.59 332.1,52.63 332.1,50.37 333.09,49.38 333.09,48.01 334.25,46.85 334.7,46.41 334.7,36.09 334.11,35.5 332.98,35.5 331.63,34.15 331.63,31.1 328.38,27.85 328.38,26.5 327.69,25.81 v1(327.69,24.86) ; R6000.2 279.69,26.51 280.07,26.89 281.89,26.89 282.15,26.63 282.15,24.93 282.61,24.47 v1(282.61,23.2)
  IN4 w0.076: v1(327.69,24.86) 327.18,24.35 324.64,24.35 324.01,23.71 320.33,23.71 319.23,24.81 316.31,24.81 315.86,24.35 305.37,24.35 302.83,26.89 300.9,26.89 300.53,26.53 291.35,26.53 290.44,25.62 289.8,25.62 289.69,25.72 289.21,25.72 289.03,25.54 286.59,25.54 286.15,25.1 286.15,24.74 285.84,24.42 285.35,24.42 284,23.08 282.73,23.08 v1(282.61,23.2)
  BOTTOM w0.076: v1(343.06,91.28) 342.68,91.66 342.68,92.83 U8500.K6
ACZ_BCLK: length 13.5
  BOTTOM w0.089: 254.27,81.01 253.72,80.47 253.72,80.28 253.78,80.23 253.78,80.08 253.59,79.9 U9002.BD11
  BOTTOM w0.114: 254.27,81.01 254.47,81.21 254.47,81.21 255.08,81.82 255.08,84.67 253.78,85.97 253.78,87.01 v1(253.65,87.14) 253.36,87.42 253.02,87.42 C9186.1 R9603.1 251.97,89.32 251.97,90.05 252.25,90.33 R9080.2
ACZ_RST#: length 15.3
  BOTTOM w0.089: 254.2,81.24 253.48,80.53 U9002.BE10
  BOTTOM w0.102: 253.72,85.72 254.87,84.57 254.87,81.92 254.2,81.24
  BOTTOM w0.114: 253.72,85.72 253.4,86.04 253.4,86.4 252.33,87.47 252.25,87.47 251.66,88.06 251.66,90.22 251.24,90.64 250.87,90.64 R9604.1 250.61,91.59 v1(250.78,91.76) 251.12,92.1 R9081.2
ACZ_RST#_AUDIO: length 179.4
  TOP w0.114: v1(333,17.39) 332.89,17.5 D3600.2 ; v1(344.2,61.43) 343.36,60.59 343.36,56.39 343.97,55.78 343.97,52.23 342.42,50.69 342.42,50 343,49.43 343,47.89 341.38,46.28 341.38,35.52 341.84,35.07 341.84,31.23 342.14,30.93 343.62,30.93 344.31,30.25 344.31,29.43 344.11,29.23 v1(344.11,28.28) 344.11,24.37 v1(343.66,23.93) 344,23.6 344,21.23 343.66,20.9 343.66,18.22 343.31,17.87 343.31,16.62 C3600.2 342.75,15.05 342.42,15.05 342.03,14.65 U3600.2
  IN1 w0.076: v1(333,17.39) 333,17.79 335.68,20.47 336.26,20.47 339.12,23.33 339.99,23.33 340.48,23.82 340.48,24.18 340.65,24.35 343.24,24.35 v1(343.66,23.93) ; v1(253.31,91.73) 257.77,91.73 260.86,88.64 260.86,87.54 266.29,82.12 266.69,82.12 270.8,78.02 270.8,77.69 270.78,77.68 270.78,77.39 270.98,77.19 271.04,77.19 272.73,75.5 273.66,75.5 275.47,73.7 276.45,73.7 280.21,69.94 281.49,69.94 282.73,68.7 283.09,68.7 284.59,67.2 286.62,67.2 291.51,62.31 292.72,62.31 293.91,61.13 297.11,61.13 297.29,61.3 299.37,61.3 300.29,60.39 302.26,60.39 303.27,61.4 309.68,61.4 309.91,61.64 309.91,61.65 311.73,61.65 312.03,61.95 314.73,61.95 316.24,63.46 318.91,63.46 320.43,61.94 322.97,61.94 323.53,61.38 328.95,61.38 329.36,60.97 331.02,60.97 331.18,60.82 335.21,60.82 335.49,60.53 343.3,60.53 v1(344.2,61.43)
  BOTTOM w0.114: v1(253.31,91.73) 253.24,91.73 252.69,92.28 252.16,92.28 251.12,93.32 R9081.1
ACZ_SDIN0: length 157.6
  TOP w0.114: R3605.1 v1(344.84,17.74) 344.98,17.89 344.98,26.78 346.49,28.28 346.49,39.84 346.72,40.07 346.72,41.32 346.06,41.98 346.06,44.48 345.27,45.26 345.27,47.16 344.4,48.02 344.4,51.48 345.35,52.42 345.35,55.59 344.2,56.73 344.2,58.13 344.46,58.38 v1(345.47,58.38)
  IN1 w0.076: v1(251.24,91.15) 251.82,90.57 251.82,89.78 252.48,89.12 254.39,89.12 254.51,88.99 257.56,88.99 257.85,88.7 257.85,88.17 259.71,86.31 259.95,86.31 269.82,76.44 269.99,76.44 270.62,75.82 270.62,74.92 271.41,74.13 273.02,74.13 274.89,72.27 275.87,72.27 280.33,67.81 281.08,67.81 283.41,65.48 285.97,65.48 289.97,61.48 289.97,61.32 291.24,60.06 292.34,60.06 292.77,59.63 296.42,59.63 297.42,58.64 305.84,58.64 306.82,59.62 315.21,59.62 316.01,60.42 316.77,60.42 317.66,59.53 328.14,59.53 329,58.66 332.29,58.66 332.98,57.98 334.59,57.98 335.2,57.37 337.85,57.37 338.43,57.95 342.28,57.95 342.82,58.5 345.36,58.5 v1(345.47,58.38)
  BOTTOM w0.114: v1(251.24,91.15) 251.62,91.53 R9083.1
ACZ_SDIN0_R: length 13.5
  BOTTOM w0.114: U9002.BE11 254.25,80.17 254.25,80.63 255.3,81.67 255.3,84.77 254.21,85.86 254.21,88.05 v1(253.83,88.43) 253.48,88.78 253.48,90.84 252.78,91.53 R9083.2
ACZ_SDO: length 16.3
  TOP w0.114: v1(255.02,89.78) 254.92,89.88 253.65,89.88 253,89.22 253,88.46 252.81,88.28 Q9007.3
  BOTTOM w0.102: U9002.BF12 254.92,80.14 254.92,80.69 255.71,81.49 255.71,81.53
  BOTTOM w0.114: 255.71,81.53 255.71,84.95 255.12,85.54 255.12,86.32 255.55,86.75 255.55,88.34 255.82,88.61 R9086.1 255.11,89.78 v1(255.02,89.78) 254.45,89.78 R9084.2
ACZ_SDOUT_AUDIO: length 156.7
  TOP w0.114: v1(344.41,59.79) 343.78,59.17 343.78,56.56 344.39,55.96 344.39,52.06 343.98,51.65 343.98,48.06 342.63,46.7 342.63,32.52 344.73,30.42 344.73,28.81 344.56,28.65 344.56,18.23 344.33,17.99 344.33,15.97 342.93,14.57 342.68,14.57 342.43,14.32 U3600.1
  IN1 w0.076: v1(253.91,90.87) 254.11,91.07 257.84,91.07 259.57,89.35 259.57,88.08 260.26,87.39 260.36,87.39 270.03,77.71 270.14,77.71 270.67,77.19 270.67,77.03 272.52,75.17 273.53,75.17 275.34,73.36 276.32,73.36 280.6,69.08 281.44,69.08 283.74,66.78 286.5,66.78 291.38,61.9 292.6,61.9 293.73,60.77 297.19,60.77 298.02,59.93 302.42,59.93 303.5,61.02 309.87,61.02 310.1,61.25 311.96,61.25 312.26,61.55 314.87,61.55 315.46,62.14 318.01,62.14 318.27,62.4 319.44,62.4 320.28,61.56 322.79,61.56 323.35,61 328.8,61 329.84,59.96 331.87,59.96 332.27,60.35 334.93,60.35 335.17,60.11 339.81,60.11 340.12,59.79 v1(344.41,59.79)
  BOTTOM w0.114: R9084.1 254.02,90.75 v1(253.91,90.87)

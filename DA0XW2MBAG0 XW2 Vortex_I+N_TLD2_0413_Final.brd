# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_RXN6_C: length 11.4
  TOP w0.095: v1(204.87,113.13) 204.87,113.19 204.31,113.75 203.78,113.75 203.43,113.39 201.89,113.39 201.49,113 199.92,113 199.62,112.7 197.43,112.7 196.77,112.03 195.37,112.03 C2102.2
  BOTTOM w0.102: U2000.AJ18 204.53,112.79 v1(204.87,113.13)
PEG_RXN7: length 68.1
  TOP w0.095: v1(177.12,111.4) 177.12,112.04 177.36,112.28 178.89,112.28 179.28,112.66 179.61,112.66 180.01,112.26 180.01,111.71 179.56,111.26 179.56,110.82 179.71,110.67 186,110.67 186.09,110.76 186.09,111.06 186,111.15 180.72,111.15 180.49,111.37 180.49,111.8 180.73,112.04 186,112.04 186.11,112.15 186.11,112.41 186,112.52 180.75,112.52 180.55,112.72 180.55,113.15 180.81,113.41 184.97,113.41 185.07,113.51 185.07,113.8 184.98,113.89 181.34,113.89 181.11,114.12 181.11,114.5 181.76,115.15 182.28,115.15 182.65,114.78 186.1,114.78 186.34,114.54 186.34,114.19 185.96,113.81 185.96,113.51 186.03,113.44 187.7,113.44 188.09,113.04 189.54,113.04 189.64,113.15 189.64,113.43 189.54,113.53 188.32,113.53 187.99,113.86 187.99,114.22 188.19,114.42 188.77,114.42 188.88,114.53 188.88,114.67 188.65,114.9 188.09,114.9 187.79,115.2 187.79,115.98 188.05,116.25 188.57,116.25 189.23,115.58 189.47,115.58 189.8,115.25 189.8,114.51 189.89,114.42 190.28,114.42 190.53,114.16 190.53,113.19 190.79,112.94 195.62,112.94 C2089.1
  BOTTOM w0.114: U9001.E17 176.79,111.72 v1(177.12,111.4)
PEG_RXN7_C: length 8.3
  TOP w0.095: v1(203.29,113.87) 203.06,113.87 202.62,114.31 201.89,114.31 201.42,113.84 199.81,113.84 199.45,113.48 197.36,113.48 196.9,113.03 196.53,113.03 C2089.2
  BOTTOM w0.102: v1(203.29,113.87) 203.29,113.84 U2000.AK19
PEG_RXN8: length 65.8
  TOP w0.095: C2189.1 193.95,113.64 193.5,113.64 193.26,113.88 193.26,114.31 193.16,114.42 192.86,114.42 192.75,114.31 192.75,114.04 192.55,113.84 191.92,113.84 v1(191.68,113.6)
  IN4 w0.076: v1(191.68,113.6) 191.46,113.81 190.84,113.81 190.27,113.24 188.24,113.24 188.11,113.1 188.11,112.86 188.19,112.78 190.47,112.78 190.67,112.58 190.67,112.2 190.46,111.99 188.02,111.99 187.94,111.91 187.94,111.58 187.99,111.53 189.88,111.53 190.11,111.3 190.11,110.98 189.88,110.75 188.05,110.75 187.97,110.66 187.97,110.35 188.02,110.29 189.65,110.29 189.88,110.06 189.88,109.73 189.65,109.5 187.84,109.5 187.74,109.4 187.74,109.15 187.84,109.04 189.38,109.04 189.58,108.85 189.58,108.45 189.38,108.26 188.04,108.26 187.95,108.17 187.95,107.86 188.01,107.8 188.79,107.8 188.98,107.61 188.98,107.3 188.7,107.01 188.04,107.01 187.95,106.93 187.95,105.41 187.62,105.08 186.53,105.08 186.19,105.42 186.19,106.03 185.78,106.44 182.73,106.44 182.52,106.66 182.52,106.96 182.73,107.18 186.25,107.18 186.37,107.3 186.37,107.46 186.25,107.58 182.34,107.58 181.95,107.96 181.15,107.96 179.83,109.29 179.83,110.7 179.41,111.12 179.41,111.61 179.58,111.78 179.85,111.78 179.93,111.85 179.93,112.16 179.85,112.24 179.58,112.24 179.41,112.41 179.41,112.9 179.27,113.03 179.08,113.03 178.95,112.9 178.95,111.1 178.78,110.93 178.33,110.93 178.16,111.1 178.16,113.04 178.08,113.12 177.79,113.12 177.71,113.04 177.71,111.98 177.53,111.81 177.06,111.81 176.92,111.95 176.92,112.28 176.87,112.32 176.24,112.32 176.01,112.55 176.01,112.78 v1(175.82,112.97)
  BOTTOM w0.127: U9001.F18 175.82,112.9 v1(175.82,112.97)
PEG_RXN8_C: length 10.8
  TOP w0.095: C2189.2 194.85,113.5 195.18,113.5 195.38,113.71 196.34,113.71 197.01,114.37 201.13,114.37 201.4,114.64 202.71,114.64 203.06,114.29 203.72,114.29 v1(204.13,114.7)
  BOTTOM w0.102: v1(204.13,114.7) 204.13,114.7 U2000.AJ20
PEG_RXN9: length 65.4
  TOP w0.095: C2191.1 195.51,114.93 195.36,114.77 194.98,114.77 194.53,115.22 190.5,115.22 190.41,115.31 190.41,115.97 190.17,116.2 189.47,116.2 189.36,116.31 189.36,116.59 189.47,116.69 189.95,116.69 190.21,116.95 190.21,117.32 189.95,117.58 189.47,117.58 189.36,117.68 189.36,117.96 189.47,118.06 189.75,118.06 190.01,118.32 190.01,118.69 189.75,118.95 189.47,118.95 189.36,119.05 189.36,121.45 189.1,121.71 188.73,121.71 188.47,121.45 188.47,116.98 188.35,116.85 188.12,116.85 187.99,116.98 187.99,121.79 188.8,122.59 188.94,122.59 189.3,122.23 189.61,122.23 189.93,122.55 189.93,122.86 189.57,123.22 189.57,123.37 189.65,123.45 189.65,123.82 189.39,124.08 189.02,124.08 187.03,122.09 186.68,122.09 186.5,122.27 185.76,122.27 185.55,122.06 185.55,121.56 185.75,121.36 185.99,121.36 186.1,121.24 186.1,120.99 185.99,120.88 185.81,120.88 185.55,120.62 185.55,120.2 185.76,119.99 186.02,119.99 186.11,119.9 186.11,119.6 186.02,119.51 185.33,119.51 185.07,119.25 185.07,118.88 185.33,118.62 185.99,118.62 186.13,118.48 186.13,118.28 185.99,118.13 184.93,118.13 184.56,117.77 184.56,117.44 184.76,117.25 185.96,117.25 186.1,117.1 186.1,116.9 185.96,116.76 184.5,116.76 184.21,117.06 183.85,117.06 183.38,116.58 183.38,116.13 183.64,115.87 185.96,115.87 186.09,115.75 186.09,115.52 185.96,115.39 182.93,115.39 182.76,115.56 182.76,116.5 182.53,116.73 182.13,116.73 181.87,116.47 181.87,116.15 180.5,114.78 180.5,114.04 180.25,113.79 179.14,113.79 178.79,113.44 178.79,113.07 178.68,112.96 178.01,112.96 177.51,113.46 177.51,113.61 177.66,113.76 v1(177.77,113.76)
  BOTTOM w0.114: v1(177.77,113.76) 177.77,113.59 177.54,113.37 U9001.D19
PEG_RXN9_C: length 11
  TOP w0.095: v1(205.78,114.7) 205.56,114.7 204.99,115.27 204.58,115.27 204.43,115.42 204,115.42 203.88,115.54 201.1,115.54 200.76,115.2 196.66,115.2 196.42,114.95 196.14,114.95 C2191.2
  BOTTOM w0.102: U2000.AG20 v1(205.78,114.7)
PEG_RXN10: length 66.7
  TOP w0.095: v1(191.68,115.88) 191.92,116.12 192.36,116.12 192.63,116.39 192.63,116.56 192.78,116.71 192.99,116.71 193.14,116.56 193.14,115.89 193.39,115.64 193.75,115.64 194,115.89 194,116.24 194.12,116.36 194.41,116.36 194.64,116.12 195.4,116.12 C2193.1
  IN4 w0.076: v1(191.68,115.88) 191.47,116.09 190.81,116.09 190.66,115.93 190.66,115.27 190.41,115.03 188.1,115.03 187.99,114.92 187.99,114.65 188.08,114.57 190.04,114.57 190.27,114.34 190.27,114.01 190.04,113.78 188.02,113.78 187.48,113.25 186.7,113.25 186.33,112.87 186.33,111.76 186.57,111.52 186.57,111.06 186.33,110.82 186.33,109.81 186.01,109.49 185.74,109.49 185.67,109.41 185.67,108.31 185.49,108.13 185.04,108.13 184.88,108.28 184.88,109.41 184.81,109.49 184.5,109.49 184.42,109.41 184.42,108.31 184.24,108.13 183.82,108.13 183.64,108.31 183.64,109.41 183.56,109.49 183.26,109.49 183.18,109.41 183.18,108.28 183.03,108.13 182.57,108.13 182.39,108.31 182.39,109.41 182.32,109.49 182.01,109.49 181.93,109.41 181.93,108.74 181.7,108.51 181.38,108.51 181.15,108.74 181.15,109.41 181.07,109.49 180.92,109.49 180.72,109.69 180.72,110.1 180.89,110.28 185.41,110.28 185.54,110.41 185.54,110.6 185.41,110.73 180.69,110.73 180.49,110.93 180.49,111.32 180.69,111.52 185.46,111.52 185.54,111.6 185.54,111.91 185.47,111.98 180.63,111.98 180.48,112.13 180.48,112.44 180.88,112.85 180.88,113.75 180.75,113.88 180.56,113.88 180.42,113.75 180.42,113.44 180.19,113.21 179.87,113.21 179.64,113.44 179.64,113.75 179.45,113.93 178.86,113.93 178.6,114.19 177.95,114.19 177.78,114.37 177.78,114.73 177.7,114.8 177.4,114.8 177.32,114.73 177.32,114.37 177.15,114.19 176.9,114.19 v1(176.47,113.76)
  BOTTOM w0.127: v1(176.47,113.76) 176.47,113.83 U9001.F20
PEG_RXN10_C: length 9.7
  TOP w0.095: C2193.2 196.32,116.11 200.94,116.11 201.31,115.74 203.99,115.74 204.07,115.67 204.5,115.67 204.52,115.69 v1(204.82,115.69)
  BOTTOM w0.102: v1(204.82,115.69) 204.53,115.4 U2000.AJ21
PEG_RXN11: length 66.8
  TOP w0.095: v1(177.77,115.34) 177.71,115.34 177.32,114.94 177.32,114.83 177.41,114.74 178.66,114.74 179.33,115.41 180.27,115.41 180.52,115.66 180.52,116.1 181.76,117.34 183.27,117.34 184.46,118.53 184.46,119.88 184.94,120.36 184.94,122.55 185.27,122.88 186.95,122.88 188.37,124.31 188.37,125.19 185.78,127.77 185.78,128.16 186.19,128.56 186.57,128.56 187.48,127.66 187.79,127.66 188.29,128.17 188.85,128.17 189.39,127.63 189.39,127.09 188.94,126.65 188.94,126.19 189.49,125.64 189.92,125.64 190.14,125.42 190.14,124.34 190.26,124.22 190.51,124.22 190.62,124.34 190.62,125.42 190.85,125.64 191.25,125.64 191.35,125.74 191.35,126.53 191.61,126.79 191.98,126.79 192.24,126.53 192.24,125.74 192.34,125.64 192.62,125.64 192.73,125.74 192.73,126.53 192.99,126.79 193.35,126.79 193.61,126.53 193.61,125.74 193.72,125.64 194,125.64 194.1,125.74 194.1,126.53 194.36,126.79 194.73,126.79 194.99,126.53 194.99,125.74 195.09,125.64 195.37,125.64 195.47,125.74 195.47,126.53 195.73,126.79 196.1,126.79 196.36,126.53 196.36,125.74 196.46,125.64 196.79,125.64 197.03,125.4 197.03,124.97 196.74,124.68 192.09,124.68 191.88,124.47 191.88,122.82 191.42,122.37 190.66,122.37 190,121.71 190,119.81 190.62,119.19 190.62,117.77 190.88,117.51 192.2,117.51 192.3,117.61 192.3,117.8 192.52,118.02 192.97,118.02 193.19,117.8 193.19,117.61 193.29,117.51 194.09,117.51 C2195.1
  BOTTOM w0.127: U9001.D21 177.64,114.94 177.77,115.06 v1(177.77,115.34)
PEG_RXN11_C: length 9.6
  TOP w0.095: v1(203.28,116.35) 203.08,116.35 202.42,117.01 197.72,117.01 197.11,117.62 194.99,117.62 C2195.2
  BOTTOM w0.102: v1(203.28,116.35) 203.28,116.35 U2000.AK22
PEG_RXN12: length 65.2
  TOP w0.095: v1(191.68,118.17) 191.94,118.44 192.39,118.44 192.63,118.67 192.63,119.1 192.78,119.26 193.15,119.26 193.56,118.84 193.82,118.84 C2197.1
  IN4 w0.076: v1(191.68,118.17) 191.52,118.32 190.78,118.32 190.53,118.07 190.53,117.06 190.11,116.64 190.11,115.79 189.9,115.57 188.01,115.57 187.78,115.8 187.78,116.13 188.01,116.36 189.18,116.36 189.31,116.49 189.31,116.68 189.18,116.82 188.01,116.82 187.78,117.05 187.78,117.37 188.01,117.6 189.61,117.6 189.74,117.74 189.74,117.93 189.61,118.06 187.99,118.06 187.74,118.31 187.74,118.7 187.89,118.85 190.27,118.85 190.41,118.98 190.41,119.17 190.27,119.31 186.43,119.31 186.26,119.14 186.26,117.01 186.02,116.77 185.33,116.77 185.2,116.63 185.2,116.44 185.33,116.31 186.07,116.31 186.26,116.12 186.26,115.32 185.95,115 185.95,113.27 185.72,113.04 185.39,113.04 185.16,113.27 185.16,115.43 185.05,115.53 184.81,115.53 184.7,115.43 184.7,112.7 184.52,112.52 184.09,112.52 183.92,112.7 183.92,115.39 183.81,115.5 183.57,115.5 183.46,115.39 183.46,112.7 183.28,112.52 182.85,112.52 182.67,112.7 182.67,115.2 182.54,115.33 182.35,115.33 182.21,115.2 182.21,112.7 182.04,112.52 181.6,112.52 181.43,112.7 181.43,115.15 181.29,115.28 181.1,115.28 180.97,115.15 180.97,114.74 180.74,114.51 180.41,114.51 180.18,114.74 180.18,115.15 180.05,115.28 179.86,115.28 179.72,115.15 179.72,114.73 179.48,114.48 179.19,114.48 178.94,114.73 178.94,115.36 178.53,115.77 176.9,115.77 v1(176.47,115.34)
  BOTTOM w0.127: v1(176.47,115.34) 176.47,115.4 U9001.F22
PEG_RXN12_C: length 11.2
  TOP w0.095: v1(204.13,117.2) 203.7,116.78 203.12,116.78 202.63,117.28 201.21,117.28 200.45,118.04 195.77,118.04 195.09,118.72 194.74,118.72 C2197.2
  BOTTOM w0.102: U2000.AJ23 v1(204.13,117.2)
PEG_RXN13: length 65.5
  TOP w0.095: v1(177.77,116.91) 177.72,116.91 177.32,116.52 177.32,116.3 177.41,116.21 178.35,116.21 179.02,116.88 180.34,116.88 181.42,117.95 183.03,117.95 183.85,118.78 183.85,120.17 184.33,120.65 184.33,123.18 184.65,123.49 186.7,123.49 187.32,124.11 187.32,125.07 185.09,127.3 183.34,127.3 183.04,127.6 183.04,128.74 183.47,129.17 188.71,129.17 190.1,127.78 190.1,127.27 190.48,126.89 190.83,126.89 191.34,127.4 191.75,127.4 191.85,127.5 191.85,127.84 192.08,128.06 192.52,128.06 192.74,127.84 192.74,127.5 192.85,127.4 193.12,127.4 193.23,127.5 193.23,127.84 193.45,128.06 193.89,128.06 194.12,127.84 194.12,127.5 194.22,127.4 194.5,127.4 194.6,127.5 194.6,127.84 194.82,128.06 195.27,128.06 195.49,127.84 195.49,127.5 195.59,127.4 196.37,127.4 197.64,126.13 197.64,124.3 197.36,124.02 194.34,124.02 194.24,123.92 194.24,122.49 194.02,122.26 193.45,122.26 193.23,122.49 193.23,123.92 193.12,124.02 192.72,124.02 192.56,123.87 192.56,122.39 191.91,121.74 190.89,121.74 190.61,121.45 190.61,120.06 190.88,119.79 191.67,119.79 191.93,120.06 194.94,120.06 195.58,119.42 195.75,119.42 C2199.1
  BOTTOM w0.114: v1(177.77,116.91) 177.77,116.61 177.67,116.51 U9001.D23
PEG_RXN13_C: length 10.9
  TOP w0.095: C2199.2 196.78,119.38 197.06,119.38 197.58,118.87 200.86,118.87 201.7,118.03 204.18,118.03 204.56,117.64 205.16,117.64 205.61,117.2 v1(205.78,117.2)
  BOTTOM w0.102: U2000.AG23 v1(205.78,117.2)
PEG_RXN14: length 65.2
  TOP w0.095: C2201.1 195.37,120.72 194.92,120.72 194.66,120.99 194.66,121.49 194.51,121.64 194.3,121.64 194.15,121.49 194.15,120.93 193.9,120.68 193.54,120.68 193.29,120.93 193.29,121.49 193.14,121.64 192.93,121.64 192.78,121.49 192.78,120.99 192.49,120.7 191.89,120.7 v1(191.68,120.48)
  IN4 w0.076: v1(176.47,116.91) 176.91,117.35 177.36,117.35 177.48,117.47 178.84,117.47 178.98,117.33 178.98,116.12 179.21,115.89 179.55,115.89 179.79,116.12 179.79,118.3 179.94,118.45 180.47,118.45 180.63,118.3 180.63,116.06 180.86,115.83 181.18,115.83 181.41,116.06 181.41,118.3 181.57,118.45 181.72,118.45 181.87,118.3 181.87,116.11 182.1,115.88 182.43,115.88 182.66,116.11 182.66,118.67 182.79,118.8 182.98,118.8 183.12,118.67 183.12,116.22 183.29,116.04 184.36,116.04 184.59,116.27 184.59,116.6 184.36,116.83 184.07,116.83 183.93,116.97 183.93,117.17 184.07,117.31 185.49,117.31 185.72,117.54 185.72,117.87 185.49,118.1 184.06,118.1 183.93,118.23 183.93,118.42 184.06,118.56 185.49,118.56 185.72,118.79 185.72,119.11 185.49,119.34 184.06,119.34 183.9,119.5 183.9,119.63 184.08,119.8 184.57,119.8 184.85,120.08 184.85,121.92 184.99,122.06 185.19,122.06 185.33,121.92 185.33,120.02 185.56,119.79 185.88,119.79 186.11,120.02 186.11,121.93 186.25,122.06 186.44,122.06 186.57,121.93 186.57,121.48 186.8,121.25 187.13,121.25 187.36,121.48 187.36,121.93 187.49,122.06 187.68,122.06 187.81,121.93 187.81,120.08 188.04,119.85 188.37,119.85 188.6,120.08 188.6,121.78 188.73,121.91 188.92,121.91 189.06,121.77 189.06,121.27 189.24,121.1 189.78,121.1 189.92,120.96 189.92,120.77 189.78,120.64 189.29,120.64 189.06,120.41 189.06,120.08 189.29,119.85 190.49,119.85 190.7,120.06 190.7,120.56 190.85,120.71 191.45,120.71 v1(191.68,120.48)
  BOTTOM w0.127: U9001.F24 176.47,116.98 v1(176.47,116.91)
PEG_RXN14_C: length 11.2
  TOP w0.095: v1(204.96,118.05) 204.54,118.05 204.33,118.26 202.09,118.26 200.58,119.76 197.97,119.76 197.12,120.61 196.25,120.61 C2201.2
  BOTTOM w0.102: U2000.AJ24 204.34,117.79 204.34,117.98 204.49,118.13 204.88,118.13 v1(204.96,118.05)
PEG_RXN15: length 66.4
  TOP w0.095: v1(177.77,118.49) 177.71,118.49 177.32,118.1 177.32,117.86 177.51,117.67 178.64,117.67 178.87,117.9 178.87,118.35 179.09,118.56 179.66,118.56 179.89,118.34 179.89,118.12 179.99,118.02 180.27,118.02 180.37,118.12 180.37,118.34 180.59,118.56 182.77,118.56 183.24,119.03 183.24,120.42 183.72,120.9 183.72,121.29 183.42,121.6 183.42,122.14 183.72,122.44 183.72,122.79 183.56,122.95 183.22,122.95 182.79,122.52 180.75,122.52 180.5,122.77 180.5,123.41 180.75,123.66 182.14,123.66 182.57,124.1 186.47,124.1 186.72,124.35 186.72,124.8 185.9,125.63 185.75,125.63 185.64,125.52 185.33,125.52 185.01,125.84 185.01,126.15 185.12,126.26 185.12,126.4 184.83,126.69 182.57,126.69 181.57,127.7 181.57,128.95 182.4,129.78 189.73,129.78 190.01,129.5 190.01,128.73 190.76,127.99 191.14,127.99 191.82,128.67 193.44,128.67 193.54,128.77 193.54,129.57 193.8,129.83 194.17,129.83 194.43,129.57 194.43,128.77 194.53,128.67 194.81,128.67 194.91,128.77 194.91,129.57 195.17,129.83 195.54,129.83 195.8,129.57 195.8,128.46 196.09,128.17 196.6,128.17 197.3,128.87 197.67,128.87 197.93,128.61 197.93,128.24 197.23,127.54 197.23,127.4 197.41,127.22 198,127.22 198.25,126.96 198.25,123.93 197.35,123.03 196.76,123.03 196.37,123.41 195.23,123.41 195.1,123.28 195.1,122.55 195.2,122.46 195.36,122.46 C2203.1
  BOTTOM w0.14: U9001.D25 177.65,118.09 177.77,118.21 v1(177.77,118.49)
PEG_RXN15_C: length 10.1
  TOP w0.095: v1(204.04,118.87) 203.62,119.3 202.99,119.3 201.73,120.56 198.49,120.56 196.59,122.46 196.37,122.46 C2203.2
  BOTTOM w0.102: v1(204.04,118.87) 204.04,118.81 U2000.AK25
PEG_RXP0: length 68.6
  TOP w0.095: v1(176.47,106.65) 177.04,106.08 178.05,106.08 178.33,105.8 178.47,105.8 179.12,106.45 179.43,106.45 179.75,106.13 179.75,105.82 179.26,105.33 179.1,105.17 179.1,104.57 179.24,104.43 179.69,104.43 180.12,104.87 180.63,104.87 181.26,104.23 181.26,103.6 180.87,103.2 179.16,103.2 179.05,103.09 179.05,102.86 179.19,102.72 180.61,102.72 180.88,102.45 180.88,102.07 180.64,101.83 179.28,101.83 179.05,101.6 179.05,101.03 179.31,100.77 180.79,100.77 181.01,100.55 181.01,100.1 180.79,99.88 179.15,99.88 179.05,99.78 179.05,99.5 179.15,99.4 180.79,99.4 181.01,99.18 181.01,98.73 180.79,98.51 179.15,98.51 179.05,98.41 179.05,98.13 179.16,98.03 181.2,98.03 181.57,98.39 181.57,99.26 181.79,99.48 182.1,99.48 182.2,99.58 182.2,99.86 182.1,99.96 181.79,99.96 181.57,100.18 181.57,100.63 181.79,100.85 182.1,100.85 182.2,100.95 182.2,101.23 182.1,101.34 181.79,101.34 181.57,101.56 181.57,102.28 182.04,102.76 184.61,102.76 185.2,103.34 186.09,103.34 186.34,103.09 186.34,102.11 186.1,101.87 185.33,101.87 185.2,101.74 185.2,101.51 185.33,101.39 187.03,101.39 187.48,100.93 187.48,100.04 187.61,99.91 188.91,99.91 189.16,99.67 189.16,99.14 188.91,98.9 187.1,98.9 186.98,98.77 186.98,98.49 187.08,98.39 189.9,98.39 190.28,98.77 194.05,98.77 194.85,99.57 194.85,101.98 195.58,102.71 196.61,102.71 196.76,102.85 196.76,103.34 197.14,103.72 198.21,103.72 198.66,104.17 198.66,104.64 C2140.1
  BOTTOM w0.114: U9001.F10 176.47,106.6 v1(176.47,106.65)
PEG_RXP0_C: length 7.7
  TOP w0.095: v1(203.29,108.86) 203.08,108.65 202.98,108.65 202.54,108.21 201.76,108.21 199.98,106.43 199.01,106.43 198.58,106 198.58,105.77 C2140.2
  BOTTOM w0.102: v1(203.29,108.86) 203.29,109.43 203.41,109.54 203.57,109.54 203.68,109.43 U2000.AK14
PEG_RXP1: length 65.5
  TOP w0.095: v1(191.68,105.34) 191.41,105.61 191.41,105.78 191.64,106.02 192.09,106.02 192.25,105.86 192.25,100.99 192.44,100.79 193.37,100.79 193.57,100.6 193.57,100.32 193.4,100.15 189.95,100.15 189.71,99.92 189.71,99.47 189.94,99.24 193.86,99.24 194.43,99.81 194.43,102.18 195.79,103.53 195.79,104.01 196.05,104.27 197.41,104.27 197.6,104.46 197.6,104.91 197.38,105.13 196.22,105.13 195.98,105.37 195.98,105.75 196.23,106 196.63,106 C2144.1
  IN4 w0.076: v1(191.68,105.34) 191.54,105.34 191.38,105.5 191.38,105.87 191.2,106.05 190.72,106.05 190.37,105.7 190.37,104.54 190.76,104.15 192.11,104.15 192.82,103.45 192.82,102.65 192.6,102.43 192.6,101.75 192.82,101.54 192.82,99.63 192.09,98.9 187.25,98.9 185.61,97.26 184.41,97.26 184.18,97.49 184.18,97.88 183.93,98.13 182.84,98.13 182.46,97.75 182.05,97.75 181.81,98 181.81,98.11 182.04,98.34 182.04,98.65 181.8,98.89 181.48,98.89 181.25,98.66 181.14,98.66 180.92,98.88 180.92,98.99 181.17,99.23 181.17,99.55 180.93,99.79 180.61,99.79 180.37,99.54 180.26,99.54 179.03,100.78 179.03,101.38 179.1,101.46 179.4,101.46 179.57,101.63 179.57,102.07 179.4,102.25 179.1,102.25 179.03,102.32 179.03,103.62 179.26,103.85 179.26,104.31 179.03,104.54 179.03,105.2 178.34,105.88 177.75,105.88 177.44,106.19 177.44,106.48 177.63,106.68 v1(177.77,106.68)
  BOTTOM w0.114: v1(177.77,106.68) 177.77,106.74 U9001.D11
PEG_RXP1_C: length 10.9
  TOP w0.095: v1(205.77,108.89) 205.41,109.25 205.28,109.25 205.16,109.37 202.41,109.37 200.06,107.02 198.54,107.02 198.28,106.76 198.28,106.34 197.95,106.01 197.65,106.01 C2144.2
  BOTTOM w0.102: v1(205.77,108.89) 205.77,108.92 205.39,109.3 U2000.AH14
PEG_RXP2: length 65.4
  TOP w0.095: v1(191.68,107.37) 191.68,107.28 191.83,107.13 192.48,107.13 192.61,107.26 192.61,107.49 192.87,107.75 193.24,107.75 193.5,107.49 193.5,106.86 193.05,106.41 193.05,101.94 193.17,101.82 193.4,101.82 193.53,101.94 193.53,106.09 193.78,106.34 194.17,106.34 194.42,106.09 194.42,103.78 194.55,103.65 194.77,103.65 194.9,103.78 194.9,106.31 194.77,106.43 194.77,106.98 195.02,107.22 195.36,107.22 C2135.1
  IN4 w0.076: v1(176.47,108.25) 176.82,107.89 176.96,107.89 177.17,107.68 178.19,107.68 178.95,106.92 178.95,106.25 179.57,105.63 179.57,105.01 180.35,104.23 180.75,104.23 180.97,104.01 180.97,103.5 180.75,103.28 179.74,103.28 179.61,103.15 179.61,102.95 179.74,102.82 181.38,102.82 181.6,102.6 181.6,102.26 181.38,102.03 180.25,102.03 180.12,101.91 180.12,101.7 180.25,101.58 181.41,101.58 181.63,101.35 181.63,101.01 181.41,100.79 180.25,100.79 180.12,100.66 180.12,100.46 180.25,100.33 181.6,100.33 181.85,100.09 181.85,99.85 183.02,98.68 185.17,98.68 185.3,98.81 185.3,99.25 185.53,99.48 186.07,99.48 186.15,99.56 186.15,99.74 186.37,99.96 186.71,99.96 186.93,99.74 186.93,99.59 187.04,99.48 189.01,99.48 189.08,99.56 189.08,99.74 189.31,99.96 189.65,99.96 189.87,99.74 189.87,99.56 189.95,99.48 190.25,99.48 190.33,99.56 190.33,99.74 190.55,99.96 190.89,99.96 191.12,99.74 191.12,99.56 191.19,99.48 191.9,99.48 192.27,99.85 192.27,101.31 192.06,101.53 192.06,102.69 192.27,102.9 192.27,103.22 191.89,103.61 190.52,103.61 189.81,104.32 189.81,106.03 191.05,107.28 191.58,107.28 v1(191.68,107.37)
  BOTTOM w0.114: v1(176.47,108.25) 176.47,108.18 U9001.F12
PEG_RXP2_C: length 11
  TOP w0.095: v1(204.12,110.49) 203.74,110.1 202.01,110.1 199.75,107.84 197.56,107.84 196.83,107.12 196.15,107.12 196.09,107.18 C2135.2
  BOTTOM w0.102: v1(204.12,110.49) 204.12,109.98 203.97,109.83 203.83,109.83 203.68,109.98 U2000.AK15
PEG_RXP3: length 65.1
  TOP w0.095: v1(177.77,108.25) 177.72,108.25 177.32,107.85 177.32,107.49 177.46,107.36 177.7,107.36 178,107.66 178.4,107.66 178.7,107.36 179.02,107.36 179.1,107.44 179.1,108.04 179.36,108.29 179.74,108.29 179.99,108.04 179.99,107.21 180.09,107.11 180.46,107.11 181.43,108.08 181.77,108.08 182.06,107.8 182.06,107.45 180.83,106.22 180.83,106.06 180.98,105.91 181.2,105.91 182,106.7 185.41,106.7 185.66,106.46 185.66,106.06 185.41,105.82 182.72,105.82 182.59,105.69 182.59,105.46 182.72,105.33 185.65,105.33 185.89,105.09 185.89,104.69 185.65,104.44 184.39,104.44 184.27,104.32 184.27,104.09 184.39,103.96 186.07,103.96 186.6,104.48 187.74,104.48 188.63,105.37 188.63,106.09 188.87,106.34 189.32,106.34 189.52,106.14 189.52,104.87 188.12,103.47 188.12,101.36 188.63,100.85 191.5,100.85 191.62,100.98 191.62,101.21 191.5,101.34 189.01,101.34 188.76,101.58 188.76,101.98 189.01,102.22 191.5,102.22 191.62,102.35 191.62,102.58 191.5,102.71 189.05,102.71 188.8,102.95 188.8,103.35 189.05,103.6 191.5,103.6 191.62,103.72 191.62,103.95 191.5,104.08 190.52,104.08 190.13,104.48 190.13,106.4 190.42,106.69 190.42,107.99 190.79,108.36 194.09,108.36 C2138.1
  BOTTOM w0.114: v1(177.77,108.25) 177.77,108.51 177.64,108.64 U9001.D13
PEG_RXP3_C: length 11.2
  TOP w0.095: C2138.2 195.09,108.38 196.82,108.38 197.98,109.54 198.6,109.54 198.81,109.33 198.81,109.06 198.92,108.95 199.3,108.95 199.45,109.1 199.45,109.31 199.66,109.53 200.29,109.53 201.77,111.01 201.76,111.01 201.76,111.02 202.92,111.02 v1(203.28,111.37)
  BOTTOM w0.102: U2000.AL16 203.28,111.35 v1(203.28,111.37)
PEG_RXP4: length 66.2
  TOP w0.095: v1(191.68,109.66) 191.88,109.46 192.26,109.46 192.31,109.51 192.31,109.81 192.54,110.04 192.99,110.04 193.2,109.83 193.2,109.06 193.29,108.97 193.59,108.97 193.68,109.06 193.68,109.83 193.89,110.04 194.36,110.04 194.57,109.83 194.57,109.53 194.65,109.46 195.69,109.46 C2115.1
  IN4 w0.076: v1(176.47,109.82) 176.9,109.39 178.05,109.39 179.32,108.12 179.32,107.44 179.7,107.06 179.7,106.28 180.12,105.86 180.12,105.37 180.58,104.92 181.21,104.92 181.52,104.61 181.52,103.96 182.15,103.32 182.15,101.56 182.53,101.18 182.53,99.94 183.24,99.23 184.45,99.23 185.73,100.51 187.32,100.51 187.48,100.34 187.48,100.17 187.62,100.03 188.41,100.03 188.53,100.15 188.53,100.34 188.69,100.51 191.62,100.51 191.73,100.61 191.73,100.87 191.62,100.97 185.11,100.97 184.94,100.8 183.4,100.8 183.22,100.97 183.22,101.4 183.45,101.63 184.72,101.63 184.82,101.73 184.82,102.76 185.02,102.96 185.48,102.96 185.66,102.78 185.66,101.85 185.75,101.75 191.25,101.75 191.5,102 191.5,102.95 191.4,103.05 191.16,103.05 191.04,102.93 191.04,102.5 190.75,102.21 189.25,102.21 189.1,102.36 189.1,102.81 189.29,103 189.96,103 190.06,103.11 190.06,103.28 189.88,103.46 189.25,103.46 189.05,103.66 189.05,104.87 189.26,105.08 189.26,106.26 190.51,107.5 190.51,109.04 190.86,109.39 191.41,109.39 v1(191.68,109.66)
  BOTTOM w0.114: v1(176.47,109.82) 176.47,109.75 U9001.F14
PEG_RXP4_C: length 10.2
  TOP w0.095: v1(204.11,112.18) 204.11,112.09 203.92,111.9 203.69,111.9 203.59,112 202.97,112 202.61,111.64 201.51,111.64 200.38,110.52 200.01,110.52 199.76,110.76 197.63,110.76 197.12,110.25 197.12,109.66 196.94,109.48 196.78,109.48 C2115.2
  BOTTOM w0.102: v1(204.11,112.18) 204.04,112.18 203.68,111.83 U2000.AK17
PEG_RXP5: length 65.1
  TOP w0.095: C2080.1 196.02,110.68 195.81,110.89 195.68,110.89 195.25,110.46 190.76,110.46 190.43,110.79 190.43,111.78 189.97,112.24 188.1,112.24 187.97,112.11 187.97,111.87 188.1,111.74 189.72,111.74 189.92,111.54 189.92,111.07 189.72,110.87 188.1,110.87 187.97,110.74 187.97,110.5 188.1,110.37 189.98,110.37 190.21,110.13 190.21,109.74 189.98,109.5 187.99,109.5 187.85,109.37 187.85,109.13 187.99,108.99 189.76,108.99 190,108.75 190,108.37 189.76,108.13 188.1,108.13 187.97,108 187.97,107.76 188.1,107.62 189.68,107.62 189.92,107.38 189.92,107 189.68,106.76 188.12,106.76 188.04,106.68 188.04,105.47 187.63,105.06 186.52,105.06 186.1,105.47 186.1,106.99 185.97,107.12 183.16,107.12 182.92,107.36 182.92,107.75 183.16,107.99 185.97,107.99 186.1,108.12 186.1,108.36 185.97,108.5 181.82,108.5 181.58,108.73 181.58,109.12 181.82,109.36 185.99,109.36 186.12,109.49 186.12,109.73 185.99,109.87 181.2,109.87 181.07,109.74 181.07,109.23 180.58,108.74 179.29,108.74 178.86,109.16 178.86,110.3 178.41,110.75 177.46,110.75 177.31,110.59 177.31,110.28 v1(177.77,109.82)
  BOTTOM w0.114: U9001.D15 177.77,109.89 v1(177.77,109.82)
PEG_RXP5_C: length 11.3
  TOP w0.095: C2080.2 196.76,110.84 197.09,110.84 197.43,111.18 200.06,111.18 201,112.12 201.69,112.12 202.21,112.65 204.37,112.65 205.28,111.74 205.4,111.74 v1(205.76,111.37)
  BOTTOM w0.102: U2000.AH17 205.76,111.42 v1(205.76,111.37)
PEG_RXP6: length 64.9
  TOP w0.095: v1(191.68,111.31) 191.87,111.5 192.36,111.5 192.58,111.71 192.58,112.01 192.7,112.14 192.99,112.14 193.08,112.04 193.08,111.27 193.29,111.07 193.72,111.07 193.95,111.3 193.95,111.63 194.06,111.74 194.45,111.74 C2104.1
  IN4 w0.076: v1(191.68,111.31) 191.42,111.56 190.86,111.56 190.66,111.36 190.66,110.73 190.49,110.56 190.49,110.31 190.66,110.14 190.66,109.74 190.13,109.21 190.13,108.07 189.82,107.76 189.64,107.76 189.54,107.66 189.54,107.08 188.92,106.46 188.57,106.46 188.5,106.39 188.5,106.04 188.55,105.99 188.71,105.99 188.88,105.81 188.88,105.35 188.72,105.18 188.5,105.18 188.35,105.03 188.35,104.83 188.67,104.52 188.67,102.69 188.14,102.17 186.24,102.17 186.05,102.36 186.05,102.78 186.3,103.03 186.3,103.2 186.2,103.3 185.87,103.3 185.76,103.41 184.65,103.41 184.44,103.61 184.44,104.04 184.6,104.19 185.98,104.19 186.09,104.08 187.17,104.08 187.42,103.83 187.42,102.98 187.48,102.92 187.77,102.92 187.88,103.03 187.88,104.27 187.61,104.54 186.29,104.54 186.17,104.65 183.83,104.65 183.78,104.6 183.78,104.44 183.57,104.23 183.17,104.23 183,104.4 183,104.6 182.95,104.65 182.54,104.65 182.37,104.82 182.37,105.26 182.54,105.44 185.52,105.44 185.64,105.56 185.64,105.77 185.52,105.89 182.39,105.89 182.11,106.17 181.36,106.17 181.3,106.11 181.3,105.88 181.13,105.7 180.68,105.7 180.51,105.88 180.51,106.83 180.64,106.96 181.78,106.96 181.86,107.04 181.86,107.28 181.73,107.42 179.88,107.42 179.7,107.59 179.7,107.92 179.95,108.17 179.95,108.4 179.44,108.91 179.08,108.91 178.77,109.21 178.77,109.49 179.28,110 179.28,110.28 179.2,110.37 178.79,110.37 178.63,110.21 178.28,110.21 177.94,110.54 177.79,110.54 177.46,110.21 177.14,110.21 176.97,110.38 176.97,110.75 176.88,110.83 176.63,110.83 176.51,110.72 176.51,110.38 176.34,110.21 175.02,110.21 174.61,109.79 174.26,109.79 173.6,110.45 173.6,110.79 173.83,111.01 175.8,111.01 175.96,111.17 175.96,111.26 v1(175.82,111.4)
  BOTTOM w0.114: U9001.F16 176.14,111.07 v1(175.82,111.4)
PEG_RXP6_C: length 11.4
  TOP w0.095: v1(204.22,113.27) 204.22,113.47 204.13,113.56 203.86,113.56 203.51,113.2 201.96,113.2 201.57,112.81 200,112.81 199.69,112.5 197.51,112.5 196.85,111.84 195.35,111.84 195.2,111.69 C2104.2
  BOTTOM w0.102: U2000.AK18 203.95,112.6 204.3,112.94 204.3,113.19 v1(204.22,113.27)
PEG_RXP7: length 68
  TOP w0.095: C2093.1 195.6,112.75 190.71,112.75 190.34,113.11 190.34,114.08 190.2,114.23 189.81,114.23 189.6,114.43 189.6,115.18 189.39,115.39 189.15,115.39 188.49,116.05 188.13,116.05 187.98,115.9 187.98,115.27 188.16,115.09 188.73,115.09 189.07,114.75 189.07,114.45 188.85,114.23 188.27,114.23 188.18,114.14 188.18,113.94 188.4,113.72 189.62,113.72 189.83,113.5 189.83,113.07 189.62,112.85 188.01,112.85 187.62,113.25 185.95,113.25 185.77,113.43 185.77,113.89 186.15,114.27 186.15,114.46 186.02,114.59 182.57,114.59 182.2,114.96 181.84,114.96 181.3,114.42 181.3,114.2 181.42,114.08 185.06,114.08 185.26,113.88 185.26,113.43 185.05,113.22 180.89,113.22 180.74,113.07 180.74,112.8 180.83,112.71 186.08,112.71 186.3,112.48 186.3,112.08 186.08,111.85 180.81,111.85 180.69,111.72 180.69,111.45 180.79,111.34 186.08,111.34 186.28,111.14 186.28,110.68 186.08,110.48 179.63,110.48 179.37,110.74 179.37,111.34 179.82,111.79 179.82,112.18 179.53,112.47 179.36,112.47 178.97,112.09 177.44,112.09 177.31,111.96 177.31,111.8 177.71,111.4 v1(177.77,111.4)
  BOTTOM w0.114: v1(177.77,111.4) 177.44,111.72 U9001.D17
PEG_RXP7_C: length 8.3
  TOP w0.095: v1(202.48,113.87) 202.48,113.99 202.36,114.12 201.97,114.12 201.49,113.65 199.89,113.65 199.52,113.28 199.49,113.28 199.47,113.29 197.43,113.29 196.98,112.84 196.45,112.84 196.35,112.74 C2093.2
  BOTTOM w0.102: U2000.AL19 202.88,113.34 202.76,113.22 202.6,113.22 202.48,113.34 v1(202.48,113.87)
PEG_RXP8: length 65.8
  TOP w0.095: C2188.1 193.97,113.83 193.58,113.83 193.45,113.96 193.45,114.39 193.24,114.61 192.78,114.61 192.56,114.39 192.56,114.12 192.47,114.03 191.88,114.03 v1(191.68,114.23)
  IN4 w0.076: v1(176.47,112.97) 176.33,112.97 176.17,112.82 176.17,112.62 176.31,112.49 176.94,112.49 177.08,112.35 177.08,112.02 177.13,111.97 177.46,111.97 177.54,112.05 177.54,113.11 177.72,113.29 178.15,113.29 178.33,113.11 178.33,111.17 178.4,111.1 178.71,111.1 178.78,111.17 178.78,112.96 179.01,113.2 179.34,113.2 179.57,112.96 179.57,112.48 179.65,112.4 179.92,112.4 180.09,112.23 180.09,111.79 179.92,111.61 179.65,111.61 179.57,111.54 179.57,111.19 179.99,110.77 179.99,109.36 181.22,108.13 182.02,108.13 182.4,107.75 186.32,107.75 186.53,107.53 186.53,107.23 186.32,107.01 182.8,107.01 182.68,106.89 182.68,106.72 182.8,106.61 185.85,106.61 186.35,106.1 186.35,105.49 186.6,105.25 187.56,105.25 187.79,105.48 187.79,107 187.97,107.18 188.63,107.18 188.82,107.37 188.82,107.54 188.72,107.63 187.94,107.63 187.79,107.79 187.79,108.24 187.97,108.42 189.31,108.42 189.41,108.52 189.41,108.78 189.31,108.88 187.77,108.88 187.57,109.08 187.57,109.47 187.77,109.67 189.58,109.67 189.71,109.8 189.71,109.99 189.58,110.12 187.96,110.12 187.8,110.28 187.8,110.73 187.98,110.91 189.81,110.91 189.95,111.04 189.95,111.23 189.81,111.37 187.92,111.37 187.78,111.52 187.78,111.98 187.95,112.16 190.39,112.16 190.51,112.27 190.51,112.51 190.41,112.61 188.12,112.61 187.95,112.79 187.95,113.17 188.18,113.4 190.2,113.4 190.77,113.98 191.55,113.98 191.68,114.1 v1(191.68,114.23)
  BOTTOM w0.127: U9001.E18 176.62,112.58 176.47,112.73 v1(176.47,112.97)
PEG_RXP8_C: length 10.8
  TOP w0.095: C2188.2 194.69,113.84 194.84,113.69 195.1,113.69 195.3,113.9 196.26,113.9 196.93,114.56 201.05,114.56 201.32,114.83 202.78,114.83 203.08,115.13 203.26,115.13 203.38,115 203.38,114.81 v1(203.28,114.7)
  BOTTOM w0.102: U2000.AK20 203.68,114.63 203.55,114.76 203.33,114.76 v1(203.28,114.7)
PEG_RXP9: length 65.4
  TOP w0.095: C2190.1 195.51,114.36 195.29,114.58 194.9,114.58 194.45,115.03 190.42,115.03 190.21,115.23 190.21,115.89 190.09,116.01 189.39,116.01 189.17,116.24 189.17,116.66 189.39,116.88 189.87,116.88 190.02,117.03 190.02,117.24 189.87,117.39 189.39,117.39 189.17,117.6 189.17,118.04 189.39,118.25 189.67,118.25 189.82,118.4 189.82,118.61 189.67,118.76 189.39,118.76 189.17,118.97 189.17,121.37 189.02,121.52 188.81,121.52 188.67,121.37 188.67,116.9 188.43,116.66 188.04,116.66 187.8,116.9 187.8,121.87 188.72,122.79 189.02,122.79 189.38,122.43 189.53,122.43 189.74,122.63 189.74,122.78 189.38,123.14 189.38,123.45 189.46,123.53 189.46,123.74 189.31,123.89 189.1,123.89 187.11,121.9 186.6,121.9 186.42,122.08 185.84,122.08 185.74,121.98 185.74,121.63 185.83,121.55 186.07,121.55 186.29,121.32 186.29,120.91 186.07,120.69 185.89,120.69 185.74,120.54 185.74,120.28 185.84,120.18 186.1,120.18 186.3,119.98 186.3,119.52 186.1,119.32 185.41,119.32 185.26,119.17 185.26,118.96 185.41,118.81 186.07,118.81 186.32,118.56 186.32,118.2 186.07,117.94 185.01,117.94 184.75,117.69 184.75,117.52 184.84,117.44 186.04,117.44 186.29,117.18 186.29,116.83 186.04,116.57 184.42,116.57 184.13,116.87 183.93,116.87 183.57,116.5 183.57,116.21 183.72,116.06 186.04,116.06 186.28,115.83 186.28,115.44 186.04,115.2 182.85,115.2 182.57,115.48 182.57,116.42 182.45,116.54 182.2,116.54 182.06,116.39 182.06,116.07 180.69,114.7 180.69,113.96 180.33,113.6 179.21,113.6 178.98,113.36 178.98,112.99 178.76,112.77 177.93,112.77 177.31,113.4 177.31,113.57 v1(177.12,113.76)
  BOTTOM w0.114: U9001.E19 177.12,113.69 v1(177.12,113.76)
PEG_RXP9_C: length 11
  TOP w0.095: C2190.2 195.96,114.51 196.21,114.76 196.5,114.76 196.74,115.01 200.84,115.01 201.18,115.35 203.8,115.35 203.92,115.23 204.34,115.23 204.49,115.07 204.91,115.07 205.01,114.97 205.01,114.78 v1(204.95,114.72)
  BOTTOM w0.102: U2000.AH20 205.24,114.16 205.1,114.16 204.88,114.38 204.88,114.65 v1(204.95,114.72)
PEG_RXP10: length 66.7
  TOP w0.095: C2192.1 195.31,116.31 194.72,116.31 194.49,116.55 194.04,116.55 193.81,116.32 193.81,115.97 193.67,115.83 193.47,115.83 193.33,115.97 193.33,116.64 193.07,116.9 192.7,116.9 192.44,116.64 192.44,116.47 192.28,116.31 191.89,116.31 191.84,116.37 191.83,116.37 v1(191.68,116.52)
  IN4 w0.076: v1(191.68,116.52) 191.68,116.42 191.5,116.25 190.74,116.25 190.49,116 190.49,115.34 190.34,115.19 188.03,115.19 187.83,114.99 187.83,114.58 188.01,114.4 189.97,114.4 190.1,114.27 190.1,114.08 189.97,113.95 187.95,113.95 187.42,113.41 186.63,113.41 186.16,112.94 186.16,111.69 186.4,111.45 186.4,111.13 186.16,110.89 186.16,109.87 185.94,109.65 185.68,109.65 185.5,109.48 185.5,108.38 185.42,108.29 185.1,108.29 185.05,108.35 185.05,109.48 184.87,109.65 184.43,109.65 184.26,109.48 184.26,108.38 184.18,108.29 183.88,108.29 183.8,108.38 183.8,109.48 183.63,109.65 183.19,109.65 183.01,109.48 183.01,108.35 182.96,108.29 182.64,108.29 182.56,108.38 182.56,109.48 182.38,109.65 181.94,109.65 181.77,109.48 181.77,108.81 181.64,108.68 181.45,108.68 181.31,108.81 181.31,109.48 181.14,109.65 180.99,109.65 180.88,109.76 180.88,110.03 180.96,110.11 185.48,110.11 185.71,110.34 185.71,110.67 185.48,110.9 180.76,110.9 180.66,111 180.66,111.25 180.76,111.36 185.53,111.36 185.71,111.53 185.71,111.98 185.54,112.14 180.69,112.14 180.64,112.2 180.64,112.37 181.05,112.78 181.05,113.82 180.81,114.05 180.49,114.05 180.26,113.82 180.26,113.51 180.12,113.37 179.93,113.37 179.8,113.51 179.8,113.82 179.52,114.1 178.92,114.1 178.66,114.36 178.02,114.36 177.94,114.44 177.94,114.8 177.77,114.97 177.33,114.97 177.16,114.8 177.16,114.44 177.08,114.36 176.66,114.36 v1(176.47,114.55)
  BOTTOM w0.127: U9001.E20 176.47,114.48 v1(176.47,114.55)
PEG_RXP10_C: length 9.8
  TOP w0.095: C2192.2 196.43,116.3 201.02,116.3 201.39,115.93 204.13,115.93 v1(204.27,116.07)
  BOTTOM w0.102: v1(204.27,116.07) 204.27,115.69 U2000.AK21
PEG_RXP11: length 66.8
  TOP w0.095: v1(177.12,115.34) 177.12,114.76 177.33,114.55 178.73,114.55 179.41,115.22 180.35,115.22 180.71,115.58 180.71,116.02 181.84,117.15 183.35,117.15 184.65,118.45 184.65,119.8 185.13,120.28 185.13,122.47 185.35,122.69 187.03,122.69 188.56,124.23 188.56,125.26 185.97,127.85 185.97,128.08 186.27,128.37 186.49,128.37 187.4,127.47 187.87,127.47 188.37,127.98 188.77,127.98 189.2,127.55 189.2,127.17 188.75,126.73 188.75,126.11 189.42,125.45 189.84,125.45 189.95,125.34 189.95,124.26 190.18,124.03 190.59,124.03 190.82,124.26 190.82,125.34 190.92,125.45 191.33,125.45 191.54,125.67 191.54,126.45 191.69,126.6 191.9,126.6 192.05,126.45 192.05,125.67 192.27,125.45 192.7,125.45 192.92,125.67 192.92,126.45 193.06,126.6 193.27,126.6 193.42,126.45 193.42,125.67 193.64,125.45 194.07,125.45 194.29,125.67 194.29,126.45 194.44,126.6 194.65,126.6 194.8,126.45 194.8,125.67 195.01,125.45 195.45,125.45 195.66,125.67 195.66,126.45 195.81,126.6 196.02,126.6 196.17,126.45 196.17,125.67 196.38,125.45 196.71,125.45 196.84,125.32 196.84,125.05 196.66,124.87 192.01,124.87 191.69,124.55 191.69,122.9 191.34,122.56 190.58,122.56 189.81,121.79 189.81,119.73 190.43,119.11 190.43,117.69 190.8,117.32 192.28,117.32 192.49,117.53 192.49,117.72 192.6,117.83 192.89,117.83 193,117.72 193,117.53 193.21,117.32 194.08,117.32 C2194.1
  BOTTOM w0.127: U9001.E21 177.12,115.27 v1(177.12,115.34)
PEG_RXP11_C: length 9.6
  TOP w0.095: C2194.2 194.82,117.28 194.95,117.41 194.98,117.41 194.99,117.43 197.03,117.43 197.64,116.82 202.34,116.82 202.48,116.68 v1(202.48,116.37)
  BOTTOM w0.114: U2000.AL22 202.7,115.77 202.58,115.77 202.48,115.87 v1(202.48,116.37)
PEG_RXP12: length 65.2
  TOP w0.095: v1(191.68,118.8) 191.85,118.63 192.31,118.63 192.44,118.75 192.44,119.18 192.7,119.45 193.22,119.45 193.64,119.03 193.84,119.03 C2196.1
  IN4 w0.076: v1(176.47,116.12) 176.65,115.94 178.6,115.94 179.1,115.43 179.1,114.8 179.25,114.64 179.41,114.64 179.56,114.8 179.56,115.21 179.79,115.45 180.12,115.45 180.35,115.21 180.35,114.8 180.48,114.67 180.67,114.67 180.8,114.8 180.8,115.21 181.03,115.45 181.36,115.45 181.59,115.21 181.59,112.77 181.67,112.69 181.97,112.69 182.05,112.77 182.05,115.27 182.28,115.5 182.61,115.5 182.84,115.27 182.84,112.77 182.92,112.69 183.21,112.69 183.29,112.77 183.29,115.46 183.5,115.66 183.88,115.66 184.08,115.46 184.08,112.77 184.16,112.69 184.46,112.69 184.54,112.77 184.54,115.49 184.74,115.7 185.12,115.7 185.33,115.49 185.33,113.33 185.46,113.2 185.65,113.2 185.78,113.33 185.78,115.07 186.1,115.39 186.1,116.05 186.01,116.14 185.26,116.14 185.03,116.37 185.03,116.7 185.26,116.93 185.95,116.93 186.1,117.08 186.1,119.21 186.36,119.47 190.34,119.47 190.57,119.24 190.57,118.91 190.34,118.68 187.96,118.68 187.9,118.63 187.9,118.38 188.06,118.23 189.68,118.23 189.91,118 189.91,117.67 189.68,117.44 188.08,117.44 187.94,117.31 187.94,117.12 188.08,116.98 189.25,116.98 189.48,116.75 189.48,116.42 189.25,116.19 188.08,116.19 187.94,116.06 187.94,115.87 188.08,115.74 189.83,115.74 189.95,115.86 189.95,116.71 190.37,117.13 190.37,118.14 190.71,118.49 191.47,118.49 191.68,118.69 v1(191.68,118.8)
  BOTTOM w0.127: v1(176.47,116.12) 176.47,116.05 U9001.E22
PEG_RXP12_C: length 11.2
  TOP w0.095: C2196.2 194.57,119.09 194.75,118.91 195.17,118.91 195.85,118.23 200.53,118.23 201.29,117.47 202.96,117.47 203.11,117.62 203.44,117.62 203.54,117.52 203.54,117.29 203.45,117.2 v1(203.28,117.2)
  BOTTOM w0.102: U2000.AK23 203.68,117.06 203.54,117.2 v1(203.28,117.2)
PEG_RXP13: length 65.5
  TOP w0.095: C2198.1 196.02,118.96 195.75,119.23 195.5,119.23 194.86,119.86 192.01,119.86 191.75,119.6 190.8,119.6 190.42,119.98 190.42,121.53 190.81,121.93 191.83,121.93 192.37,122.47 192.37,123.94 192.64,124.21 193.2,124.21 193.42,123.99 193.42,122.56 193.53,122.46 193.94,122.46 194.05,122.56 194.05,123.99 194.26,124.21 197.29,124.21 197.45,124.38 197.45,126.05 196.3,127.21 195.51,127.21 195.3,127.42 195.3,127.76 195.19,127.87 194.9,127.87 194.79,127.76 194.79,127.42 194.58,127.21 194.14,127.21 193.92,127.42 193.92,127.76 193.82,127.87 193.53,127.87 193.42,127.76 193.42,127.42 193.2,127.21 192.77,127.21 192.55,127.42 192.55,127.76 192.44,127.87 192.15,127.87 192.05,127.76 192.05,127.42 191.83,127.21 191.42,127.21 190.91,126.7 190.4,126.7 189.91,127.19 189.91,127.7 188.63,128.98 183.55,128.98 183.23,128.66 183.23,127.68 183.42,127.49 185.17,127.49 187.51,125.15 187.51,124.03 186.77,123.3 184.72,123.3 184.52,123.1 184.52,120.57 184.04,120.09 184.04,118.7 183.1,117.76 181.5,117.76 180.42,116.69 179.1,116.69 178.43,116.02 177.33,116.02 177.12,116.23 v1(177.12,116.91)
  BOTTOM w0.114: U9001.E23 177.12,116.84 v1(177.12,116.91)
PEG_RXP13_C: length 10.9
  TOP w0.095: v1(204.95,117.22) 204.95,117.05 204.83,116.93 204.64,116.93 204.54,117.03 204.54,117.39 204.1,117.84 201.63,117.84 200.79,118.68 197.5,118.68 196.99,119.19 196.73,119.19 196.7,119.15 196.69,119.15 C2198.2
  BOTTOM w0.102: U2000.AH23 205.35,116.77 204.99,116.77 204.88,116.88 204.88,117.15 v1(204.95,117.22)
PEG_RXP14: length 65.1
  TOP w0.095: v1(191.68,121.12) 191.9,120.89 192.41,120.89 192.59,121.06 192.59,121.57 192.85,121.83 193.22,121.83 193.48,121.57 193.48,121.01 193.62,120.87 193.82,120.87 193.96,121.01 193.96,121.57 194.22,121.83 194.59,121.83 194.85,121.57 194.85,121.06 195,120.91 195.34,120.91 C2200.1
  IN4 w0.076: v1(176.47,117.7) 176.65,117.51 177.29,117.51 177.41,117.64 178.91,117.64 179.14,117.4 179.14,116.19 179.28,116.05 179.48,116.05 179.62,116.19 179.62,118.37 179.87,118.62 180.54,118.62 180.79,118.37 180.79,116.12 180.92,115.99 181.11,115.99 181.25,116.12 181.25,118.37 181.5,118.61 181.79,118.61 182.04,118.37 182.04,116.18 182.17,116.04 182.36,116.04 182.49,116.18 182.49,118.73 182.72,118.96 183.05,118.96 183.28,118.73 183.28,116.29 183.36,116.21 184.3,116.21 184.43,116.34 184.43,116.53 184.3,116.66 184,116.66 183.76,116.9 183.76,117.24 184,117.48 185.42,117.48 185.55,117.61 185.55,117.8 185.42,117.93 183.99,117.93 183.76,118.16 183.76,118.49 183.99,118.72 185.42,118.72 185.55,118.86 185.55,119.04 185.42,119.18 183.99,119.18 183.74,119.43 183.74,119.69 184.01,119.97 184.5,119.97 184.69,120.15 184.69,121.99 184.92,122.23 185.26,122.23 185.49,121.99 185.49,120.09 185.62,119.95 185.81,119.95 185.95,120.09 185.95,122 186.18,122.23 186.5,122.23 186.73,122 186.73,121.55 186.87,121.42 187.06,121.42 187.19,121.55 187.19,122 187.42,122.23 187.75,122.23 187.98,122 187.98,120.15 188.11,120.02 188.3,120.02 188.44,120.15 188.44,121.84 188.67,122.07 188.99,122.07 189.22,121.84 189.22,121.34 189.31,121.26 189.85,121.26 190.08,121.03 190.08,120.7 189.85,120.47 189.36,120.47 189.22,120.34 189.22,120.15 189.36,120.02 190.43,120.02 190.53,120.12 190.53,120.63 190.78,120.87 191.55,120.87 191.68,121 v1(191.68,121.12)
  BOTTOM w0.127: v1(176.47,117.7) 176.47,117.63 U9001.E24
PEG_RXP14_C: length 11.2
  TOP w0.095: C2200.2 196.5,120.8 197.2,120.8 198.05,119.95 200.66,119.95 202.17,118.45 204.48,118.45 v1(204.61,118.58)
  BOTTOM w0.102: U2000.AK24 203.81,117.6 204.1,117.89 204.1,118.07 v1(204.61,118.58)
PEG_RXP15: length 66.4
  TOP w0.095: C2202.1 195.35,122.27 195.12,122.27 194.91,122.47 194.91,123.36 195.15,123.6 196.45,123.6 196.83,123.22 197.27,123.22 198.06,124.01 198.06,126.88 197.92,127.03 197.34,127.03 197.04,127.32 197.04,127.62 197.6,128.18 197.74,128.32 197.74,128.53 197.59,128.68 197.38,128.68 196.88,128.18 196.68,127.98 196.01,127.98 195.61,128.38 195.61,129.5 195.46,129.64 195.25,129.64 195.1,129.5 195.1,128.69 194.89,128.48 194.45,128.48 194.24,128.69 194.24,129.5 194.09,129.64 193.88,129.64 193.73,129.5 193.73,128.69 193.51,128.48 191.9,128.48 191.22,127.8 190.68,127.8 189.82,128.65 189.82,129.42 189.66,129.59 182.47,129.59 181.76,128.87 181.76,127.78 182.65,126.88 184.91,126.88 185.31,126.48 185.31,126.18 185.2,126.07 185.2,125.92 185.41,125.71 185.56,125.71 185.67,125.82 185.97,125.82 186.91,124.88 186.91,124.28 186.55,123.91 182.65,123.91 182.21,123.47 180.83,123.47 180.69,123.33 180.69,122.85 180.83,122.71 182.71,122.71 183.15,123.14 183.64,123.14 183.92,122.87 183.92,122.36 183.61,122.06 183.61,121.68 183.92,121.37 183.92,120.82 183.43,120.34 183.43,118.96 182.85,118.37 180.67,118.37 180.56,118.26 180.56,118.05 180.35,117.83 179.91,117.83 179.69,118.05 179.69,118.26 179.59,118.37 179.17,118.37 179.06,118.27 179.06,117.83 178.72,117.48 177.43,117.48 177.12,117.79 v1(177.12,118.49)
  BOTTOM w0.14: v1(177.12,118.49) 177.12,118.42 U9001.E25
PEG_RXP15_C: length 10.1
  TOP w0.095: C2202.2 196.37,122.26 196.53,122.26 198.41,120.37 201.65,120.37 202.91,119.11 203.05,119.11 v1(203.28,118.87)
  BOTTOM w0.102: v1(203.28,118.87) 203.28,118.2 203.16,118.08 203,118.08 202.88,118.2 U2000.AL25
PEG_TXN0: length 68.6
  BOTTOM w0.095: C9005.1 184.49,105.44 186.34,105.44 186.53,105.25 187.41,105.25 187.61,105.04 187.61,104.72 187.29,104.41 187.29,104.17 187.61,103.85 187.61,101.99 187.37,101.74 185.83,101.74 185.71,101.61 185.71,101.36 185.83,101.23 187.3,101.23 187.57,100.97 187.57,100.59 187.3,100.32 185.71,100.32 185.56,100.17 185.56,99.96 185.71,99.81 187.29,99.81 187.56,99.54 187.56,99.16 187.32,98.92 185.58,98.92 185.33,98.67 185.33,98.31 185.58,98.06 186.54,98.06 186.95,97.65 186.95,97.23 187.07,97.12 187.29,97.12 187.43,97.26 187.43,98.33 187.69,98.59 188.06,98.59 188.32,98.33 188.32,97.68 188.93,97.07 189.71,97.07 190.09,96.69 190.09,95.14 188.98,94.04 188.01,94.04 187.87,93.89 187.87,93.69 188.01,93.55 188.24,93.55 188.49,93.3 188.49,92.94 188.24,92.69 187.99,92.69 187.87,92.57 187.87,92.39 187.99,92.27 189.55,92.27 189.71,92.42 189.71,93.77 190.51,94.57 191.67,94.57 191.81,94.71 191.81,94.92 191.67,95.06 190.79,95.06 190.58,95.27 190.58,95.74 190.79,95.95 192.06,95.95 192.42,95.59 192.65,95.59 192.79,95.74 192.79,96.91 193.03,97.14 193.46,97.14 193.69,96.91 193.69,94.81 193.85,94.66 194.13,94.66 194.28,94.81 194.28,101.78 194.91,102.41 194.91,105.34 195.79,106.21 196.03,106.45 197.69,106.45 198.95,107.7 199.72,107.7 200.26,108.24 200.75,108.24 201.03,107.96 201.72,107.96 U2000.AM12
PEG_TXN1: length 68.8
  IN3 w0.089: v1(198.94,108.34) 198.74,108.14 198.74,107.85 198.87,107.72 200.78,107.72 201.03,107.47 201.03,106.17 200.64,105.78 200.29,105.78 200.06,106.01 200.06,106.64 199.83,106.87 198.8,106.87 198.66,106.73 198.66,106.54 198.8,106.4 199.24,106.4 199.49,106.15 199.49,105.8 199.24,105.55 198.56,105.55 198.42,105.41 198.42,105.22 198.56,105.08 199.1,105.08 199.35,104.83 199.35,104.48 198.74,103.88 198.74,102.12 198.49,101.87 197.79,101.87 197.66,101.73 197.66,101.54 197.79,101.4 198.49,101.4 198.74,101.15 198.74,100.8 198.49,100.55 198.23,100.55 198.09,100.41 198.09,100.22 198.23,100.08 198.49,100.08 198.74,99.83 198.74,99.48 198.49,99.23 197.83,99.23 197.69,99.09 197.69,98.89 197.83,98.76 198.49,98.76 198.74,98.51 198.74,98.16 198.49,97.91 197.65,97.91 197.52,97.77 197.52,97.57 197.65,97.44 198.49,97.44 198.74,97.19 198.74,96.83 198.49,96.59 197.85,96.59 197.71,96.45 197.71,96.25 197.85,96.12 198.49,96.12 198.74,95.87 198.74,95.51 198.49,95.26 197.7,95.26 197.61,95.18 197.61,95.02 197.85,94.78 198.46,94.78 198.69,94.56 198.69,94.2 198.41,93.92 197.01,93.92 196.76,94.18 196.76,95.18 196.67,95.26 196.23,95.26 195.67,94.71 195.03,94.71 194.53,95.2 194.53,95.85 194.8,96.12 196.01,96.12 196.15,96.25 196.15,96.45 196.01,96.59 193.13,96.59 192.88,96.83 192.88,97.19 193.13,97.44 196.49,97.44 196.63,97.57 196.63,97.77 196.49,97.91 192.12,97.91 190.43,99.59 190.43,102.2 187.87,104.77 187.87,105.87 187.61,106.12 187,106.12 v1(186.72,105.85)
  BOTTOM w0.095: U2000.AM14 201.7,108.92 201.17,108.92 200.97,108.72 199.32,108.72 199.12,108.53 v1(198.94,108.34) ; C9007.1 186.07,106.07 186.51,106.07 v1(186.72,105.85)
PEG_TXN2: length 69.1
  BOTTOM w0.095: C9009.1 184.61,107.35 188.92,107.35 189.16,107.11 189.16,106.68 188.92,106.44 188.25,106.44 188.03,106.22 188.03,105.73 188.22,105.54 188.22,102.58 188.37,102.43 188.82,102.43 189.08,102.17 189.08,101.8 188.82,101.54 188.3,101.54 188.15,101.4 188.15,101.2 188.3,101.06 188.81,101.06 189.08,100.78 189.08,99.98 188.81,99.71 188.31,99.71 188.17,99.57 188.17,99.37 188.31,99.23 188.66,99.23 188.93,98.96 188.93,97.99 189.17,97.75 189.41,97.75 189.57,97.91 189.57,101.97 189.83,102.23 190.2,102.23 190.46,101.97 190.46,97.18 191.08,96.56 192.03,96.56 192.18,96.71 192.18,96.89 192.03,97.04 191.3,97.04 191.04,97.31 191.04,97.69 191.3,97.96 192.46,97.96 192.67,97.75 193.52,97.75 193.67,97.91 193.67,98.29 193.52,98.44 191.21,98.44 190.95,98.7 190.95,99.07 191.21,99.33 193.53,99.33 193.67,99.47 193.67,99.67 193.53,99.81 191.2,99.81 190.94,100.07 190.94,100.44 191.2,100.7 193.52,100.7 193.67,100.85 193.67,101.03 193.52,101.18 191.23,101.18 190.97,101.44 190.97,101.81 191.23,102.07 193.71,102.07 194.3,102.67 194.3,105.87 194.57,106.14 194.85,106.14 195.78,107.06 197.44,107.06 197.59,107.21 197.59,107.47 197.49,107.57 197.2,107.57 196.93,107.84 196.93,108.96 197.45,109.48 199.86,109.48 U2000.AP15
PEG_TXN3: length 67.9
  IN3 w0.089: v1(186.72,107.88) 187.01,108.17 187.87,108.17 188.12,107.91 188.12,106.52 188.45,106.19 188.45,105.01 191.01,102.44 191.01,100.05 192.57,98.49 196.81,98.49 197.07,98.75 197.07,101.75 196.81,102.01 196.44,102.01 196.18,101.75 196.18,99.49 196.03,99.34 192.97,99.34 192.82,99.49 192.82,99.66 192.97,99.81 195.05,99.81 195.29,100.06 195.29,100.41 195.05,100.66 192.08,100.66 191.93,100.81 191.93,101.03 192.08,101.18 195.05,101.18 195.29,101.43 195.29,102.29 195.49,102.48 197.91,102.48 198.16,102.73 198.16,103.08 197.91,103.33 195.88,103.33 195.74,103.47 195.74,103.66 195.88,103.8 197.44,103.8 197.69,104.05 197.69,104.4 197.44,104.65 196.02,104.65 195.88,104.79 195.88,104.98 196.02,105.12 197.59,105.12 197.83,105.37 197.83,105.72 197.59,105.97 196.51,105.97 196.37,106.11 196.37,106.3 196.51,106.44 197.83,106.44 198.08,106.69 198.08,107.21 197.81,107.47 197.34,107.47 197.2,107.61 197.2,108.58 197.35,108.73 199.36,108.73 199.61,108.98 199.61,109.34 199.36,109.58 199.04,109.58 198.91,109.71 198.91,109.89 v1(199.01,109.99)
  BOTTOM w0.095: v1(186.72,107.88) 186.43,108.17 186.14,108.17 C9011.1 ; v1(199.01,109.99) 198.85,110.15 198.85,110.41 199.09,110.65 200.61,110.65 200.91,110.35 200.91,109.95 201.12,109.74 201.72,109.74 U2000.AM15
PEG_TXN4: length 68.9
  BOTTOM w0.095: U2000.AM17 201.71,112.17 201.12,112.17 200.84,111.9 200.84,111.59 200.64,111.39 196.56,111.39 196.3,111.12 196.3,110.75 196.56,110.48 196.98,110.48 197.12,110.33 197.12,110.12 196.98,109.97 196.59,109.97 196.32,109.7 196.32,107.81 196.18,107.67 195.98,107.67 195.84,107.81 195.84,109.51 195.58,109.77 195.21,109.77 194.95,109.51 194.95,108.32 194.8,108.17 192.32,108.17 192.06,107.91 192.06,107.54 192.32,107.28 194.58,107.28 194.72,107.14 194.72,106.94 194.58,106.8 192.3,106.8 192.04,106.54 192.04,106.17 192.3,105.91 193.55,105.91 193.69,105.77 193.69,105.57 193.55,105.42 192.34,105.42 192.08,105.16 192.08,104.8 192.34,104.54 193.55,104.54 193.69,104.39 193.69,104.19 193.55,104.05 192.57,104.05 192.31,103.79 192.31,103.42 192.57,103.16 193.54,103.16 193.69,103.01 193.69,102.92 193.46,102.68 191.97,102.68 191.83,102.82 191.83,104.04 191.57,104.3 191.2,104.3 190.94,104.04 190.94,102.99 190.8,102.85 190.6,102.85 190.46,102.99 190.46,103.61 190.19,103.88 189.81,103.88 189.54,103.61 189.54,103.17 189.39,103.02 189.03,103.02 188.88,103.17 188.88,104.21 189.03,104.36 190.36,104.36 190.62,104.62 190.62,104.99 190.36,105.25 188.97,105.25 188.83,105.39 188.83,105.59 188.97,105.73 190.39,105.73 190.65,105.99 190.65,106.36 190.39,106.62 189.91,106.62 189.77,106.76 189.77,106.96 189.91,107.1 190.36,107.1 190.62,107.36 190.62,107.73 190.36,107.99 188.02,107.99 187.88,108.13 187.88,108.33 188.02,108.47 190.36,108.47 190.62,108.74 190.62,109.11 190.36,109.38 188.83,109.38 188.68,109.53 188.68,110.14 188.41,110.4 188.04,110.4 187.78,110.14 187.78,109.53 187.62,109.38 185.07,109.38 184.96,109.49 184.5,109.49 C9013.1

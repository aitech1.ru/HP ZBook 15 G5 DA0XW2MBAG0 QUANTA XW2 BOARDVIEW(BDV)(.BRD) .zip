# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R7310  33_4  [R0402]  24.52 69.61 0 bottom
R7311  *0_4/S  [S0402]  24.52 68.59 0 bottom
R7312  33_4  [R0402]  24.52 66.56 0 bottom
R7313  33_5%_4  [R0402]  24.64 64.4 90 bottom
R7314  6.2K_1%_4  [R0402]  33.41 64.71 90 bottom
R7315  33_5%_4  [R0402]  25.66 64.4 90 bottom
R7316  *0_6/S  [S0603]  29.1 64.02 270 bottom
R7320  *0_5%_4  [R0402]  353.09 143.65 270 top
R7322  *10K_1%_4  [R0402]  359.19 119.8 180 top
R7323  *0_5%_4  [R0402]  342.55 130.27 0 top
R7324  10K/F_4  [R0402]  351.87 143.65 270 top
R7327  10K/F_4  [R0402]  342.56 131.29 0 top
R7328  10K_4  [R0402]  32.01 73.8 270 bottom
R7329  10K_4  [R0402]  36.99 76.54 0 top
R7330  *0_4  [R0402]  36.99 77.56 180 top
R7331  10K_4  [R0402]  31.78 78.07 270 top
R7333  *0_4  [R0402]  30.77 78.07 90 top
R8001  3.01K/F_4  [R0402]  341.95 113.25 0 top
R8002  *100K_1%_4  [R0402]  348.52 105.88 90 top
R8005  *100K_1%_4  [R0402]  351.11 105.07 0 bottom
R8006  100K_1%_4  [R0402]  356.27 108.04 180 bottom
R8007  100K_1%_4  [R0402]  354.24 108.8 180 bottom
R8008  10K_1%_4  [R0402]  351.47 113.22 0 top
R8009  10K_1%_4  [R0402]  353.6 112.08 0 top
R8010  10K_1%_4  [R0402]  356.27 104.99 0 bottom
R8011  200/F_4  [R0402]  340.27 115.91 270 top
R8012  200/F_4  [R0402]  340.27 117.69 90 top
R8013  100K_1%_4  [R0402]  350.43 111.37 270 top
R8014  10K_1%_4  [R0402]  341.51 106.52 90 top
R8015  10K_1%_4  [R0402]  342.5 106.52 90 top
R8016  10K_1%_4  [R0402]  343.49 106.52 90 top
R8017  10K_1%_4  [R0402]  344.51 106.52 90 top
R8018  33_5%_2  [R0201]  337.6 119.09 270 bottom
R8019  33_5%_2  [R0201]  336.84 119.09 270 bottom
R8020  *10K/F_4  [R0402]  353.6 109.06 0 top
R8021  2.2K_5%_4  [R0402]  353.6 110.07 180 top
R8022  2.2K_5%_4  [R0402]  353.6 111.09 180 top
R8023  *0_4/S  [S0402]  356.27 107.02 180 bottom
R8024  *0_4/S  [S0402]  354.24 107.79 180 bottom
R8025  *0_5%_4  [R0402]  353.98 105.81 0 top
R8026  *0_4/S  [S0402]  351.11 105.25 180 top
R8027  10K_1%_4  [R0402]  354.24 104.74 0 bottom
R8028  *10K/F_4  [R0402]  353.98 106.77 180 top
R8029  *10K/F_4  [R0402]  349.38 108.02 270 top
R8031  100K_1%_4  [R0402]  354.24 106.77 180 bottom
R8032  100K_1%_4  [R0402]  356.27 106.01 180 bottom
R8033  4.75K+-0.5%_4  [R0402]  348.39 115.95 180 top
R8034  2.2K_5%_4  [R0402]  314.36 66 0 bottom
R8035  100K_1%_4  [R0402]  349.54 105.88 90 top
R8036  3.32K/F_4  [R0402]  314.36 63.97 0 bottom
R8037  2.2K_5%_4  [R0402]  314.36 64.99 0 bottom
R8038  100K_1%_4  [R0402]  347.5 105.88 90 top
R8039  3.32K/F_4  [R0402]  313.6 67.78 90 bottom
R8040  100K_1%_4  [R0402]  354.24 105.75 180 bottom
R8041  10K/F_4  [R0402]  344.71 105.12 180 top
R8042  *1M/F_4  [R0402]  346.49 105.88 270 top
R8043  *0_6  [R0603]  353.65 113.35 0 top
R8044  *0_6/S  [S0603]  354.21 115.53 270 top
R8045  *0_6/S  [S0603]  353.47 117.57 0 top
R8046  *0_6  [R0603]  353.5 118.99 0 top
R8047  10K_1%_4  [R0402]  342.35 115.53 90 top
R8048  0_5%_2  [R0201]  340.9 122.65 270 top
R8049  0_5%_2  [R0201]  341.66 122.65 270 top
R8050  0_5%_2  [R0201]  341.41 122.9 270 bottom
R8051  0_5%_2  [R0201]  342.17 122.9 270 bottom
R8052  0_5%_2  [R0201]  343.95 122.9 270 bottom
R8053  0_5%_2  [R0201]  343.19 122.9 270 bottom
R8054  0_5%_2  [R0201]  343.57 122.65 270 top
R8055  0_5%_2  [R0201]  342.81 122.65 270 top
R8056  0_5%_2  [R0201]  344.33 122.65 270 top
R8057  0_5%_2  [R0201]  345.09 122.65 270 top
R8058  0_5%_2  [R0201]  344.96 122.93 270 bottom
R8059  0_5%_2  [R0201]  345.73 122.93 270 bottom
R8060  0_5%_2  [R0201]  347.43 122.65 270 bottom
R8061  0_5%_2  [R0201]  346.67 122.65 270 bottom
R8062  0_5%_2  [R0201]  346.87 122.65 270 top
R8063  0_5%_2  [R0201]  346.11 122.65 270 top
R8098  *10K_1%_4  [R0402]  356.7 106.14 270 top
R8501  *10K_1%_4  [R0402]  343.19 89.37 270 bottom
R8502  *0_5%_4  [R0402]  340.39 91.28 270 top
R8505  49.9K_1%_4  [R0402]  341.54 100.93 0 bottom
R8506  30K/F_4  [R0402]  341.54 99.91 180 bottom
R8507  10K/F_4  [R0402]  339.73 101.03 0 bottom
R8508  2.2K_5%_4  [R0402]  344.2 89.37 270 bottom
R8511  *10K_1%_4  [R0402]  338.28 96.99 90 bottom
R8512  71.5K_1%_4  [R0402]  339.76 100.04 0 bottom
R8530  *0_5%_4  [R0402]  357.79 103.47 90 top
R8531  *0_4/S  [S0402]  347.38 97.21 0 bottom
R8532  *0_4/S  [S0402]  347.38 95.98 0 bottom
R8533  *0_4/S  [S0402]  346.49 100.55 270 bottom
R8534  *0_4/S  [S0402]  345.47 100.55 270 bottom
R8551  *10K_1%_4  [R0402]  343.44 100.55 90 bottom
R8556  100K_1%_4  [R0402]  338.28 95.16 270 bottom
R8557  100K_1%_4  [R0402]  342.17 89.37 90 bottom
R8570  *1K/F_4  [R0402]  343.69 98.64 270 top
R8571  *1K/F_4  [R0402]  343.69 97.25 180 top
R8572  *0_2/S  [S0201]  340.77 95.47 90 top
R8573  *0_2/S  [S0201]  340.01 95.47 90 top
R8574  *0_2/S  [S0201]  339.88 98.9 0 top
R8575  *0_2/S  [S0201]  339.88 98.13 0 top
R8588  4.7K_1%_2  [R0201]  342.93 95.47 270 top
R8680  10K_1%_4  [R0402]  346.34 100.57 90 top
R8681  *100K_1%_4  [R0402]  337.93 95.85 0 top
R8682  *100K_1%_4  [R0402]  338.03 97.83 0 top
R8683  *100K_1%_4  [R0402]  337.98 96.81 0 top
R8684  *100K_1%_4  [R0402]  338.03 98.82 0 top
R9000  *49.9/F_4  [R0402]  135.16 115.79 180 top
R9001  10K_5%_2  [R0201]  261.27 18.43 270 bottom
R9002  *4.7K/F_4  [R0402]  132.37 110.07 0 top
R9003  *0_2/S  [S0201]  262.03 18.46 90 bottom
R9004  33_5%_2  [R0201]  262.8 18.43 90 bottom
R9005  33_5%_2  [R0201]  263.56 18.43 90 bottom
R9006  33_5%_2  [R0201]  263.96 19.95 180 bottom
R9007  33_5%_2  [R0201]  263.96 20.72 180 bottom
R9008  33_5%_2  [R0201]  265.84 18.4 90 bottom
R9009  *0_2/S  [S0201]  266.61 18.4 90 bottom
R9010  10_1%_4  [R0402]  267.49 18.51 270 bottom
R9011  1K_1%_4  [R0402]  135.16 113.22 0 top
R9012  20_1%_4  [R0402]  135.08 122.87 180 bottom
R9013  1K_1%_4  [R0402]  135.16 115.79 0 bottom
R9014  *1K_1%_4  [R0402]  135.16 112.23 0 top
R9015  *1K_1%_4  [R0402]  135.16 114.52 0 bottom
R9016  *0_4/S  [S0402]  270.92 17.62 180 bottom
R9017  13_1%_4  [R0402]  135.08 124.65 180 bottom
R9018  200_1%_4  [R0402]  168.31 139.03 270 top
R9019  1K_1%_4  [R0402]  168.31 137.25 270 top
R9020  *0_4/S  [S0402]  273.16 18.51 90 bottom
R9021  *0_4/S  [S0402]  274.15 18.51 90 bottom
R9026  *0_4/S  [S0402]  261.65 36.03 180 top
R9028  100K_1%_4  [R0402]  133.64 106.52 0 bottom
R9030  220_1%_4  [R0402]  132.49 118.07 0 top
R9031  49.9K_1%_4  [R0402]  273.21 20.28 90 bottom
R9032  49.9K_1%_4  [R0402]  274.23 20.28 90 bottom
R9033  *0_5%_4  [R0402]  187.1 126.58 180 bottom
R9034  100_1%_4  [R0402]  132.49 117.06 180 top
R9036  *0_5%_4  [S0402]  129.83 115.91 0 top
R9037  24.9/F_4  [R0402]  172.93 94.04 180 bottom
R9038  24.9_1%_4  [R0402]  183.93 131.03 0 bottom
R9039  20_1%_4  [R0402]  190.28 124.3 180 bottom
R9040  121_1%_4  [R0402]  172.93 93.02 0 bottom
R9041  75_1%_4  [R0402]  172.93 95.05 180 bottom
R9042  100_1%_4  [R0402]  172.93 96.07 0 bottom
R9043  *0_6  [R0603]  151.29 109.31 90 top
R9044  *0_6/S  [S0603]  147.86 109.31 90 top
R9045  *0_6/S  [S0603]  187.46 123.13 270 bottom
R9046  *0_6/S  [S0603]  187.36 128.11 180 bottom
R9047  100/F_4  [R0402]  161.7 130.39 180 bottom
R9048  100/F_4  [R0402]  158.15 130.39 0 bottom
R9049  *0_4/S  [S0402]  184.39 129 0 bottom
R9050  *0_4/S  [S0402]  184.39 130.01 0 bottom
R9052  30K_4  [R0402]  262.67 56.86 315 top
R9053  *30K_4  [R0402]  256.19 63.95 225 top
R9054  8.2K_1%_4  [R0402]  264.95 56.1 135 top
R9055  *30K_4  [R0402]  255.43 65.24 135 top
R9056  *10K/F_4  [R0402]  267.54 73.17 45 top
R9057  10K_1%_4  [R0402]  266.81 73.88 45 top
R9058  113/F_4  [R0402]  232.82 74.13 315 bottom
R9059  1K_1%_4  [R0402]  234.34 72.55 135 bottom
R9060  1K_1%_4  [R0402]  235.11 73.37 135 bottom
R9061  10_1%_4  [R0402]  268.26 72.48 45 top
R9062  10_1%_4  [R0402]  270.8 72.99 45 top
R9063  10_1%_4  [R0402]  269.02 71.72 45 top
R9064  10_1%_4  [R0402]  270.03 73.75 45 top
R9065  10K_1%_4  [R0402]  273.97 74.26 180 bottom
R9066  33_4  [R0402]  268.38 75.4 45 top
R9067  100K_1%_4  [R0402]  260.76 49.49 315 bottom
R9068  200K/F_4  [R0402]  256.24 71.03 225 top
R9071  10K_1%_4  [R0402]  268.76 59.91 135 bottom
R9072  *10K_1%_4  [R0402]  267.24 61.43 315 bottom
R9073  *10K_1%_4  [R0402]  257.31 67.19 45 top
R9074  10K_1%_4  [R0402]  258.09 66.45 225 top
R9075  10K_1%_4  [R0402]  260.46 67.2 45 top
R9076  *10K_1%_4  [R0402]  259.75 67.91 45 top
R9077  *10K_1%_4  [R0402]  268.76 59.91 135 top
R9078  10K_1%_4  [R0402]  267.24 61.43 315 top
R9079  100K_1%_4  [R0402]  269.91 74.39 225 bottom
R9080  33_4  [R0402]  252.64 90.51 0 bottom
R9081  33_4  [R0402]  251.12 93 90 bottom
R9082  10K_1%_4  [R0402]  266.58 77.13 225 top
R9083  *0_4/S  [S0402]  252.25 91.53 180 bottom
R9084  33_4  [R0402]  254.03 89.75 90 bottom
R9085  470/F_4  [R0402]  273.46 60.92 135 bottom
R9086  30K_4  [R0402]  255.43 89.07 0 bottom
R9087  30_4  [R0402]  243.87 82.13 315 bottom
R9088  33_4  [R0402]  256.45 87.85 0 bottom
R9089  *0_4/S  [S0402]  272.32 66.58 135 bottom
R9090  100K_1%_4  [R0402]  270.16 71.46 225 bottom
R9091  30_4  [R0402]  241.71 84.29 315 bottom
R9092  10K_1%_4  [R0402]  274.48 71.34 135 bottom
R9093  *0_4/S  [S0402]  275.75 66.99 90 bottom
R9094  10K_1%_4  [R0402]  274.55 65.76 135 bottom
R9095  0_4  [R0402]  280.32 49.39 90 bottom
R9097  *0_4  [R0402]  278.67 53.56 90 bottom
R9098  *0_4  [R0402]  276.41 54.4 90 bottom
R9099  *0_4/S  [S0402]  274.1 71.72 135 top
R9100  *0_4/S  [S0402]  272.06 66.32 135 top
R9101  10K_1%_4  [R0402]  253.98 84.16 90 top
R9102  0_4  [R0402]  267.24 73.75 180 bottom
R9103  1M_1%_4  [R0402]  267.37 76.42 225 bottom
R9104  *4.7K/F_4  [R0402]  272.96 70.83 225 bottom
R9105  100K_1%_4  [R0402]  287.94 48.58 180 bottom
R9106  10K_1%_4  [R0402]  330.62 27.6 180 bottom
R9107  0_4  [R0402]  271.81 71.97 225 top
R9110  4.7K/F_4  [R0402]  267.37 79.59 45 top
R9111  *0_4/S  [S0402]  239.3 80.61 315 bottom
R9112  *0_4/S  [S0402]  238.54 83.53 315 bottom
R9113  4.7K/F_4  [R0402]  266.35 80.48 45 top
R9114  *0_4/S  [S0402]  240.06 81.37 315 bottom
R9115  *0_4/S  [S0402]  240.82 79.08 315 bottom
R9116  4.7K/F_4  [R0402]  264.57 82.01 135 bottom
R9117  51_4  [R0402]  242.98 80.86 135 top
R9118  4.7K/F_4  [R0402]  263.05 79.72 225 bottom
R9119  150K/F_4  [R0402]  268.28 75.55 225 bottom
R9120  4.7K/F_4  [R0402]  262.8 83.4 135 bottom
R9121  *100K/F_4  [R0402]  261.53 81.24 225 bottom
R9122  *0_4  [R0402]  272.82 67.08 135 top
R9123  1K_1%_4  [R0402]  255 84.16 90 top
R9124  *51_4  [R0402]  241.59 79.85 135 bottom
R9125  4.7K/F_4  [R0402]  261.53 85.69 225 top
R9126  4.7K/F_4  [R0402]  264.95 81.75 45 top
R9127  20K/F_4  [R0402]  258.25 74.21 90 top
R9128  *0_4/S  [S0402]  273.72 70.07 45 top
R9129  *0_4/S  [S0402]  274.66 69.61 225 top
R9130  0_4  [R0402]  321.44 11.98 90 top
R9131  27K_4  [R0402]  310.09 15.25 0 top
R9132  100K_1%_4  [R0402]  272.83 70.96 225 top
R9133  *47K/F_4  [R0402]  320.43 11.98 270 top
R9134  *470K_4  [R0402]  271.81 68.92 225 top
R9135  1K_1%_4  [R0402]  262.92 84.67 315 bottom
R9136  27K_4  [R0402]  308.34 16.14 0 top
R9137  1K_1%_4  [R0402]  322.99 12.54 90 top
R9138  *20K/F_4  [R0402]  262.29 80.48 45 bottom
R9139  680K/F_4  [R0402]  269.78 70.96 45 top
R9141  2K/F_4  [R0402]  238.41 79.72 315 bottom
R9142  100K_1%_4  [R0402]  263.43 57.62 135 top
R9144  100K_1%_4  [R0402]  268.66 55.54 315 bottom
R9145  *10K_1%_4  [R0402]  251.24 88.99 270 bottom
R9148  10K_1%_4  [R0402]  266.33 54.04 135 bottom
R9149  100K_1%_4  [R0402]  267.24 58.38 315 bottom
R9150  *100K/F_4  [R0402]  265.72 59.91 135 bottom
R9151  *100K/F_4  [R0402]  268 59.15 315 bottom
R9152  100K_1%_4  [R0402]  266.48 60.67 135 bottom
R9153  100K_1%_4  [R0402]  259.92 80.58 45 top
R9154  *100K/F_4  [R0402]  258.91 77.74 225 top
R9157  10K_1%_4  [R0402]  262.67 63.72 45 top
R9158  *10K_1%_4  [R0402]  263.43 62.96 225 top
R9159  10K_1%_4  [R0402]  264.19 58.38 315 bottom
R9160  *10K_1%_4  [R0402]  265.72 56.96 135 bottom
R9161  619_4/F  [R0402]  236.46 81.5 315 bottom
R9164  30_4  [R0402]  237.22 82.26 135 bottom
R9165  *0_4/S  [S0402]  243.74 76.1 315 top
R9166  *100K/F_4  [R0402]  244.89 77.18 135 top
R9167  60.4/F_4  [R0402]  233.51 74.84 135 bottom
R9168  0_2  [R0201]  237.27 77.56 315 bottom
R9169  200K_1%_4  [R0402]  237.9 76.42 225 bottom
R9170  0_2  [R0201]  236.76 77.05 315 bottom
R9171  10K_1%_4  [R0402]  267.37 79.47 225 bottom
R9172  10K_1%_4  [R0402]  265.72 77.94 45 top
R9173  10K_1%_4  [R0402]  255.81 58.13 90 top
R9174  10K_1%_4  [R0402]  255.63 68.98 45 top
R9175  10M_4  [R0402]  270.41 64.99 225 bottom
R9176  10K_1%_4  [R0402]  264.32 52.16 135 bottom
R9177  10K_1%_4  [R0402]  254.67 61.3 0 top
R9178  10K_1%_4  [R0402]  268.18 78.65 225 bottom
R9179  10K_1%_4  [R0402]  262.67 53.81 135 top
R9180  10K_1%_4  [R0402]  256.34 68.16 45 top
R9181  10K_1%_4  [R0402]  258.86 53.18 135 bottom
R9182  10K_1%_4  [R0402]  261.14 52.29 315 bottom
R9183  10K_1%_4  [R0402]  259.62 53.81 135 top
R9184  10K_1%_4  [R0402]  259.62 53.94 135 bottom
R9185  10K_1%_4  [R0402]  256.83 58.13 90 top
R9186  10K_1%_4  [R0402]  261.14 55.34 135 top
R9187  10K_1%_4  [R0402]  264.19 76.42 225 top
R9188  100/F_4  [R0402]  235.11 61.99 45 bottom
R9189  200_1%_4  [R0402]  250.48 83.28 315 top
R9190  200_1%_4  [R0402]  251.57 83.58 315 top
R9191  200_1%_4  [R0402]  247.94 88.43 45 bottom
R9192  *20K/F_4  [R0402]  268.21 62.19 315 top
R9193  *4.7K/F_4  [R0402]  260.26 51.65 135 bottom
R9194  *4.7K/F_4  [R0402]  266 65.65 315 top
R9195  *30K_4  [R0402]  261.53 50.38 135 bottom
R9196  100K_1%_4  [R0402]  272.52 75.4 90 bottom
R9197  *0_4/S  [S0402]  267.05 58.03 315 top
R9199  *0_4/S  [S0402]  268 62.19 315 bottom
R9200  *0_4/S  [S0402]  271.3 59.02 315 bottom
R9201  30K_4  [R0402]  260.38 54.57 135 top
R9202  *0_4/S  [S0402]  264.19 64.61 315 top
R9203  *20K/F_4  [R0402]  267.81 58.78 135 top
R9204  10K_1%_4  [R0402]  269.63 77.21 225 bottom
R9205  1M/F_4  [R0402]  274.35 69.56 315 bottom
R9206  *100K_1%_4  [R0402]  269.4 53.3 135 bottom
R9207  *4.7K/F_4  [R0402]  266.4 60.64 315 top
R9208  10K_1%_4  [R0402]  265.56 53.41 315 bottom
R9210  100K_1%_4  [R0402]  268.89 77.94 225 bottom
R9211  20K/F_4  [R0402]  270.29 61.43 135 bottom
R9212  *4.7K/F_4  [R0402]  268.76 62.96 315 bottom
R9213  100K_1%_4  [R0402]  260.26 77.31 45 top
R9214  20K/F_4  [R0402]  270.29 61.43 135 top
R9215  *0_4  [R0402]  261.02 76.54 225 top
R9216  *100_4  [R0402]  266.78 66.33 135 top
R9220  100K_1%_4  [R0402]  260.89 61.43 135 top
R9221  100K_1%_4  [R0402]  258.35 58.83 90 top
R9223  100K_1%_4  [R0402]  256.45 72.73 135 top
R9224  *47K/F_4  [R0402]  259.37 84.42 225 top
R9225  10K_1%_4  [R0402]  261.65 80.86 225 top
R9227  10K/F_4  [R0402]  259.85 83.86 225 bottom
R9229  20K/F_4  [R0402]  259.75 87.09 225 bottom
R9231  *10K/F_4  [R0402]  257.44 86.43 225 bottom
R9232  2.2K_5%_4  [R0402]  105.92 3.34 270 top
R9234  2.2K_5%_4  [R0402]  103.92 3.34 270 top
R9236  100K_1%_4  [R0402]  259.06 84.67 45 bottom
R9237  100K_1%_4  [R0402]  258.2 85.64 45 bottom
R9239  100K_1%_4  [R0402]  262.41 80.1 45 top
R9240  *100K/F_4  [R0402]  257.46 83.28 45 top
R9241  10K_1%_4  [R0402]  271.05 54.95 135 bottom
R9242  2.2K_5%_4  [R0402]  349.54 63.08 180 bottom
R9243  2.2K_5%_4  [R0402]  244.63 82.89 135 bottom
R9244  2.2K_5%_4  [R0402]  248.95 73.5 0 top
R9245  2.2K_5%_4  [R0402]  248.06 75.53 0 top
R9246  2.2K_5%_4  [R0402]  248.95 74.51 0 top
R9247  2.2K_5%_4  [R0402]  248.06 77.76 315 top
R9248  *100K/F_4  [R0402]  265.72 77.94 225 bottom
R9249  100K_1%_4  [R0402]  250.48 77.81 315 top
R9250  100K_1%_4  [R0402]  251.75 75.78 315 top
R9251  100K_1%_4  [R0402]  249.99 76.39 225 top
R9252  100K_1%_4  [R0402]  253.12 71.52 270 top
R9253  10K_1%_4  [R0402]  261.91 62.45 135 top
R9255  *100K/F_4  [R0402]  259.49 50.89 135 bottom
R9256  *20K/F_4  [R0402]  258.1 52.41 315 bottom
R9257  *0_4/S  [S0402]  248.34 65.74 45 top
R9258  *0_4/S  [S0402]  254.79 81.5 90 top
R9259  *0_4/S  [S0402]  252.64 64.1 315 top
R9260  *0_4/S  [S0402]  231.8 73.05 315 bottom
R9261  2.2UH_0.7A  [R0603]  254.51 48.15 135 bottom
R9262  2.2UH_0.7A  [R0603]  230.41 69.43 315 bottom
R9263  *0_4/S  [S0402]  230.79 72.04 315 bottom
R9265  *0_4/S  [S0402]  247.89 68.7 135 top
R9266  *1K/F_4  [R0402]  245.21 70.95 0 top
R9267  *0_4/S  [S0402]  239.27 84.24 135 bottom
R9268  *0_4/S  [S0402]  246.29 78.83 135 top
R9269  *0_4/S  [S0402]  237.32 84.95 180 bottom
R9270  *0_4/S  [S0402]  242.35 80.61 135 bottom
R9271  *51_4  [R0402]  245.52 78.07 135 top
R9272  *51_4  [R0402]  243.11 81.37 135 bottom
R9273  *0_4/S  [S0402]  202.14 22.37 0 top
R9274  *0_4/S  [S0402]  202.14 21.35 0 top
R9275  *0_4/S  [S0402]  203.54 21.99 90 top
R9276  100K_1%_4  [R0402]  200.21 20.33 180 top
R9277  10K_1%_4  [R0402]  202.14 20.33 180 top
R9278  10K_1%_4  [R0402]  202.34 25.59 180 bottom
R9279  *0_4/S  [S0402]  202.34 24.57 0 bottom
R9280  100/F_4  [R0402]  198.15 24.32 270 bottom
R9281  100K_1%_4  [R0402]  198.15 26.22 90 bottom
R9282  *0_4/S  [S0402]  101.63 71.85 180 top
R9283  *0_4/S  [S0402]  188.63 153.38 0 bottom
R9284  *0_4/S  [S0402]  188.63 154.52 180 bottom
R9285  *0_4/S  [S0402]  264.7 19.01 0 top
R9286  *10K/F_4  [R0402]  309.02 59.83 90 top
R9287  10K_1%_4  [R0402]  310.04 59.81 270 top
R9288  100K_1%_4  [R0402]  309.66 61.18 0 top
R9299  150/F_4  [R0402]  247.56 85.56 225 bottom
R9300  *0_4/S  [S0402]  264.95 59.15 315 bottom
R9301  *360_1%_6  [R0603]  130.59 110.71 90 top
R9302  100_1%_4  [R0402]  135.16 118.2 0 bottom
R9303  51_5%_4  [R0402]  135.16 114.52 0 top
R9304  51_5%_4  [R0402]  132.49 116.04 180 top
R9305  *56.2_1%_4  [R0402]  135.41 117.95 270 top
R9306  51_5%_4  [R0402]  135.16 119.34 180 bottom
R9307  *51_5%_4  [R0402]  135.08 121.09 180 bottom
R9308  4.7K_1%_4  [R0402]  191.42 93.05 0 top
R9309  1K_1%_4  [R0402]  189.14 94.55 270 top
R9310  49.9/F_4  [R0402]  135.16 116.93 0 bottom
R9311  *54.9_1%_4  [R0402]  129.83 118.96 180 top
R9312  10K_1%_4  [R0402]  130.84 107.28 0 bottom
R9313  10K_1%_4  [R0402]  131.22 105.72 90 bottom
R9314  *0/S  [S0402]  132.49 119.09 0 top
R9315  *100K_1%_4  [R0402]  129.45 106.23 180 bottom
R9316  10K_1%_4  [R0402]  133.64 107.63 180 bottom
R9317  *10K_1%_4  [R0402]  133.64 98.61 270 bottom
R9318  56.2_1%_4  [R0402]  129.83 117.95 0 top
R9319  *0_5%_4  [R0402]  134.65 98.61 90 bottom
R9320  1K_1%_4  [R0402]  184.69 126.2 270 bottom
R9321  499_1%_4  [R0402]  187.1 125.57 180 bottom
R9322  100K_1%_4  [R0402]  268.05 64.51 315 top
R9323  *10K/F_4  [R0402]  264.07 76.49 45 bottom
R9324  100K_1%_4  [R0402]  255.94 81.88 90 top
R9325  *100K/F_4  [R0402]  254.57 72.28 135 top
R9326  100K_1%_4  [R0402]  258.15 78.42 45 top
R9327  100K_1%_4  [R0402]  255.56 66.51 315 top
R9328  100K_1%_4  [R0402]  253.4 35.9 180 top
R9329  100K_1%_4  [R0402]  245.78 39.21 90 top
R9330  10K_1%_4  [R0402]  256.45 36.79 180 top
R9335  *0_4/S  [S0402]  269.5 60.67 315 top
R9336  *0_4/S  [S0402]  259.24 75.78 225 top
R9337  *0_4/S  [S0402]  25.05 122.01 0 top
R9338  *100K/F_4  [R0402]  264.95 78.7 225 bottom
R9339  *0_4/S  [S0402]  261.78 65.19 135 top
R9340  60.4_1%_4  [R0402]  184.56 101.18 180 bottom
R9341  *0_4/S  [S0402]  258.96 68.92 45 top
R9342  *0_4/S  [S0402]  270.16 54.07 135 bottom
R9343  *0_4/S  [S0402]  271.05 75.73 225 bottom
R9344  *0_4  [R0402]  308.49 37.76 0 bottom
R9345  49.9_2  [R0201]  235.62 75.5 315 bottom
R9346  49.9_2  [R0201]  235.74 74.26 315 bottom
R9347  49.9_2  [R0201]  232.65 78.02 225 bottom
R9348  *0_4  [R0402]  233.38 76.98 315 bottom
R9349  *0_4/S  [S0402]  260.38 54.7 315 bottom
R9350  *0_4/S  [S0402]  261.07 55.41 315 bottom
R9351  *0_4/S  [S0402]  265.08 75.66 45 top
R9352  *10K/F_4  [R0402]  269.02 74.89 225 bottom
R9353  10K_1%_4  [R0402]  267.37 76.34 225 top
R9354  10K_1%_4  [R0402]  261.91 53.05 135 bottom
R9355  10K_1%_4  [R0402]  262.67 53.68 135 bottom
R9357  *0_4/S  [S0402]  258.99 87.85 45 bottom
R9358  *10K_1%_4  [R0402]  281.85 53.56 315 top
R9360  100K_1%_4  [R0402]  264.8 59.15 135 top
R9361  100K_1%_4  [R0402]  266.48 57.62 315 bottom
R9362  *0_4/S  [S0402]  263.99 55.29 315 bottom
R9363  *0_4/S  [S0402]  263.3 54.57 315 bottom
R9364  2.2K_5%_4  [R0402]  262.62 56.96 135 bottom
R9365  2.2K_5%_4  [R0402]  261.91 56.22 135 bottom
R9366  *10K/F_4  [R0402]  266.86 69.05 180 top
R9367  10K_1%_4  [R0402]  268.89 69.18 0 top
R9368  100K_1%_4  [R0402]  262.8 48.73 45 bottom
R9369  *100K_1%_4  [R0402]  262.41 51.02 315 bottom
R9370  *4.7K/F_4  [R0402]  297.72 58.54 180 top
R9371  *4.7K/F_4  [R0402]  246.26 82.03 315 top
R9372  *10K/F_4  [R0402]  248.19 80.35 135 top
R9373  *100K_1%_4  [R0402]  250.76 80.15 315 top
R9374  360_6  [R0603]  299.12 28.82 0 bottom
R9375  360_6  [R0603]  272.14 45.73 180 bottom
R9376  *100K_1%_4  [R0402]  265.08 71.97 315 top
R9377  33_5%_4  [R0402]  249.49 81.62 45 top
R9378  33_5%_4  [R0402]  246.64 86.21 225 top
R9379  10K_1%_4  [R0402]  259.52 49.11 180 top
R9380  10K_1%_4  [R0402]  274.25 53.41 90 bottom
R9381  *10K_1%_4  [R0402]  258.48 50.54 270 top
R9382  *10K_1%_4  [R0402]  273.82 55.16 270 bottom
R9383  *10K_1%_4  [R0402]  257.59 16.93 0 bottom
R9501  *0_6/S  [S0603]  263 9.67 180 bottom
R9502  4.7K_5%_2  [R0201]  241.74 4.15 270 top
R9503  *0_6/S  [S0603]  252.94 8.6 0 bottom
R9504  *0_4/S  [S0402]  257.08 9.67 90 bottom
R9505  *0_4/S  [S0402]  258.1 9.67 270 bottom
R9506  *0_4/S  [S0402]  259.14 9.67 270 bottom
R9507  *0_4/S  [S0402]  191.19 19.6 0 top
R9508  *0_4/S  [S0402]  192.03 18.28 0 top
R9509  10K_1%_4  [R0402]  260.94 6.57 180 top
R9512  *0_5%_4  [R0402]  191.19 21.3 180 top
R9513  4.7K_5%_2  [R0201]  239.05 4.15 90 top
R9514  4.7K_5%_2  [R0201]  240.98 4.15 90 top
R9525  *0_4/S  [S0402]  19.18 109.18 0 bottom
R9526  *0_4/S  [S0402]  19.18 108.17 0 bottom
R9527  *0_4/S  [S0402]  20.83 90.79 0 bottom
R9528  *0_4/S  [S0402]  20.83 89.78 0 bottom
R9531  *0_5%_4  [R0402]  22.77 110.45 270 bottom
R9533  *0_5%_4  [R0402]  22.13 106.49 0 top
R9535  *0_5%_4  [R0402]  24.42 90.9 0 top
R9543  *10K/F_4  [R0402]  263.43 61.56 225 top
R9544  10K/F_4  [R0402]  247.43 79.59 315 top
R9545  10K/F_4  [R0402]  248.9 82.41 225 top
R9546  20K/F_4  [R0402]  247.4 85.45 225 top
R9547  *0_4  [R0402]  260 75.02 225 top
R9549  330_4  [R0402]  16.67 112.1 270 top
R9550  330_4  [R0402]  14.51 135.12 90 top
R9586  *0_4  [R0402]  280.58 51.4 90 top
R9587  0_5%_2  [R0201]  235.87 77.94 315 bottom
R9588  100K_1%_4  [R0402]  263.13 73.09 45 top
R9589  100K_1%_4  [R0402]  353.6 108.04 180 top
R9590  0_5%_4  [R0402]  249.54 72.48 180 top
R9591  *0_4/S  [S0402]  250.27 71.46 0 top
R9592  4.7K/F_4  [R0402]  274.86 66.13 45 top
R9593  100K_1%_4  [R0402]  271.94 71.85 45 bottom
R9594  100K_1%_4  [R0402]  270.42 70.19 225 bottom
R9595  100K_1%_4  [R0402]  280.32 52.03 270 bottom
R9596  100K_1%_4  [R0402]  279.31 66 90 bottom
R9597  100K_1%_4  [R0402]  263.81 48.35 180 top
R9598  100K_1%_4  [R0402]  281.46 45.43 90 bottom
R9599  100K_1%_4  [R0402]  270.54 58.26 135 bottom
R9600  *100K_1%_4  [R0402]  270.54 70.19 225 top
R9602  *100K_1%_4  [R0402]  260.64 74 225 top
R9603  *100K_1%_4  [R0402]  252.64 89.17 180 bottom
R9604  *100K_1%_4  [R0402]  250.22 90.9 0 bottom
R9605  *100K_1%_4  [R0402]  254.92 87.64 270 bottom
R9606  10K_1%_4  [R0402]  258.15 82.46 225 top
R9607  10K_1%_4  [R0402]  253.07 73.34 315 top
R9614  *33_5%_4  [R0402]  293.35 62.4 0 bottom
R9615  *33_5%_4  [R0402]  306.99 35.27 270 bottom
R9616  *33_5%_4  [R0402]  295.28 60.72 0 bottom
R9617  *33_5%_4  [R0402]  292.84 60.9 90 bottom
R9618  *0_4  [R0402]  331.02 29.08 270 bottom
R9619  *0_4  [R0402]  287.53 49.93 270 bottom
R9620  *0_4  [R0402]  291.41 61.5 0 bottom
R9621  *0_4/S  [S0402]  291.8 61.89 270 bottom
R9622  *0_4/S  [S0402]  308.11 38.14 270 bottom
R9623  *0_4/S  [S0402]  287.92 49.54 180 bottom
R9624  *0_4/S  [S0402]  330.63 28.69 0 bottom
R9625  *100K_1%_4  [R0402]  361.35 86.45 0 top
R9626  *10K_1%_4  [R0402]  361.35 85.43 0 top
R9627  *360_6  [R0603]  318.94 40.72 180 top
R10000  *0_5%_4  [R0402]  324.01 68.29 90 bottom
R10001  *100K_1%_4  [R0402]  352.58 30.44 180 bottom
R10002  *1M_1%_4  [R0402]  352.58 31.46 0 bottom
R10003  *5.1M_5%_4  [R0402]  352.58 32.6 0 bottom
R10004  *0_5%_4  [R0402]  328.96 66.31 0 bottom
R10005  *0_5%_4  [R0402]  324.9 66.28 0 bottom
R10006  *0_5%_4  [R0402]  326.93 66.28 0 bottom
R10007  *0_5%_4  [R0402]  322.87 66.28 0 bottom
R10008  *0_5%_4  [R0402]  335.95 58.38 270 bottom
R10009  *5.1M_5%_4  [R0402]  357.23 31.23 90 bottom
R10010  *1M_1%_4  [R0402]  358.38 31.23 90 bottom
R10011  *0_5%_4  [R0402]  349.54 33.24 0 bottom
R10012  *100K_1%_4  [R0402]  356.39 27.78 90 top
R10013  *0_5%_4  [R0402]  348.14 35.14 270 bottom
R10014  *0_5%_4  [R0402]  351.19 37.17 270 bottom
R10015  *0_5%_4  [R0402]  348.01 39.08 270 bottom
R10016  *0_5%_4  [R0402]  350.37 41.75 270 bottom
R10017  *0_5%_4  [R0402]  342.93 29.17 0 bottom
R10018  *0_4/S  [S0402]  329.47 64.2 90 bottom
R10019  *0_4/S  [S0402]  328.45 64.2 90 bottom
R10020  *0_4/S  [S0402]  327.44 64.2 90 bottom
R10021  *0_4/S  [S0402]  326.42 64.2 90 bottom
R10022  *0_4/S  [S0402]  325.41 64.2 90 bottom
R10023  *0_4/S  [S0402]  324.39 64.2 90 bottom
R10024  *0_4/S  [S0402]  323.37 64.2 90 bottom
R10025  *0_4/S  [S0402]  322.36 64.2 90 bottom
R10026  *0_4/S  [S0402]  334.25 58.89 0 bottom
R10027  *0_4/S  [S0402]  334.25 57.75 0 bottom
R10028  *0_4/S  [S0402]  346.49 34.76 0 bottom
R10029  *0_4/S  [S0402]  346.49 35.78 0 bottom
R10030  *0_4/S  [S0402]  349.41 36.67 0 bottom
R10031  *0_4/S  [S0402]  349.41 37.68 0 bottom
R10032  *0_4/S  [S0402]  346.34 38.19 0 bottom
R10033  *0_4/S  [S0402]  346.34 39.21 0 bottom
R10034  *0_4/S  [S0402]  347.83 40.68 0 bottom
R10035  *0_4/S  [S0402]  347.83 41.7 0 bottom
R10036  *0_4/S  [S0402]  342.42 30.82 270 bottom
R10037  *0_4/S  [S0402]  343.57 30.82 270 bottom
R10038  *0_4/S  [S0402]  325.41 68.16 90 bottom
R10039  *0_4/S  [S0402]  349.54 34.25 0 bottom
R10040  100K_1%_4  [R0402]  209.07 95.34 270 top
R10041  100K_1%_4  [R0402]  210.09 95.34 270 top
R10042  100K_1%_4  [R0402]  207.04 95.34 270 top
R10043  100K_1%_4  [R0402]  208.06 95.34 270 top
R10048  *4.7K/F_4  [R0402]  270.34 76.42 45 bottom
R10049  *10K_4  [R0402]  353.22 41.4 270 bottom
R10050  *100K_5%_4  [R0402]  353.22 44.99 270 bottom
R10051  *10K_4  [R0402]  352.08 41.4 270 bottom
R10052  *100K_5%_4  [R0402]  352.08 44.99 270 bottom
R10053  *100K_5%_4  [R0402]  354.77 32.17 270 bottom
R10054  *10K_4  [R0402]  354.74 28.58 270 bottom
R10055  *100K_5%_4  [R0402]  355.91 32.17 270 bottom
R10056  *10K_4  [R0402]  355.89 28.58 270 bottom
R17879  100K_4  [R0402]  220 79.82 270 bottom
R17887  10K_1%_4  [R0402]  265.79 74.92 225 top
R17888  *10K_5%_2  [R0201]  249.38 36.11 0 top
R17898  *0_4/S  [S0402]  251.9 78.32 225 top
R17900  *0_4/S  [S0402]  232.14 69.2 0 top
R17901  *0_4/S  [S0402]  249.16 67.5 135 top
R17902  *0_5%_4  [R0402]  250.48 69.79 180 top
R17903  *0_5%_4  [R0402]  251.87 71.34 270 top
R17904  *0_4  [R0402]  253.57 81.32 270 top
R17906  *2.2K_5%_4  [R0402]  125.99 87.75 180 bottom
R17907  100K_1%_4  [R0402]  125.99 89.78 180 bottom
R17908  100K_1%_4  [R0402]  120.45 89.19 0 bottom
R17909  *0_4/S  [S0402]  251.75 65.37 45 top
R17910  *0_4/S  [S0402]  249.13 69.51 90 top
R17911  *0_4/S  [S0402]  120.45 88.13 180 bottom
R17930  220K_5%_2  [R0201]  358.81 135.09 90 top
R17931  220K_5%_2  [R0201]  358.81 133.95 270 top
R17932  220K_5%_2  [R0201]  359.82 128.74 270 bottom
R17933  220K_5%_2  [R0201]  359.82 130.01 90 bottom
R17934  220K_5%_2  [R0201]  359.7 118.45 90 top
R17935  220K_5%_2  [R0201]  359.7 117.18 270 top
R17936  220K_5%_2  [R0201]  360.08 111.98 270 bottom
R17937  220K_5%_2  [R0201]  360.08 113.12 90 bottom
R17938  *10K_1%_4  [R0402]  237.52 42.76 90 top
R17939  *10K_1%_4  [R0402]  243.19 52.26 90 top
R17940  100K_1%_4  [R0402]  242.98 49.49 180 top
R17941  *10K_1%_4  [R0402]  242.53 41.87 90 top
R17942  *10K_1%_4  [R0402]  261.27 15.71 90 top
R17943  *10K_1%_4  [R0402]  245.98 47.82 0 top
R17947  20K/F_4  [R0402]  246.46 83.89 45 top
R17948  20K/F_4  [R0402]  247.58 83 135 top
R17949  *4.7K/F_4  [R0402]  344.71 47.72 270 bottom
R17950  *4.7K/F_4  [R0402]  344.3 45.63 180 bottom
R17951  *4.7K/F_4  [R0402]  319.51 61.13 270 bottom
R17952  *4.7K/F_4  [R0402]  320.53 61.13 270 bottom
R17953  *10K_1%_4  [R0402]  247.78 43.25 0 top
R17956  *4.7K/F_4  [R0402]  350.78 10.16 180 top
R17958  *4.7K/F_4  [R0402]  266.63 63.36 135 top
R17963  BLM15AG121SN1D  [R0402]  334.45 28.51 180 top
R17964  *10K_1%_4  [R0402]  238.54 47 180 top
R17965  *10K_1%_4  [R0402]  236.56 52.54 180 top
R17966  *10K_1%_4  [R0402]  238.54 48.02 180 top
R17967  *10K_1%_4  [R0402]  231.05 54.07 0 bottom
R17972  *0_5%_4  [S0402]  317.41 62.04 0 bottom
R17973  *0_5%_4  [S0402]  334.27 32.2 0 bottom
R17974  *0_5%_4  [S0402]  321.27 67.43 180 bottom
R17975  *0_5%_4  [S0402]  331.65 61.79 0 bottom
R17977  *10K_1%_4  [R0402]  276.46 54.83 0 top
R17978  100K/F_4  [R0402]  279.03 51.02 180 top
R17979  *0_2/S  [S0201]  350.48 110.15 0 top
R17980  33_5%_4  [R0402]  294.16 47.46 270 top
R17981  *0_4/S  [S0402]  295.18 47.46 270 top
R17982  33_5%_4  [R0402]  298.61 47.97 180 top
R17983  33_5%_4  [R0402]  296.2 45.61 270 top
R17984  *0_4/S  [S0402]  261.02 33.11 180 top
R17985  *100K_1%_4  [R0402]  125.56 91.33 270 bottom
R17987  *0_5%_4  [R0402]  275.62 18.38 270 bottom
R17992  *0_4/S  [S0402]  275.88 20.28 270 bottom
R18002  4.7K_5%_4  [R0402]  52.89 60.77 270 top
R18003  4.7K_5%_4  [R0402]  50.07 64.45 0 top
R18004  *0_5%_4  [R0402]  50.07 65.47 0 top
R18005  *0_5%_4  [R0402]  51.87 60.77 270 top
R18006  10K/F_4  [R0402]  49.18 60.54 270 top
R18008  *0_4/S  [S0402]  263.89 34.33 90 top
R18011  10K/F_4  [R0402]  52.99 63.08 90 top
R18018  *0_4/S  [S0402]  348.01 93.44 180 bottom
R18019  *0_4/S  [S0402]  347.99 91.15 180 bottom
R18020  *0_4/S  [S0402]  342.07 94.81 270 top
R18021  *0_4/S  [S0402]  344.46 100.55 270 top
R18022  *0_4/S  [S0402]  261.91 56.1 315 top
R18023  10K_1%_4  [R0402]  263.43 54.57 315 top
R18024  100K_1%_4  [R0402]  51.57 64.61 270 top
R18043  75K/F_4  [R0402]  257.97 75.96 225 top
R18044  10K_1%_4  [R0402]  259.14 81.24 225 top
R18045  *100K/F_4  [R0402]  341.28 24.98 180 bottom
R18046  *100K/F_4  [R0402]  43.67 59.78 90 bottom
R18047  *360_6  [R0603]  319.73 44.3 180 top
R18064  1K_1%_2  [R0201]  348.67 113.25 270 top
R18066  71.5K_1%_4  [R0402]  340.65 67.53 0 top
R18067  *0_4/S  [S0402]  364.4 62.96 270 bottom
R18068  4.7K/F_4  [R0402]  350.17 58.51 0 bottom
R18069  *4.7K/F_4  [R0402]  351.95 58.51 0 bottom
R18070  *4.7K/F_4  [R0402]  353.35 58.89 270 bottom
R18071  *4.7K/F_4  [R0402]  363.63 59.78 180 bottom
R18072  *4.7K/F_4  [R0402]  363.63 58.76 180 bottom
R18073  *4.7K/F_4  [R0402]  363.63 57.75 180 bottom
R18074  *0_4/S  [S0402]  237.01 47.09 270 top
R18075  *0_4/S  [S0402]  240.37 43.91 0 top
R18076  *0_4/S  [S0402]  246.41 52.29 270 top
R18077  *0_4/S  [S0402]  360.33 55.2 90 top
R18078  4.99K_1%_4  [R0402]  363.63 54.7 180 bottom
R18079  10K_1%_4  [R0402]  363.63 56.73 180 bottom
R18088  0_5%_4  [R0402]  353.35 62.44 90 bottom
R18089  0_5%_4  [R0402]  359.32 53.68 90 bottom
R18090  0_5%_4  [R0402]  353.35 60.68 270 bottom
R18099  *0_5%_4  [R0402]  358.93 54.32 0 top
R18100  *0_5%_4  [R0402]  351.94 62.83 0 bottom
R18101  *0_5%_4  [R0402]  351.94 60.29 0 bottom
R18102  *0_4/S  [S0402]  244.38 48.99 270 top
R18103  *0_4/S  [S0402]  265.08 15.84 270 top
R18105  *0_4/S  [S0402]  359.19 43.28 90 top
R18106  *10K_1%_4  [R0402]  361.35 83.4 0 top
R18107  10K_1%_4  [R0402]  361.35 84.42 0 top
RP6800  10K_10P8R_6  [10P8R]  240.95 43.27 90 bottom
RV6000  EGA10402V05AH_0.2p  [R0402]  257.51 52.19 270 top
RV6001  EGA10402V05AH_0.2p  [R0402]  267.24 30.93 270 top
TP503  *TP  [TP2650]  318.68 58.79 180 bottom
TP505  *TP  [TP2650]  341.79 46.32 90 bottom
TP512  *TP  [TP2650]  333.71 49.72 180 bottom
TP513  *TP  [TP2650]  336.2 36.67 180 bottom
TP1000  *PAD  [TP2650]  160.18 45.43 180 bottom
TP1001  *PAD  [TP2650]  156.37 45.3 0 top
TP1002  *PAD  [TP2650]  155.48 45.68 180 bottom
TP1003  *PAD  [TP2650]  154.97 45.43 0 top
TP1004  *PAD  [TP2650]  154.08 27.9 180 bottom
TP1005  *PAD  [TP2650]  156.5 43.4 180 bottom
TP1006  *PAD  [TP2650]  155.61 27.9 180 bottom
TP1007  *PAD  [TP2650]  156.17 42.66 0 top
TP2000  *  [TP2050]  217.76 131.7 0 top
TP2001  *  [TP2050]  209.66 131.51 0 top
TP2002  *  [TP2050]  231.98 113.12 0 top
TP2003  *  [TP2050]  231.7 107.57 0 top
TP2004  *PAD  [TP2650]  196.53 105.75 90 bottom
TP2005  *PAD  [TP2650]  229.9 94.32 90 bottom
TP2006  *PAD  [TP2650]  220.12 94.53 180 bottom
TP2007  *PAD  [TP2650]  195.87 96.74 180 bottom
TP2008  *PAD  [TP2650]  196.37 98.64 0 bottom
TP2010  *  [TP2050]  215.65 105.27 0 top
TP2011  *PAD  [TP2650]  221.27 95.93 0 top
TP2012  *  [TP2050]  216.95 94.17 180 bottom
TP2014  *  [TP2050]  218.35 95.98 0 top
TP2015  *  [TP2050]  217.13 95.44 180 bottom
TP3600  *  [TP2650]  334.55 11.43 0 top
TP3601  *  [TP2650]  332.77 9.39 0 top
TP3602  *  [TP2650]  334.04 9.39 0 top
TP3603  *  [TP2650]  333.84 7.95 0 top
TP3604  *TP  [TP2050]  219.84 157.55 0 top
TP3605  *TP  [TP2050]  221.01 158.08 0 top
TP3606  *TP  [TP2050]  222.28 158.08 0 top
TP3607  *TP  [TP2050]  198.79 153.13 0 top
TP3608  *TP  [TP2050]  218.98 156.55 180 bottom
TP4000  *TP8  [TP2675]  31.4 123.92 180 bottom
TP4001  *TP8  [TP2675]  30.64 121.63 180 bottom
TP4002  *TP8  [TP2675]  30.26 122.01 0 top
TP4003  *TP8  [TP2675]  29.5 120.23 0 top
TP4100  *TP  [TP2050]  352.33 69.31 180 bottom
TP4101  *TP  [TP2050]  352.33 68.04 180 bottom
TP4102  *TP  [TP2050]  353.78 68.04 180 bottom
TP4103  *TP  [TP2050]  353.78 66.77 180 bottom
TP4104  *TP  [TP2050]  349.28 71.72 270 bottom
TP4105  *TP  [TP2050]  349.28 70.45 270 bottom
TP4106  *TP  [TP2050]  335.64 54.65 270 bottom
TP4107  *TP  [TP2050]  334.37 54.65 270 bottom
TP4108  *  [TP2650]  338.03 76.67 180 bottom
TP4109  *  [TP2650]  339.2 76.09 180 bottom
TP4110  *  [TP2650]  344.71 76.44 180 bottom
TP4200  *TP  [TP2050]  310.93 9.11 270 top
TP4201  *TP  [TP2050]  335.54 4.79 180 bottom
TP5100  *TP  [TP2050]  313.47 43.52 180 bottom
TP5102  *TP  [TP2050]  313.98 20.79 90 bottom
TP6201  *TP  [TP2675]  306.88 47.77 180 bottom
TP6202  *TP  [TP2675]  304.96 47.74 180 bottom
TP6203  *TP  [TP2675]  301.61 48.52 180 bottom
TP6204  *TP  [TP2675]  302.67 50.99 180 bottom
TP6205  *TP  [TP2675]  293.86 58.92 180 bottom
TP6206  *TP  [TP2675]  296.7 48.17 180 bottom
TP6207  *TP  [TP2675]  298.91 45.43 180 bottom
TP8000  *TP  [TP2050]  340.9 107.79 90 top
TP8001  *TP  [TP2050]  343.44 107.79 90 top
TP8002  *TP  [TP2050]  342.17 107.79 90 top
TP8003  *TP  [TP2050]  343.31 109.18 90 top
TP8005  *TP  [TP2050]  340.9 125.54 180 bottom
TP8006  *TP  [TP2050]  349.66 123.13 180 bottom
TP8007  *TP  [TP2050]  340.27 106.42 180 bottom
TP8008  *TP  [TP2050]  351.11 105.93 180 bottom
TP8009  *TP  [TP2675]  302.5 62.96 180 bottom
TP8010  *TP  [TP2675]  302.52 64.87 180 bottom
TP8519  *TP  [TP2050]  340.27 91.15 270 bottom
TP8520  *TP  [TP2050]  343.72 90.64 270 bottom
TP8522  *TP  [TP2050]  340.8 89.63 0 top
TP8523  *TP  [TP2050]  339.4 89.55 0 top
TP8524  *TP  [TP2050]  344.91 97.17 0 top
TP8525  *TP  [TP2050]  343.69 95.47 0 top
TP8526  *TP  [TP2050]  346.64 87.67 0 top
TP9000  *TP  [TP2050]  273.36 17.31 180 bottom
TP9001  *TP  [TP2050]  274.63 17.31 180 bottom
TP9002  *  [TP2650]  135.69 120.92 0 top
TP9003  *  [TP2650]  134.91 123.76 180 bottom
TP9004  *  [TP2650]  133.64 114.64 0 top
TP9005  *TP  [TP2050]  183.55 125.57 180 bottom
TP9006  *PAD  [TP2650]  128.02 105.93 0 bottom
TP9007  *  [TP2650]  133.13 99.66 0 top
TP9008  *  [TP2650]  132.37 98.52 0 top
TP9009  *TP  [TP2650]  261.4 72.99 135 top
TP9014  *TP  [TP2650]  273.31 72.63 225 bottom
TP9016  *  [TP2650]  257.33 70.83 45 top
TP9019  *TP  [TP2650]  258.73 82.13 180 bottom
TP9021  *  [TP2650]  265.92 74.92 45 bottom
TP9025  *TP  [TP2050]  269.02 60.8 270 bottom
TP9026  *TP  [TP2050]  253.19 76.34 90 top
TP9027  *TP  [TP2050]  251.72 72.61 90 top
TP9028  *TP  [TP2050]  262.8 76.95 270 bottom
TP9030  *TP  [TP2050]  268.28 72.48 270 bottom
TP9031  *TP  [TP2050]  268.82 58.08 270 bottom
TP9034  *  [TP2650]  134.53 118.28 0 top
TP9035  *  [TP2650]  134.53 119.55 0 top
TP9039  *  [TP2650]  247.63 86.96 180 bottom
TP9040  *TP  [TP2050]  263.71 77.84 180 bottom
TP9043  *TP  [TP2050]  257.38 59.58 0 top
TP9050  *TP  [TP2050]  177.71 96.48 180 bottom
TP9051  *TP  [TP2050]  183.29 99.1 180 bottom
TP9052  *TP  [TP2050]  184.72 99.1 180 bottom
TP9053  *TP  [TP2050]  134.91 99.91 180 bottom
TP9054  *TP  [TP2050]  129.19 128.23 180 bottom
TP9055  *TP  [TP2050]  129.83 129.76 180 bottom
TP9056  *TP  [TP2050]  228.68 69.51 180 bottom
TP9057  *TP  [TP2050]  229.65 68.5 180 bottom
TP9058  *TP  [TP2050]  251.49 46.32 180 bottom
TP9059  *TP  [TP2050]  252.76 46.32 180 bottom
TP9060  *TP  [TP2050]  249.33 89.24 180 bottom
TP9061  *TP  [TP2050]  267.49 67.65 0 top
TP9062  *TP  [TP2050]  250.35 90.01 180 bottom
TP9500  *TP  [TP2675]  251.77 6.85 0 bottom
TP9501  *TP  [TP2675]  260.1 9.08 0 bottom
TP9502  *TP  [TP2050]  187.74 17.9 180 top
TP11000  *TP  [TP2050]  249.69 12.36 180 bottom
TP11001  *TP  [TP2050]  243.77 10.58 180 bottom
TP11002  *TP  [TP2050]  242.3 10.12 180 bottom
TP16000  *TP  [TP2050]  99.78 20.89 0 top
TP22000  *TP  [TP2050]  41.82 69.94 0 top
TP22001  *TP  [TP2050]  43.69 60.54 0 top
TP22011  *  [TP2650]  243.62 85.31 180 bottom
TP22040  *  [TP2650]  272.85 25.64 0 top
TP22041  *PAD  [TP2650]  362.24 40.35 180 bottom
TP22042  *PAD  [TP2650]  362.24 41.62 180 bottom
TP22043  *PAD  [TP2650]  361.47 46.32 180 bottom
TP22044  *PAD  [TP2650]  361.47 47.59 180 bottom
TP22045  *PAD  [TP2650]  362.74 48.6 180 bottom
TP22046  *PAD  [TP2650]  362.73 49.88 180 bottom
TP22047  *PAD  [TP2650]  360.76 33.59 180 bottom
TP22048  *PAD  [TP2650]  360.76 34.86 180 bottom
TP22049  *PAD  [TP2650]  361.6 36.16 180 bottom
TP22050  *PAD  [TP2650]  361.6 37.43 180 bottom
TP22051  *PAD  [TP2650]  360.84 38.57 180 bottom
TP22052  *PAD  [TP2650]  360.84 39.84 180 bottom
TP22053  *PAD  [TP2650]  348.65 32.09 180 bottom
TP22054  *PAD  [TP2650]  349.92 32.09 180 bottom
TP22055  *PAD  [TP2650]  354.11 46.06 180 bottom
TP22056  *PAD  [TP2650]  355.38 46.06 180 bottom
TP22057  *PAD  [TP2650]  351.65 46.57 180 bottom
TP22058  *PAD  [TP2650]  352.92 46.57 180 bottom
TP22059  *PAD  [TP2650]  356.98 29.86 180 bottom
TP22060  *PAD  [TP2650]  358.63 29.86 180 bottom
TP22061  *PAD  [TP2650]  356.52 38.83 180 bottom
TP22062  *PAD  [TP2650]  356.52 37.56 180 bottom
TP22063  *PAD  [TP2650]  355.96 34.18 180 bottom
TP22064  *PAD  [TP2650]  354.69 34.18 180 bottom
TP22065  *PAD  [TP2650]  352.08 29.3 180 bottom
TP22066  *PAD  [TP2650]  349.16 30.7 180 bottom
TP22067  *PAD  [TP2650]  351.11 33.34 180 bottom
TP22068  *PAD  [TP2650]  360.59 44.03 180 bottom
TP22069  *TP  [TP2050]  350.04 112.61 0 top
TP22070  *TP  [TP2050]  31.15 124.3 0 top
TP98005  *TP  [TP2050]  188.88 53.05 180 bottom
TP98006  *TP  [TP2050]  187.51 52.92 180 bottom
TP98007  *TP  [TP2050]  204.88 49.75 270 top
TP98008  *TP  [TP2050]  204.88 51.02 270 top
U49  *MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  246.16 35.85 180 top
U500  PS8461QFN66GTR-A0  [QFN66-10X5-4-67P]  325.41 56.86 180 bottom
U501  PS8461QFN66GTR-A0  [QFN66-10X5-4-67P]  340.77 39.84 90 bottom
U600  PTN36001  [QFN12-1_25X2_1-4]  26.19 88.86 90 bottom
U601  PTN36001  [QFN12-1_25X2_1-4]  23.65 107.15 90 bottom
U603  PS8527B  [QFN20-4X4-5-21P-PS8527A]  61.63 49.87 180 top
U2000  N18P-Q3-A1  [BGA908-NVIDIA-N18P-Q3-A1]  214.18 112.2 180 bottom
U2001  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  225.08 85.49 0 top
U2004  *M74VHC1GT32DFT2G  [SSOP5-P-A-TOSHIBA-B]  202.09 90.77 90 bottom
U2005  M74VHC1GT32DFT2G  [SSOP5-P-A-TOSHIBA-B]  221.52 86.29 90 bottom
U2006  *NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  206.53 87.31 0 bottom
U2007  *NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  202.72 87.43 0 bottom
U2008  M74VHC1GT08DFT2G  [SOT353-1-2_125-65-5P]  225.08 82.89 0 top
U2009  M74VHC1GT08DFT2G  [SOT353-1-2_125-65-5P]  233.94 88.52 0 bottom
U2010  M74VHC1GT08DFT2G  [SOT353-1-2_125-65-5P]  230.31 87.95 90 bottom
U2011  M74VHC1GT08DFT2G  [SOT353-1-2_125-65-5P]  233.76 86.07 0 bottom
U3000  G5245AT11U  [SOT23-5]  52.86 53.18 180 top
U3001  G517C1T11U  [SOT23-5]  47.43 56.43 270 top
U3002  G517C1T11U  [SOT23-5]  30.49 50 90 bottom
U3003  G517H1T11U  [SOT23-5]  43.59 47.72 180 top
U3005  G517B1T11U  [SOT23-5]  14 55.59 0 bottom
U3007  PS8331A-A2  [QFN60-5X9-4-73P]  64.93 64.73 90 top
U3008  74LVC1G3157GW  [SC88-2_1-65-6P]  253.4 38.95 180 top
U3009  74LVC1G3157GW  [SC88-2_1-65-6P]  248.83 38.22 180 top
U3010  74LVC1G3157GW  [SC88-2_1-65-6P]  257.21 41.62 270 top
U3011  74LVC1G17GW  [SSOP5-P-A-TOSHIBA-B]  19.59 65.37 270 bottom
U3201  G524B1T11U  [SOT23-5-2_8-95-5P-G708]  353.47 87.47 0 bottom
U3600  CX8400-11Z  [QFN60-7X7-4-61P-0_85H]  339.63 10.28 180 top
U3601  HPA022642RTJR  [PWQFN20-4X4-5-30P]  351.95 23.33 90 top
U3602  TFA9891UK  [BGA49-NXP-TFA9891]  199.55 154.36 90 bottom
U3603  TFA9891UK  [BGA49-NXP-TFA9891]  222.03 157.28 0 bottom
U3606  74LVC1G3157GW  [SC88-2_1-65-6P]  200.18 158.33 0 top
U3607  *74LVC1G3157GW  [SC88-2_1-65-6P]  341.03 22.6 180 top
U4000  I219_VPRO  [QFN48-6X6-4-49P-SLG8LV630]  25.94 124.04 90 bottom
U4001  NA0069R LF  [TRF-15_6X9_4-1_27-25P]  25.43 140.68 90 top
U4100  AC-9560_V02  [MODULE-12X16-152P]  340.14 69.43 0 bottom
U4101  G517H1T11U  [SOT23-5]  328.3 75.27 90 bottom
U4102  74LVC1G32GW  [SC70-2_1-65-5P]  338.72 70.04 180 top
U4103  74LVC1G32GW  [SC70-2_1-65-5P]  339 73.67 180 top
U4200  74AUP1G97GM  [SOT363-2_1-65-6P]  341.28 21.97 90 bottom
U6001  NPCX797HA0BX  [BGA144-NUVOTON-NPCX797H]  268.89 27.27 90 bottom
U6002  FT8010MPX_MLP_8P  [MLP8-2X2-5-9P]  253.52 49.37 90 top
U6003  *SN74LVC2G07DCKR  [SC70-2_1-65-6P-0_95H]  266.61 13.17 0 top
U6004  G2129BAJ1U  [DFN8-1_4X1-35]  237.34 5.12 90 top
U6202  *WSON 8X6 BIOS SOCKET  [50950-0084N-001-8P-SOCKET]  309.53 53.21 90 bottom
U6203  EC ROM  [50951-0084N-001-8P-SOCKET]  293.12 53.56 180 bottom
U6204  W25Q256JVEIQ  [SON8-8X6-1_27-9P]  309.61 53.2 90 bottom
U6300  TC7SET00FU  [SOT353-2_1-65-5P-1_1H]  322.61 74.51 0 bottom
U6301  TC7SET00FU  [SOT353-2_1-65-5P-1_1H]  22.64 98.39 180 bottom
U6401  EMC1412-1-ACZL-TR  [MSOP8-4_9-65]  174.79 88.96 90 bottom
U6402  G708T1U  [SOT23-5-2_8-95-5P-G708]  124.87 112.1 0 top
U6500  SLB 9670VQ2.0 FW7.40  [QFN32-5X5-5-33P-SLB9645VQ]  296.8 52.08 180 top
U7000  PUSB3FR4  [UDFN10-2_5X1-5]  16.03 88.86 270 bottom
U7001  PUSB3FR4  [UDFN10-2_5X1-5]  16.29 107.15 270 bottom
U7002  PUSB3FR4  [UDFN10-2_5X1-5]  354.74 73.88 90 top
U7003  EM5213AJ-25  [SOT23-5]  353.35 84.04 270 top
U7004  EM5213AJ-25  [SOT23-5]  21.47 92.45 270 top
U7005  TPS2546  [QFN16-3X3-5-17P-WM9001]  23.53 100.55 0 top
U7112  NX5P3290AUKZ  [BGA16-NXP-NX5P3290A]  352.71 140.68 0 top
U7113  NX5P3290AUKZ  [BGA16-NXP-NX5P3290A]  345.88 132.09 180 top
U7300  AU9560-GBS  [SSOP28-7_8-65-2H]  284.39 15.05 180 bottom
U7301  RTS5258S-GRT  [QFN32-4X4-4-33P-0_9H]  29.34 69.36 270 bottom
U8000  AR ROM  [50951-0084N-001-8P-SOCKET]  307.88 63.51 270 bottom
U8001  Titan_Ridge_Host  [BGA337-INTEL-DSL6540]  345.16 114.25 270 bottom
U8500  CYPD5225-96BZXIT(0X35B8)  [BGA96-TEXAS-TPS65982]  342.93 95.09 270 bottom
U9000  *MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  276.51 68.04 135 top
U9001  *CPU_CFL-H_1440P  [BGA1440-INTEL-CFL-H]  159.08 113.7 180 bottom
U9002  PCH_CFL-H_874P  [BGA874-INTEL-CNL-PCH-H]  251.52 67.88 45 bottom
U9003  MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  263.43 78.2 45 top
U9500  HP2DCTR  [LGA12-2X2-5-HP2DCTR]  189.03 20.03 0 top
U12001  MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  277.83 52.8 180 top
U12002  *TC7SZ07FU  [SOT353-2_1-65-5P-1_1H]  351.42 107.94 90 top
U12003  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  50.2 62.7 180 top
U12005  *MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  332.01 71.36 270 top
U12006  PS8409AQFN48GTR2-A2  [QFN48-6X6-4-49P-PS8409]  358.3 58.76 90 bottom
VC3200  *TVM0G5R5M220R  [R0402]  358.55 84.16 90 top
VC3600  *AVLC 5S_4  [R0402]  355.51 3.39 90 top
VC3601  *AVLC 5S_4  [R0402]  356.24 12.44 0 top
VC3602  AVLC 5S_4  [R0402]  356.39 8.22 0 top
VC3603  *AVLC 5S_4  [R0402]  356.01 5.3 270 top
VC6000  *EGA10402V12A0_0.2p  [R0402]  255.05 31.08 270 top
VC6001  *EGA10402V12A0_0.2p  [R0402]  272.57 34.25 270 bottom
VC6002  *EGA10402V12A0_0.2p  [R0402]  275.37 34.51 270 bottom
VC7000  *AVLC5S_4  [R0402]  353.6 78.45 270 top
VC7001  *AVLC5S_4  [R0402]  16.24 105.73 90 top
VC7002  *AVLC5S_4  [R0402]  14.92 95.11 90 top
VRAM2500  GDDR5  [BGA170-HYNIX-H5GQ1H24MJR]  201.18 142.95 270 bottom
VRAM2501  GDDR5  [BGA170-HYNIX-H5GQ1H24MJR]  221.18 142.95 90 bottom
VRAM2502  GDDR5  [BGA170-HYNIX-H5GQ1H24MJR]  244.93 122.61 180 bottom
VRAM2503  GDDR5  [BGA170-HYNIX-H5GQ1H24MJR]  244.93 104.14 0 bottom
Y2000  27MHZ/10ppm  [XTL-3_2X2_5-2_2X1_6-0_9H]  227.5 91.49 180 bottom
Y4000  25MHZ +-10PPM  [XTL-3_2X2_5-2_2X1_7]  20.1 130.65 0 bottom
Y7300  *XTAL 12MHZ  [XTL-3_2X2_5-2_2X1_7]  288.2 22.52 0 bottom
Y8000  25MHZ/10ppm  [XTL-3_2X2_5-2_2X1_7-0_8H]  338.16 123.15 180 bottom
Y9000  24MHZ +-20PPM  [XTL-2X1_6-1_35X1_05]  234.86 79.47 225 bottom
Y9001  32.768KHZ/20ppm/ESR= 50Kohm  [XTL-3_2X1_5-2_5-0_8H]  272.3 63.11 45 bottom

## Library data of the parts
C400 C500-C520 C523-C530 C533-C552 C555-C563 C585-C600 C602 C605 C607-C610 C612 C613 C615 C616 C618 C619 C621 C625 C627-C635 C652 C653 C858 C859 C1000-C1029 C1031-C1088 C1090-C1117 C1119-C1124 C2231 C2527 C3000-C3004 C3006-C3034 C3036 C3037 C3039-C3042 C3044-C3047 C3084 C3085 C3201-C3205 C3207 C3600-C3621 C3626 C3631-C3670 C4006-C4009 C4101-C4104 C4106-C4112 C4200 C4202-C4204 C4206-C4211 C4214-C4218 C4221-C4223 C5001-C5003 C5100-C5107 C5112-C5115 C6001-C6004 C6006-C6009 C6011 C6012 C6015 C6016 C6018-C6020 C6022 C6029-C6033 C6038 C6039 C6201-C6204 C6300-C6309 C6351-C6355 C6401-C6403 C6500-C6504 C6800-C6831 C7000-C7009 C7013-C7018 C7020 C7022 C7100 C7102 C7104 C7105 C7108-C7111 C7138-C7141 C7146 C7147 C7154 C7155 C7200 C7201 C7316-C7324 C7326-C7331 C8000-C8010 C8014-C8016 C8018-C8031 C8033 C8035-C8040 C8042 C8044-C8047 C8050-C8091 C8502 C8506-C8508 C8511-C8513 C8580 C8586 C8587 C8613 C9072-C9075 C9081-C9093 C9097-C9101 C9104 C9107-C9116 C9124-C9132 C9137-C9163 C9166 C9167 C9170 C9171 C9174 C9175 C9178 C9179 C9182-C9217 C9219-C9228 C9230-C9235 C9237 C9238 C9245 C9246 C9248-C9251 C9255 C9256 C9262-C9300 C9303 C9305 C9306 C9500-C9502 C10000-C10023 C12021-C12027 C12037 C12043-C12049 C12051 C12052 C12054-C12058 C12060-C12066 EC3600-EC3605 EC5101 EC5102 EC5104 EC9000-EC9003 EC9011 EC9013 EC9015-EC9020 EC9022-EC9032 EC9034 EC9037 EC9040 EC9041 EC9044-EC9046 PC8001 PC8002 PC8005-PC8012 PC8014-PC8017 PC9002 PC9011 PC9013-PC9015 PC9023 PC9024 PC9030-PC9035 PC9042 PC9045 PC9046 PC9211 PC9501-PC9511 PC9804 PC9805 PC9808 PC10000-PC10003 PC11000 PC11001 PC11003-PC11013 PC11018-PC11027 PC12001-PC12009 PC13000 PC13003-PC13005 PC13007 PC13012-PC13015 PC13018-PC13021 PC13023-PC13029 PC13032-PC13036 PC13040 PC13042-PC13044 PC16013-PC16017 PC16019 PC19000-PC19008 PC19010-PC19014 PC20004 PC20005 PC20009-PC20012 PC20016 PC20017 PC20019-PC20022 PC20030 PC20031 PC20033-PC20036 PC20040 PC20041 PC20043-PC20046 PC21000 PC21001 PC21003-PC21006 PC21010-PC21013 PC21015-PC21018 PC21022-PC21028 PC21030 PC21035 PC23018 PC25008 PC25009 PC25014 VC3200 VC3600-VC3603 VC7000-VC7002 = CAP NON-POL_BGM
C521 C522 C531 C532 C553 C554 C564 C565 C3056 C3057 C3066-C3083 C4000 C4001 = C_0
C2003-C2009 C2027 C2028 C2038 C2042-C2074 C2076-C2145 C2147-C2151 C2153-C2162 C2164 C2166-C2177 C2179-C2203 C2215-C2230 C2500-C2526 C2528-C2623 C4019 C4100 C4205 C4225 C4226 C5121 C5122 C6017 C7103 C7107 C7152 C7153 C8011-C8013 C8017 C8032 C8034 C8041 C8043 C9000-C9067 C9069 C9070 C9076-C9080 C9094-C9096 C9102 C9117-C9123 C9133-C9136 C9301 C9302 C9304 C12042 EC5103 EC9004 EC9005 EC9008-EC9010 EC9012 EC9014 EC9039 EC9043 PC8003 PC8004 PC9001 PC9003 PC9004 PC9006 PC9009 PC9010 PC9017-PC9020 PC9022 PC9037 PC9038 PC9040 PC9041 PC9044 PC9512-PC9516 PC9801-PC9803 PC9806 PC9807 PC9809 PC10004 PC12010 PC12011 PC13006 PC13016 PC13017 PC13022 PC13030 PC13031 PC14003 PC14004 PC14006 PC14013 PC14018 PC15002 PC15004 PC15006 PC16001 PC16005 PC16006 PC17002 PC17003 PC17007 PC18000-PC18015 PC19009 PC20000-PC20003 PC20013-PC20015 PC20018 PC20027-PC20029 PC20032 PC20037-PC20039 PC20042 PC20047 PC21009 PC21021 PC21029 PC21031-PC21034 PC23017 = CAP_NON-POL_BGM
C2075 C2146 C2178 PC11017 PC13011 PC13041 PC20006 PC20007 PC21007 PC25007 PC25010-PC25013 = CAP_POL_BGM
C4002 = C_5
C4003-C4005 C4011 C4013 C4015 C4017 C4105 C4201 C4213 C4224 C7325 C7332 EC9006 EC9007 EC9033 EC9036 EC9038 EC9042 = C
C4010 = C_7
C4012 C4014 C4016 C4018 C7300 C7304 C7306 C7308 C7309 C7313 = CAP NP_0
C4212 C4219 C7019 C7021 C7023 C9068 C9103 C9257 PC9007 PC9008 PC9026-PC9029 PC9043 PC20008 PC20023-PC20026 PC21008 PC21019 PC21020 = CAP POL_BGM
C4220 EC9021 EC9047-EC9051 PC14000-PC14002 PC14005 PC14007-PC14012 PC14014-PC14017 PC14019 PC15000 PC15001 PC15003 PC15005 PC15007-PC15012 PC16000 PC16002-PC16004 PC16007-PC16012 PC16018 PC17000 PC17001 PC17004-PC17006 PC17008-PC17012 PC22000-PC22032 PC23005-PC23016 PC24000 PC25000-PC25005 = CAP_NP
C7010-C7012 = PESD5V0X2UM_BGM
C7301-C7303 C7305 C7307 C7310 C7312 = 0_1.1U
C7311 = C_8
C7314 C7315 = CAP NP
CAS31 CAS33 CAS35 CAS37 CAS39-CAS41 CAS44-CAS46 CAS48 CAS50 CAS51 CAS59 CAS65 CAS66 CAS68 CAS69 = Shielding Case
CON400 = XDP_0
CON401 = CON30X1_9
CON3000 = GS12401-1011_0
CON3001 = 53398-0410_2
CON3002 CON3602 = 53398-0410_6
CON3200 = CON40A_0
CON3601 = AUDIO_2SJ3088-027211F_7P_BGM
CON4000 = RJ45_12P_2RJ1729-000111F_BGM_0
CON4200 = HEADER6_0
CON4201 CON5100 CON5101 = NGFF CONN_0
CON5000 = Serial ATA_4
CON6000 = 53398-0410_4
CON6300 CON6301 CON6351 CON6352 = 53398-0410_0
CON6800 = AF1263-A2G1T_1
CON6801 CON7200 = HEADER 12_1
CON7000-CON7002 = HEADER 4_0
CON7100 CON7101 = TYPEC_0
CON7300 = CON40A_5
CON7301 = CRD_19P_4F_BGM
CON9000 = HEADER 3_0
CON9500 = CON40A_2
CON10002 = 53398-0410_1
D2003 D2004 D3001 D3002 D4200 D6000 D6001 D7170 D7171 D8000 D9003 = Schottky_DIODE_BGM_0
D2008 PD25000 = BAT54A_BGM
D3600 = DA204U_0
D5100 D5101 = DIODE
D6800-D6803 = BAW56DW_1
D7100 D7102 D7103 D7119 = TVS_DIODE_BGM
D7101 D7118 PD1-PD3 PD11000 PD11002 PD11006 = ZENER_DIODE_BGM
D7104-D7117 D7120-D7133 = VPORT0603_0
D7300-D7307 VC6000-VC6002 = Varistor_BGM

# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR0_ALERT#: length 65
  TOP w0.102: JDIM1000.116 142.35,55.38 141.49,54.51 141.49,53.04 v1(141.9,52.63)
  IN4 w0.076: 151.61,90.55 151.7,90.64 151.7,96.65 151.65,96.7 v1(151.65,97.23)
  IN4 w0.152: v1(141.9,52.63) 141.36,53.16 141.36,59.99 140.79,60.56 140.79,66.93 141.36,67.51 141.36,71.56 151.34,81.53 151.34,90.28 151.61,90.55
  BOTTOM w0.076: U9001.AU5 151.47,102.39 151.47,99.12 151.35,99
  BOTTOM w0.102: 151.35,99 151.21,98.86 151.21,97.66 v1(151.65,97.23) ; JDIM1001.116 142.35,49.86 142.61,50.12 142.61,51.92 v1(141.9,52.63)
DDR0_PAR: length 66.4
  TOP w0.102: JDIM1000.143 149.1,49.56 150.27,50.72 150.27,53.65 v1(150.81,54.18)
  IN4 w0.114: v1(158.72,95.37) 158.22,94.87 158.22,88.66 159.98,86.9 159.98,77.93 150.81,68.76 150.81,64.19 150.42,63.8 150.42,55.4 150.81,55.01 v1(150.81,54.18)
  BOTTOM w0.076: v1(158.72,95.37) 159.09,95.37 159.62,95.9 159.62,97.36 160.23,97.97 160.23,100.03 160.05,100.21 160.05,101.39 U9001.AG3
  BOTTOM w0.102: JDIM1001.143 149.1,55.66 148.62,55.18 148.62,54.11 148.75,53.98 149.03,53.98 149.16,54.11 149.16,54.97 149.37,55.18 149.81,55.18 v1(150.81,54.18)
DDR1_ALERT#: length 88.9
  TOP w0.102: JDIM1003.116 142.35,39.29 142.13,39.06 142.13,36.73 142,36.59 141.76,36.59 141.64,36.72 141.64,38.53 141.54,38.63 141.26,38.63 141.11,38.47 v1(141.11,37.64)
  IN1 w0.076: 154.34,104.11 154.71,104.47 154.71,104.81 154.53,104.98 154.53,105.07 v1(154.33,105.27)
  IN1 w0.152: 154.34,104.11 154.15,103.91 154.15,94.75 153.47,94.07 153.47,88.71 141.45,76.68 141.45,62.34 140.78,61.67 140.78,56.54 140.01,55.78 140.01,48.07 140.3,47.78 140.3,40.09 141.11,39.28 v1(141.11,37.64)
  BOTTOM w0.076: U9001.AR8 154.01,104.95 v1(154.33,105.27)
  BOTTOM w0.102: JDIM1002.116 142.35,33.18 141.76,33.78 141.76,34.23 140.7,35.3 140.7,37.23 v1(141.11,37.64)
DDR1_PAR: length 87.6
  TOP w0.102: JDIM1003.143 149.1,33.01 149.23,33.14 149.36,33.14 149.64,32.86 150.76,32.86 150.88,32.98 150.88,33.24 150.76,33.36 149.74,33.36 149.31,33.8 149.31,34.81 149.65,35.15 v1(149.96,35.15)
  IN1 w0.076: 159.55,88.32 159.55,100.52 159.45,100.61 159.45,103.96 158.9,104.51 v1(158.9,104.62)
  IN1 w0.114: 159.55,88.32 159.55,88.17 159.78,87.94 159.78,82.81 152.35,75.38 152.35,65.65 151.78,65.08 151.78,55.93 152.78,54.93 152.78,48.19 150.48,45.89 150.48,36.66 149.96,36.13 v1(149.96,35.15)
  BOTTOM w0.076: v1(158.9,104.62) 158.58,104.3 U9001.AJ7
  BOTTOM w0.102: JDIM1002.143 149.1,38.6 149.96,37.75 v1(149.96,35.15)
DDR_DRAMRST#: length 218.4
  TOP w0.102: v1(139.29,33.87) 138.39,34.77 138.39,37.9 139.21,38.72 139.68,38.72 140.35,39.4 JDIM1003.108 ; JDIM1000.108 140.35,55.17 139.81,54.62 139.81,51.82 v1(139.4,51.41)
  IN2 w0.089: v1(273.59,61.94) 273.21,61.94 271.48,60.22 271.48,58.87 270.47,57.86 270.47,55.88 269.77,55.18 269.77,54.35 267.27,51.85 267.27,49.9 266.07,48.7 266.07,48.3 264.85,47.08 264.45,47.08 259.3,41.94 259.3,40.26 258.9,39.86 258.9,38.44 257.89,37.44 255.34,37.44 252.84,34.93 251.96,34.93 249.49,32.47 248.65,32.47 245.18,29 238.32,29 237.01,27.69 234.65,27.69 232.53,25.57 223.6,25.57 218.83,20.8 216.38,20.8 214.88,19.3 205.38,19.3 204.91,19.78 195.84,19.78 195.36,19.3 194.95,19.3 194.28,19.97 192.3,19.97 191.65,19.32 182.19,19.32 180.49,17.62 175.5,17.62 174.71,16.83 172.37,16.83 171.95,17.25 163.85,17.25 162.95,18.16 143.54,18.16 v1(143.16,17.78)
  IN3 w0.089: v1(139.4,51.41) 138.59,50.6 138.59,42.06 138.72,41.93 138.72,39.59 138.46,39.33 138.46,34.7 v1(139.29,33.87) 140.62,32.54 v1(140.62,30.7)
  BOTTOM w0.102: JDIM1002.108 140.35,30.96 v1(140.62,30.7) 140.62,30.41 ; JDIM1001.108 140.35,50.05 139.91,50.49 139.91,50.9 v1(139.4,51.41)
  BOTTOM w0.114: R9085.1 273.59,61.6 v1(273.59,61.94) 273.59,62.19 274.28,62.89 274.58,62.89 275.08,63.39 275.08,63.81 275.09,63.82 275.09,64.43 274.19,65.33 C9187.1 R9089.2 ; 140.62,30.41 140.62,29.43 141.13,28.92 141.13,26.37 C1093.2 C1059.2 C1031.2 C1001.2 141.63,19.31 v1(143.16,17.78)
DDR_DRAMRST#_L: length 7.9
  BOTTOM w0.114: U9002.BB46 265.63,66.42 266.36,65.68 267.38,65.68 267.49,65.79 269.26,65.79 269.72,66.26 271.46,66.26 v1(271.69,66.03) 271.94,66.28 271.94,66.75 R9089.1
DDR_PG_CNTL: length 5.7
  BOTTOM w0.076: U9001.BT13 137.82,108.41 137.04,107.63 136.4,107.63 135.79,107.02 135.32,107.02 135.2,106.9 135.07,106.9
  BOTTOM w0.114: R9316.2 134.76,106.9 v1(134.91,106.9) 135.07,106.9
DDR_VTT_PG_CTRL: length 53.3
  TOP w0.114: R9282.1 101.24,72.09 101.63,72.48 102.23,72.48 v1(102.65,72.07)
  IN1 w0.076: v1(128.76,103.95) 128.38,103.57 126.13,103.57 115.87,93.31 115.87,88.55 113.66,86.34 113.66,79.84 105.88,72.07 v1(102.65,72.07)
  BOTTOM w0.114: v1(102.65,72.07) 102.27,72.45 102.27,73.12 ; v1(128.76,103.95) 128.8,103.99 Q9003.3 128.8,105.37 129.06,105.63 R9315.1 130.1,107.28 R9312.2
DDR_VTTREF: length 3.1
  TOP w0.114: PR14005.1 94,60.93 94.14,60.8 94.77,60.8 v1(95.16,60.42)
  TOP w0.381: PR14005.1 92.99,61.3 PC14014.1
DDRA_ACT#: length 67
  TOP w0.102: JDIM1000.114 141.85,55.39 141.29,54.83 141.29,52.6 v1(141.9,51.99)
  IN4 w0.076: v1(150.81,96.83) 151.51,96.13 151.51,90.96 151.42,90.86
  IN4 w0.114: 151.42,90.86 150.83,90.27 150.83,81.75 140.85,71.77 140.85,67.72 140.27,67.14 140.27,60.35 140.85,59.77 140.85,52.95 141.8,51.99 v1(141.9,51.99)
  BOTTOM w0.076: U9001.AU3 151.77,101.39 151.77,99.26 152.04,98.99 152.04,97.05 151.82,96.83 v1(150.81,96.83)
  BOTTOM w0.102: v1(141.9,51.99) 140.92,51.99 140.6,51.67 140.6,51.01 141.45,50.16 141.45,49.78 141.85,49.37 JDIM1001.114
DDRB_ACT#: length 91.1
  TOP w0.102: v1(140.19,34.84) 139.72,35.31 139.72,37.37 141.85,39.51 JDIM1003.114
  IN1 w0.076: 152.85,96.32 152.85,103.49 153.8,104.43 153.8,105.54 v1(153.42,105.92)
  IN1 w0.114: v1(140.19,34.84) 139.71,35.32 139.71,38.77 138.95,39.52 138.95,43.09 138.08,43.96 138.08,59.24 139.2,60.36 139.2,62.01 140.09,62.9 140.09,77.26 152.85,90.01 152.85,96.32
  BOTTOM w0.076: U9001.AT9 153.09,105.6 v1(153.42,105.92)
  BOTTOM w0.102: v1(140.19,34.84) 139.99,34.64 139.99,34.27 140.27,33.99 140.48,33.99 140.75,34.25 140.93,34.25 141.1,34.08 141.1,33.9 140.84,33.65 140.84,33.4 141,33.24 141.26,33.24 141.51,33.49 141.76,33.49 141.85,33.4 JDIM1002.114
DDSP_1_HPD0: length 97.5
  TOP w0.114: R9249.2 249.68,78.62 v1(249.56,78.62)
  IN2 w0.089: v1(321.79,52.87) 320.45,51.53 315.75,51.53 315.5,51.78 300.01,51.78 298.23,53.56 294.16,53.56 293.92,53.79 292.15,53.79 287.41,58.53 287.41,60.21 285.89,61.73 281.58,61.73 278.99,64.32 278.99,65.74 279,65.75 279,66.58 278.27,67.31 277.35,68.23 275.67,68.23 275.19,68.72 274.71,68.72 273.97,69.46 273.43,69.46 271.37,71.52 270.41,71.52 268.71,73.22 268.15,73.22 266.35,75.02 265.98,75.02 265.72,75.29 265.36,75.29 262.57,78.08 262.57,78.47 261.96,79.07 261.96,80.15 260.6,81.52 259.67,81.52 259.28,81.9 258.37,81.9 257.49,82.79 257.49,83.37 257.28,83.58 257.28,84.13 256.83,84.59 255.31,84.59 254.87,84.15 254.87,82.82 253.35,81.29 251.37,81.29 251.24,81.17 251.24,80.74 250.66,80.16 250.66,79.69 249.59,78.62 v1(249.56,78.62)
  BOTTOM w0.114: U9002.AT6 249.12,78.62 v1(249.56,78.62) ; U500.19 322.61,53.96 321.79,53.15 v1(321.79,52.87)
DDSP_1_HPD1: length 129.5
  TOP w0.114: R9250.2 250.62,76.06 v1(250.47,75.91)
  IN1 w0.076: v1(317.53,36.81) 317.8,36.54 318.42,36.54 319.69,35.27 322.1,35.27 322.49,34.89 334.17,34.89 337.85,38.57 337.85,42.24 v1(337.45,42.64)
  IN2 w0.089: v1(317.53,36.81) 315.58,38.76 315.58,41.88 312.17,45.3 312.17,46.85 307.67,51.35 299.94,51.35 298.13,53.15 293.93,53.15 293.72,53.35 292.08,53.35 290.39,55.05 289.47,55.05 288.1,56.42 284.19,56.42 284.09,56.52 283.99,56.54 283.98,56.54 283.48,56.74 283.4,56.8 283.34,56.84 283.04,57.04 282.65,57.43 282.32,57.92 282.32,57.95 282.15,58.37 282.13,58.48 281.69,58.92 281.69,61.09 278.63,64.14 278.63,66.44 277.2,67.88 275.52,67.88 275.04,68.36 273.07,68.36 272.69,68.74 272.69,68.96 268.75,72.91 268.21,72.91 266.3,74.82 265.94,74.82 265.64,75.11 265.29,75.11 262.39,78.01 262.39,78.39 261.79,79 261.79,80.08 260.53,81.34 259.5,81.34 259.11,81.73 258.29,81.73 257.31,82.71 257.31,83.3 257.08,83.53 257.08,84.08 256.75,84.41 255.39,84.41 255.28,84.3 255.28,83.2 255.25,83.17 255.25,82.37 253.44,80.56 253.44,79.29 252.34,78.19 252.34,77.89 251.87,77.42 251.87,76.8 250.98,75.91 v1(250.47,75.91)
  BOTTOM w0.114: U9002.AN10 250.13,76.25 v1(250.47,75.91) ; v1(337.45,42.64) U501.19
DEBUG_DP0_AUXN: length 3.7
  BOTTOM w0.114: TP22057.1 351.98,46.57 352.1,46.45 352.1,46.22 352.55,45.78 352.55,45.07 R10052.1 C10009.2
DEBUG_DP0_AUXN_R: length 34.4
  IN2 w0.089: v1(336.58,58.64) 336.32,58.37 336.12,58.37 335.73,57.98 335.73,57.64 336.98,56.4 336.98,53.29 337.05,53.22 337.05,52.79 338.72,51.11 341.9,51.11 342.26,50.75 342.26,48.91 343.27,47.89 344.11,47.89 345.15,46.85 345.15,45.73 347.22,43.66 349.17,43.66 349.41,43.91 350.58,43.91 352.85,41.63 352.85,40.36 v1(352.61,40.12)
  BOTTOM w0.114: v1(336.58,58.64) 336.45,58.77 R10008.2 ; v1(352.61,40.12) 352.53,40.2 352.53,41.33 R10051.2 C10009.1
DEBUG_DP0_AUXP: length 3.9
  BOTTOM w0.114: C10008.2 R10050.1 352.77,45.05 352.77,45.88 352.33,46.32 352.33,46.42 352.49,46.57 TP22058.1
DEBUG_DP0_AUXP_R: length 34.4
  IN2 w0.089: v1(336.58,58) 336.4,58.18 336.2,58.18 335.92,57.9 335.92,57.72 337.17,56.48 337.17,53.37 337.24,53.3 337.24,52.87 338.8,51.3 341.98,51.3 342.45,50.83 342.45,48.99 343.35,48.08 344.19,48.08 345.35,46.93 345.35,45.81 347.3,43.86 349.09,43.86 349.33,44.1 350.66,44.1 353.04,41.71 353.04,40.32 v1(353.24,40.12)
  BOTTOM w0.114: R10008.1 335.96,58 v1(336.58,58) ; C10008.1 R10049.2 352.85,41.79 352.76,41.7 352.76,40.6 v1(353.24,40.12)
DEBUG_DP0_HPD: length 185.9
  TOP w0.114: v1(351.19,30.06) 351.54,30.06 353.67,32.19 353.67,38.25 v1(353.35,38.57) ; R2140.2 232.34,90.29 232.95,90.9 236.74,90.9 v1(237.23,90.41)
  IN1 w0.076: v1(251.92,93.13) 251.92,93.03 252.66,92.29 257.87,92.29 259.95,90.21 260.94,90.21 261.44,89.71 261.44,88.46 273.68,76.22 273.96,76.22 275.75,74.44 276.82,74.44 279.28,71.97 281.31,71.97 281.67,72.33 282.12,72.33 283.52,70.93 283.52,69.08 284.83,67.77 286.81,67.77 291.42,63.16 291.66,62.92 292.98,62.92 293.94,61.97 302.29,61.97 302.75,62.42 307.7,62.42 308.34,63.06 308.34,66.21 309.68,67.55 317.07,67.55 319.49,69.97 322.36,69.97 323.55,68.77 324.47,68.77 v1(324.77,69.08)
  IN2 w0.089: v1(324.77,69.08) 324.49,68.8 323.37,68.8 322.05,67.48 322.05,65.2 322.98,64.28 323.91,64.28 324.06,64.13 324.1,64.13 324.77,63.46 324.77,62.7 326.04,61.43 327.13,61.43 331.07,57.5 331.07,56.65 331.62,56.1 332.39,56.1 334.37,54.12 334.37,52.86 334.42,52.81 334.42,51.47 334.12,51.17 334.12,49.77 334.6,49.28 334.6,47.38 335.25,46.72 335.25,45.92 337.01,44.16 342.17,44.16 343.49,42.84 343.49,40.81 344.61,39.69 347.81,39.69 348.19,39.31 349.36,39.31 349.62,39.58 350.69,39.58 351.7,38.57 v1(353.35,38.57) ; v1(237.23,90.41) 240.29,90.41 241.69,89.02 246.01,89.02 248.35,91.35 248.35,91.81 249.76,93.23 249.76,93.64 250,93.87 250.43,93.87 251.14,93.16 251.9,93.16 v1(251.92,93.13)
  BOTTOM w0.114: R10000.1 324.37,68.68 v1(324.77,69.08) ; v1(351.19,30.06) 351.95,29.3 TP22065.1 352.19,29.42 R10001.1
DEBUG_DP0_TXN0: length 4.4
  BOTTOM w0.114: TP22042.1 362.24,41.19 362.13,41.09 360.86,41.09 359.66,39.89 359.27,39.89 C10001.2
DEBUG_DP0_TXN0_R: length 49.6
  IN2 w0.089: v1(357.33,40.02) 357.19,39.88 357.18,39.88 356.88,39.88 356.78,39.98 356.78,43.58 353.57,46.78 352.65,46.78 351.83,47.6 351.83,49.14 350.89,50.08 350.89,51.44 346.36,55.97 345.13,55.97 343,58.1 343,59.95 341.93,61.01 340.65,61.01 338.46,63.2 338.44,63.2 338.41,63.22 335.82,63.22 335.23,62.64 333.04,62.64 331.5,64.18 331.5,66.6 330.15,67.95 329.26,67.95 328.75,67.43 328.75,67.19 v1(328.57,67.01)
  BOTTOM w0.114: R10004.2 v1(328.57,67.01) ; v1(357.33,40.02) 357.54,39.82 357.77,39.82 358.14,40.19 C10001.1
DEBUG_DP0_TXN1: length 4.4
  BOTTOM w0.114: TP22044.1 361.47,47.16 361.37,47.06 359.98,47.06 358.28,45.36 C10003.2
DEBUG_DP0_TXN1_R: length 51.3
  IN2 w0.089: v1(354.74,41.37) 354.92,41.54 354.92,42.01 354.78,42.15 354.3,42.15 350.82,45.63 349.39,45.63 349.02,46 349.02,51.01 345.77,54.26 344.92,54.26 340.49,58.69 339.81,58.69 338.77,59.73 335.07,59.73 333.76,61.04 332.64,61.04 329.38,64.3 326.86,64.3 325.7,65.47 325.7,65.82 324.94,66.58 324.53,66.99 v1(324.53,67.1)
  BOTTOM w0.114: C10003.1 358.55,44.3 358.55,44.17 358.29,43.91 357.81,43.91 356.26,42.36 355.26,42.36 354.92,42.02 354.92,41.54 v1(354.74,41.37) ; R10005.2 324.51,67.07 v1(324.53,67.1)
DEBUG_DP0_TXN2: length 8.8
  BOTTOM w0.114: C10005.2 356.5,45.59 356.5,45.85 356.83,46.19 358.14,46.19 361.31,49.37 362.51,49.37 362.66,49.37 362.68,49.4 362.74,49.45 TP22046.1
DEBUG_DP0_TXN2_R: length 45.4
  IN2 w0.089: v1(355.51,42.89) 355.68,43.07 355.68,43.5 355.4,43.78 354.24,43.78 350.93,47.08 350.93,48.75 349.98,49.7 349.98,51.06 346.03,55.02 344.99,55.02 340.52,59.49 340.08,59.49 339.25,60.33 335.49,60.33 334.14,61.67 332.85,61.67 330.41,64.12 330.41,65.45 329.69,66.17 327.23,66.17 326.83,66.57 326.83,66.8 v1(326.54,67.09)
  BOTTOM w0.114: R10006.2 v1(326.54,67.09) ; v1(355.51,42.89) 355.91,43.3 355.91,43.42 356.6,44.1 356.6,44.25 C10005.1
DEBUG_DP0_TXN3: length 1.7
  BOTTOM w0.114: TP22055.1 354.54,46.06 354.64,45.96 354.64,45.39 C10007.2
DEBUG_DP0_TXN3_R: length 55.3
  IN2 w0.089: v1(354.51,40.12) 354.62,40.12 354.77,40.27 354.82,40.32 354.82,40.51 354.61,40.72 354.16,40.72 353.74,41.13 353.74,41.73 350.53,44.93 346.98,44.93 345.85,46.06 345.85,47.21 344.04,49.02 344.04,54.09 340.42,57.71 337.8,57.71 337.31,58.2 337.31,58.94 337.13,59.12 334.35,59.12 333.2,60.26 332.57,60.26 331.77,61.06 330.15,61.06 329.48,61.73 329.48,62.66 328.5,63.64 326.55,63.64 325.56,64.63 324.25,64.63 323.82,65.06 323.82,65.75 323.32,66.25 323.12,66.25 322.85,66.51 322.85,66.9 322.66,67.09 v1(322.48,67.09)
  BOTTOM w0.114: v1(354.51,40.12) 354.62,40.22 354.62,40.55 353.93,41.23 353.93,43.15 354.64,43.86 354.64,44.01 354.45,44.2 C10007.1 ; v1(322.48,67.09) R10007.2
DEBUG_DP0_TXP0: length 4.5
  BOTTOM w0.114: TP22041.1 362.24,40.78 362.16,40.86 360.95,40.86 359.76,39.66 359.35,39.66 C10000.2
DEBUG_DP0_TXP0_R: length 49.6
  IN2 w0.089: v1(357.33,39.38) 357.33,39.49 357.13,39.69 356.8,39.69 356.58,39.91 356.58,43.5 353.49,46.59 352.57,46.59 351.64,47.52 351.64,49.06 350.7,50.01 350.7,51.36 346.28,55.78 345.05,55.78 342.81,58.03 342.81,59.87 341.85,60.82 340.57,60.82 338.39,63.01 338.36,63.01 338.33,63.03 335.9,63.03 335.31,62.45 332.96,62.45 331.31,64.1 331.31,66.52 330.07,67.76 329.34,67.76 328.94,67.35 328.94,67.15 328.97,67.11 v1(329.35,67.11)
  BOTTOM w0.114: v1(329.35,67.11) R10004.1 ; C10000.1 357.78,39.59 357.54,39.59 v1(357.33,39.38)
DEBUG_DP0_TXP1: length 4.3
  BOTTOM w0.114: TP22043.1 361.47,46.75 361.4,46.83 360.07,46.83 358.81,45.56 358.81,45.43 358.93,45.3 359.23,45.3 C10002.2
DEBUG_DP0_TXP1_R: length 51.1
  IN2 w0.089: v1(355.38,41.37) 355.11,41.63 355.11,42.09 354.86,42.34 354.37,42.34 350.9,45.82 349.47,45.82 349.21,46.09 349.21,51.09 345.85,54.45 345,54.45 340.57,58.88 339.89,58.88 338.85,59.92 335.15,59.92 333.84,61.23 332.72,61.23 329.46,64.49 326.94,64.49 325.89,65.55 325.89,65.9 325.18,66.61 325.18,66.9 v1(325.29,67.01)
  BOTTOM w0.114: R10005.1 v1(325.29,67.01) ; C10002.1 358.38,43.68 357.9,43.68 356.35,42.13 355.35,42.13 355.15,41.92 355.15,41.59 v1(355.38,41.37)
DEBUG_DP0_TXP2: length 8.9
  BOTTOM w0.114: TP22045.1 362.74,49.04 362.64,49.14 362.53,49.14 361.41,49.14 358.23,45.96 356.93,45.96 356.72,45.76 356.72,45.46 356.9,45.28 357.2,45.28 C10004.2
DEBUG_DP0_TXP2_R: length 45.4
  IN2 w0.089: v1(356.14,42.89) 355.87,43.16 355.87,43.58 355.48,43.97 354.32,43.97 351.12,47.16 351.12,48.83 350.17,49.78 350.17,51.14 346.11,55.21 345.06,55.21 340.59,59.68 340.16,59.68 339.33,60.52 335.57,60.52 334.22,61.86 332.93,61.86 330.6,64.2 330.6,65.52 329.76,66.36 327.31,66.36 327.02,66.65 327.02,66.79 v1(327.32,67.09)
  BOTTOM w0.114: C10004.1 357.15,44.58 356.83,44.26 356.83,44.01 356.14,43.32 v1(356.14,42.89) ; R10006.1 v1(327.32,67.09)
DEBUG_DP0_TXP3: length 1.7
  BOTTOM w0.114: TP22056.1 355,46.06 354.87,45.94 354.87,45.36 C10006.2
DEBUG_DP0_TXP3_R: length 55.1
  IN2 w0.089: v1(355.15,40.12) 355.01,40.26 355.01,40.59 354.69,40.91 354.24,40.91 353.93,41.21 353.93,41.81 350.61,45.13 347.06,45.13 346.04,46.15 346.04,47.29 344.23,49.11 344.23,54.15 340.48,57.9 337.88,57.9 337.5,58.28 337.5,59.02 337.2,59.32 337.19,59.31 334.43,59.31 333.28,60.45 332.65,60.45 331.85,61.25 330.23,61.25 329.67,61.81 329.67,62.74 328.58,63.83 326.63,63.83 325.64,64.82 324.33,64.82 324.01,65.14 324.01,65.83 323.4,66.44 323.2,66.44 323.04,66.59 323.04,66.88 v1(323.26,67.09)
  BOTTOM w0.114: v1(323.26,67.09) R10007.1 ; v1(355.15,40.12) 354.88,40.39 354.88,40.6 354.16,41.33 354.16,43.06 354.87,43.77 354.87,44.03 355.04,44.2 C10006.1
DEBUG_DP1_AUXN: length 3.8
  BOTTOM w0.114: C10022.2 R10055.1 355.48,32.21 355.48,33.7 TP22063.1
DEBUG_DP1_AUXN_R: length 18.2
  BOTTOM w0.114: C10022.1 355.91,28.99 R10056.2 355.4,28.49 355.4,27.56 355.01,27.17 354.42,27.17 353.48,28.11 351.93,28.11 351.24,28.79 350.98,28.79 v1(350.48,28.28) 349.97,28.79 348.81,28.79 348.07,29.53 345.01,29.53 343.74,28.26 343.07,28.26 342.81,28.53 342.81,28.91 R10017.2
DEBUG_DP1_AUXP: length 4.5
  BOTTOM w0.114: C10021.2 355.04,30.77 355.17,30.9 355.17,31.37 R10053.1 355.06,31.78 355.25,31.97 355.25,33.62 TP22064.1
DEBUG_DP1_AUXP_R: length 17.4
  BOTTOM w0.114: R10017.1 343.03,28.89 343.03,28.62 343.17,28.49 343.64,28.49 344.91,29.76 348.16,29.76 348.9,29.02 349.94,29.02 v1(350.48,29.55) 351.01,29.02 351.34,29.02 352.03,28.34 353.57,28.34 354.51,27.4 354.91,27.4 355.17,27.66 355.17,28.54 R10054.2 354.74,29.96 C10021.1
DEBUG_DP1_HPD: length 207.1
  TOP w0.114: v1(357.77,32.86) 357.77,29.54 R10012.1 ; R2141.2 232.16,72.2 231.83,71.87 231.83,71.21 230.71,70.09 230.71,64.51 v1(230.92,64.3)
  IN2 w0.089: v1(357.77,32.86) 353.6,32.86 352.2,34.25 v1(351.31,34.25) ; v1(230.92,64.3) 230.59,63.98 230.59,41.32 229.55,40.27 v1(229.55,40.22)
  IN3 w0.089: v1(253.19,25.74) 253.19,26.01 253.77,26.49 254.95,26.49 255.32,26.12 257.42,26.12 257.61,25.92 259.32,25.92 260.53,24.7 260.53,23.31 261.47,22.37 261.47,20.46 262.16,19.78 264.24,19.78 265.57,18.46 266.66,18.46 267.49,17.62 271.56,17.62 272.88,18.94 272.88,20.2 273.42,20.74 273.42,22.51 274.4,23.5 275.37,23.5 276.27,24.4 277.58,24.4 278.74,25.57 283.39,25.57 284.08,26.26 288.75,26.26 290.17,27.68 294.6,27.68 295.53,28.61 302.86,28.61 307.95,23.52 311,23.52 313.49,21.03 317.44,21.03 317.78,21.37 318.75,21.37 321.54,24.16 324.84,24.16 325.1,24.42 329.1,24.42 331.51,26.82 333.84,26.82 334.65,27.63 335.55,27.63 335.82,27.9 335.82,28.44 336.39,29.01 337.65,29.01 337.96,28.7 337.96,27.82 337.87,27.73 337.87,27.41 338.1,27.19 339.06,27.19 339.63,27.76 339.63,28.74 340.07,29.19 344.63,29.19 345.26,29.82 346.94,29.82 347.5,30.37 348.72,30.37 349.4,31.04 349.4,32.34 v1(351.31,34.25)
  BOTTOM w0.114: v1(351.31,34.25) 351.31,33.54 TP22067.1 351.01,33.24 R10011.1 ; v1(229.55,40.22) 229.39,40.22 228.86,39.7 228.86,38.65 229.27,38.24 230.26,38.24 230.62,37.88 230.62,35.38 233.34,32.66 233.4,32.61 235.95,32.61 236.92,31.63 241.49,31.63 243.8,33.94 244.56,33.94 245.08,33.43 246.73,33.43 247.3,32.86 247.3,32.38 251.22,28.46 251.22,28 252.08,27.14 252.08,26.81 253.14,25.74 v1(253.19,25.74)
DEBUG_DP1_TXN1: length 2.5
  BOTTOM w0.114: C10017.2 359.29,34.34 360.67,34.34 360.76,34.43 TP22048.1
DEBUG_DP1_TXN1_R: length 11.2
  BOTTOM w0.114: R10013.2 348.38,35.3 348.77,35.3 349.43,35.96 v2(350.63,35.96) 351.26,35.96 352.33,34.88 354.05,34.88 354.13,34.97 356.44,34.97 357.05,34.36 357.68,34.36 C10017.1
DEBUG_DP1_TXN2: length 7.6
  BOTTOM w0.114: C10020.2 355.87,36.06 356.66,36.06 357.28,35.44 358.94,35.44 360.4,36.9 361.5,36.9 361.6,37 TP22050.1
DEBUG_DP1_TXN2_R: length 4.9
  BOTTOM w0.114: R10014.2 351.42,37.33 351.76,37.33 353,36.08 353.3,36.08 v1(353.8,36.59) 353.8,36.21 353.93,36.08 354.3,36.08 C10020.1
DEBUG_DP1_TXN3: length 4.1
  BOTTOM w0.114: TP22052.1 360.84,39.41 360.74,39.31 360.25,39.31 359.59,38.65 358.7,38.65 358.3,38.25 358.3,37.95 C10023.2
DEBUG_DP1_TXN3_R: length 12.7
  BOTTOM w0.114: R10015.2 348.27,39.21 348.72,39.21 349.45,38.47 v2(350.73,38.47) 351.71,38.47 352.87,37.3 354.21,37.3 354.38,37.14 355.93,37.14 356.32,36.74 356.9,36.74 357.18,36.46 357.48,36.16 358.34,36.16 358.43,36.24 358.43,36.53 C10023.1
DEBUG_DP1_TXN4: length 1.9
  BOTTOM w0.114: C10015.2 355.46,38.39 355.61,38.24 356.44,38.24 356.52,38.32 TP22061.1
DEBUG_DP1_TXN4_R: length 7.2
  BOTTOM w0.114: R10016.2 350.64,41.87 351.03,41.87 351.42,41.49 351.42,39.87 v2(352.48,38.8) 353.15,38.13 354.3,38.13 354.68,38.51 C10015.1
DEBUG_DP1_TXP1: length 2.5
  BOTTOM w0.114: C10014.2 359.23,34.11 360.65,34.11 360.76,34 TP22047.1
DEBUG_DP1_TXP1_R: length 11.2
  BOTTOM w0.114: R10013.1 348.45,35.07 348.86,35.07 349.52,35.73 351.16,35.73 352.24,34.65 v2(352.63,34.65) 354.14,34.65 354.23,34.74 356.35,34.74 356.96,34.13 357.71,34.13 C10014.1
DEBUG_DP1_TXP2: length 7.6
  BOTTOM w0.114: TP22049.1 361.6,36.59 361.52,36.67 360.49,36.67 359.03,35.21 357.18,35.21 356.56,35.83 355.84,35.83 C10019.2
DEBUG_DP1_TXP2_R: length 5
  BOTTOM w0.114: C10019.1 354.28,35.85 353.96,35.85 353.8,35.7 v1(353.8,35.32) 353.27,35.85 352.91,35.85 351.66,37.1 351.5,37.1 R10014.1
DEBUG_DP1_TXP3: length 4
  BOTTOM w0.114: TP22051.1 360.84,39 360.76,39.08 360.34,39.08 359.68,38.42 358.79,38.42 358.53,38.16 358.53,37.89 358.72,37.69 C10018.2
DEBUG_DP1_TXP3_R: length 13.1
  BOTTOM w0.114: R10015.1 348.3,38.98 348.62,38.98 349.36,38.24 351.61,38.24 352.78,37.07 354.11,37.07 354.28,36.91 355.83,36.91 356.23,36.51 356.8,36.51 357.39,35.93 v2(357.97,35.93) 358.43,35.93 358.65,36.15 358.65,36.51 C10018.1
DEBUG_DP1_TXP4: length 1.9
  BOTTOM w0.114: C10016.2 355.46,37.92 355.56,38.01 356.44,38.01 356.52,37.94 TP22062.1
DEBUG_DP1_TXP4_R: length 7.1
  BOTTOM w0.114: R10016.1 350.66,41.65 350.93,41.65 351.19,41.39 351.19,39.77 351.41,39.55 351.41,39.55 351.67,39.29 353.06,37.9 v2(353.57,37.9) 354.36,37.9 C10016.1
DEVSLP1_SSD1: length 91.6
  TOP w0.114: R9327.1 256.36,66.24 v1(256.57,66.45)
  IN4 w0.076: v1(320.38,45.46) 320.48,45.46 322.33,47.31 322.33,48.17 320.47,50.04 318.69,50.04 318.13,50.6 317.22,50.6 317.11,50.48 309.12,50.48 308.59,51.02 306.48,51.02 305.89,51.61 302.68,51.61 302.08,52.21 299.59,52.21 299.27,52.53 294.9,52.53 294.58,52.21 294.25,52.21 293.69,52.76 291.59,52.76 291.45,52.62 288.25,52.62 287.94,52.92 287.58,52.92 287.58,52.92 281.62,52.92 280.85,53.68 279.84,53.68 279.44,53.29 278.38,53.29 278.19,53.48 277.86,53.48 276.5,54.84 274.15,54.84 272.23,56.76 271.28,56.76 270.55,57.48 268.95,57.48 268.46,56.99 267.75,56.99 267.23,57.51 265.86,57.51 260.79,62.57 260.26,62.57 258.48,64.35 257.97,64.35 256.57,65.75 v1(256.57,66.45)
  BOTTOM w0.114: U9002.AH35 256.33,66.21 v1(256.57,66.45) ; v1(320.38,45.46) 320.38,43.36 317.89,40.87 317.89,39.54 316.9,38.55 316.9,36.92 316.38,36.4 CON5100.38
DEVSLP3_HDD: length 270.4
  TOP w0.114: v1(264.19,60.65) 263.92,60.65 263.68,60.42 263.68,59.79 264.05,59.42 R9360.1
  IN2 w0.089: v1(264.19,60.65) 264.19,60.65 263.62,60.65 260.78,57.81 259.62,57.81 258.53,56.73 258.53,56.28 253.87,51.62 253.87,48.96 251.82,46.91 251.82,44.52 250.82,43.52 248.29,43.52 246.41,41.65 246.41,39.97 244.01,37.56 244.01,36.94 239.93,32.86 236.09,32.86 234.94,31.71 233.35,31.71 230.83,29.2 221.69,29.2 217.15,24.65 214.77,24.65 213.96,23.84 206.03,23.84 205.68,23.5 201.53,23.5 200.51,24.52 190.62,24.52 190.08,23.97 187.95,23.97 186.93,22.95 180.59,22.95 180.28,23.26 171.39,23.26 170.42,22.29 136.28,22.29 136.12,22.44 105.82,22.44 102.41,25.85 102.41,28.84 100.91,30.34 100.91,38.49 96.91,42.5 96.91,44.06 89.88,51.09 84.7,51.09 82.36,53.43 78.01,53.43 76.57,51.99 68.43,51.99 67.84,51.4 66.37,51.4 62.56,47.59 61.25,47.59 60.48,46.83 55.66,46.83 55.02,46.19 49.18,46.19 v1(47.66,44.67)
  BOTTOM w0.114: CON5000.12 46.42,43.43 v1(47.66,44.67) ; v1(264.19,60.65) 263.82,61.02 263.82,62.33 262.86,63.3 U9002.AP48
DEVSLP4_SSD2: length 100.5
  TOP w0.114: v1(320.42,39.17) 320.42,38.86 322.46,36.82 322.46,25.82 321.78,25.14 321.78,24.22 319.89,22.33 319.89,21.05 v1(319.36,20.51)
  IN1 w0.076: v1(320.42,39.17) 320.36,39.23 313.95,39.23 311.56,41.62 307.18,41.62 306.86,41.94 298.95,41.94 298.43,42.46 295.84,42.46 295.1,43.19 288.89,43.19 287.47,44.62 284.43,44.62 283.97,45.07 282.33,45.07 280.8,46.6 278.81,46.6 275.97,49.44 273.39,49.44 271.2,51.63 271.2,52.38 267.37,56.21 v1(267.37,56.76)
  BOTTOM w0.102: U9002.AR47 263.03,63.95 263.37,63.61 263.37,63.37 264.7,62.04 264.7,61.43
  BOTTOM w0.114: v1(319.36,20.51) 319.36,20.21 317.91,18.76 317.91,14.06 317.25,13.4 CON5101.38 ; 264.7,61.43 264.7,60 266.75,57.95 R9361.1 267.34,56.76 v1(267.37,56.76)
DGPU_HOLD_RST#: length 53.9
  TOP w0.114: R9055.2 256.01,65.27 256.3,65.27 R2228.1 257.02,65.99 v1(257.05,65.99) ; U2001.1 226.79,84.84 226.98,84.65 227.34,84.65 227.87,85.18 v1(228.78,85.18)
  IN2 w0.089: v1(228.78,85.18) 230.23,83.73 236.15,83.73 237.5,82.39 241.28,82.39 242.38,81.28 243.71,81.28 244.89,80.1 244.89,77.14 245.78,76.25 245.78,74.64 246.62,73.8 246.62,71.74 247.69,70.67 247.69,70.35 246.56,69.23 246.56,67.6 246.95,67.22 246.95,64.83 249.36,62.42 254.51,62.42 257.05,64.96 v1(257.05,65.99)
  BOTTOM w0.114: U9002.AH36 256.88,65.82 v1(257.05,65.99)
DGPU_INTR#: length 50.4
  TOP w0.114: 257.87,78.15 257.87,77.5 256.42,76.05 256.42,75.61 v1(256.23,75.42) ; v1(230.64,84.6) 230.38,84.85 229.77,84.85 229.22,85.4 228.25,86.37 Q2022.3 227.53,87.68 227.52,87.69 227.05,87.21 v1(225.2,87.21) 224.49,87.21 222.83,88.88 Q2023.6 222.63,88.88 221.33,87.58 Q2023.3
  IN4 w0.076: v1(230.64,84.6) 231.36,83.87 235.91,83.87 240.43,79.35 242.32,79.35 242.81,78.87 244.1,78.87 244.8,78.17 246.69,78.17 247.93,76.93 249.31,76.93 249.43,77.05 249.43,77.47 249.75,77.79 250.26,77.79 250.64,77.41 250.64,77.13 251.21,76.56 251.98,76.56 252.41,76.13 253.79,76.13 254.04,75.87 254.04,74.62 254.47,74.2 254.85,74.2 255.07,74.41 255.07,74.74 255.75,75.42 v1(256.23,75.42)
  BOTTOM w0.102: v1(256.23,75.42) 256.72,75.91 256.98,75.91 U9002.BD21
DGPU_OVT#: length 15.2
  TOP w0.114: v1(225.05,78.81) 225.08,78.83 R2133.1
  BOTTOM w0.114: Q2015.3 218.6,88.74 218.98,88.36 218.98,86.96 219.74,86.2 219.74,83.15 221.57,81.32 221.57,80.43 222.05,79.95 222.58,79.95 223.39,79.14 224.71,79.14 225.05,78.8 v1(225.05,78.81)
DGPU_PRSNT#: length 247.2
  TOP w0.114: Q3003.2 76.82,63.02 76.88,62.96 R2226.1 78.61,60.71 80.95,60.71 82.02,59.65 82.02,57.52 81.06,56.56 81.06,53.05 81.69,52.41 83.14,52.41 v1(83.73,53) ; v1(257.97,65.1) 257.09,64.22 R9053.2
  IN2 w0.089: v1(257.97,65.1) 258.1,65.24 259.55,65.24 261.15,63.64 261.15,62.63 260.62,62.11 259.28,62.11 256.7,59.52 256.7,57.93 253.36,54.6 250.42,54.6 248.39,52.57 248.39,49.87 246.35,47.82 246.35,45.44 244.72,43.82 244.72,41.45 243.26,39.99 239.79,39.99 237.05,37.25 237.05,34.32 234.8,32.07 233.2,32.07 230.86,29.73 221.67,29.73 217.3,25.36 214.54,25.36 213.65,24.47 206.24,24.47 205.39,25.32 190.29,25.32 189.75,24.77 187.58,24.77 187.06,24.25 177.42,24.25 177.2,24.47 170.33,24.47 170.19,24.33 153.28,24.33 153.17,24.22 106.22,24.22 104.03,26.41 104.03,28.99 102.2,30.82 102.2,40.54 95.8,46.95 95.8,48.99 94.1,50.69 90.83,50.69 90.08,51.44 85.28,51.44 v1(83.73,53)
  BOTTOM w0.114: U9002.AL40 v1(257.97,65.1)
DGPU_PWR_EN: length 199.4
  TOP w0.114: R9052.2 261.96,57.57 261.96,57.95 260.85,59.06 260.85,60.46 260.51,60.8 259.75,60.8 259.35,61.2 259.35,62.29 259.24,62.4 v1(259.24,62.94)
  IN2 w0.089: v1(178.59,24.75) 187.31,24.75 187.51,24.95 189.67,24.95 190.25,25.53 205.43,25.53 206.16,24.81 213.47,24.81 214.28,25.62 217.3,25.62 221.6,29.91 230.79,29.91 233.13,32.25 234.72,32.25 236.87,34.39 236.87,37.32 239.71,40.17 243.18,40.17 244.55,41.53 244.55,44.74 246.08,46.27 246.08,47.81 247.92,49.65 247.92,52.35 250.35,54.78 253.29,54.78 256.52,58.01 256.52,59.6 258.48,61.56 258.48,62.18 v1(259.24,62.94) ; v1(192.44,79.47) 193.07,80.09 193.5,80.09 194.58,81.17 196.71,81.17 197.8,82.26 197.8,85.97 197.39,86.38 197.39,88.3 v1(196.58,89.11)
  IN4 w0.076: v1(178.59,24.75) 179.57,25.73 181.75,25.73 182.6,26.58 185.18,26.58 189.35,30.76 189.35,43.89 190.11,44.65 190.11,60.46 188.36,62.21 188.36,68.89 189.05,69.58 189.05,77.35 191.17,79.47 v1(192.44,79.47)
  BOTTOM w0.114: v1(196.58,89.11) 197.89,89.11 198.15,89.37 198.15,90.01 198.76,90.62 v1(198.96,90.62) 199.35,90.62 199.37,90.64 199.79,90.64 R2127.2 200.66,91.03 200.82,90.87 201.84,90.87 202.09,91.12 U2004.2 ; v1(259.24,62.94) 259.36,63.06 U9002.AJ44
DGPU_PWROK: length 201.7
  TOP w0.114: v1(259.85,64.14) 259.75,64.04 259.75,63.57 261.91,61.41 261.91,60.44 262.54,59.81 262.54,59.3 264.68,57.16 R9054.1
  IN2 w0.089: v1(177.96,24.75) 178.47,25.26 189.73,25.26 190.22,25.75 205.46,25.75 206.23,24.98 213.35,24.98 214.24,25.87 217.31,25.87 221.52,30.09 230.71,30.09 233.05,32.43 234.65,32.43 236.69,34.47 236.69,37.4 239.64,40.34 243.11,40.34 244.37,41.6 244.37,44.81 245.9,46.35 245.9,47.88 247.75,49.72 247.75,52.43 250.27,54.95 253.22,54.95 256.32,58.06 256.32,60.03 255.05,61.3 255.05,62.45 257,64.4 258.58,64.4 258.84,64.14 v1(259.85,64.14)
  IN4 w0.076: v1(193.07,94.32) 193.07,88.58 190.66,86.16 190.66,79.17 188.88,77.4 188.88,69.63 188.21,68.96 188.21,62.15 189.96,60.4 189.96,44.71 189.2,43.95 189.2,30.82 185.11,26.73 182.54,26.73 181.69,25.88 179.09,25.88 v1(177.96,24.75)
  BOTTOM w0.114: v1(193.07,94.32) 193.07,93.82 193.58,93.31 Q2011.3 ; U9002.AL41 259.59,64.39 v1(259.85,64.14)
DGPU_PWROK_Q: length 13.5
  IN4 w0.076: v1(193.91,86.96) 193.6,87.27 v1(193.6,93.92)
  BOTTOM w0.114: v1(193.91,86.96) 193.94,86.93 Q2000.3 ; Q2011.1 193.08,92.3 193.45,92.67 194.21,92.67 195.1,93.57 Q2012.2 ; Q2012.2 R2089.2 ; Q2012.2 v1(194.22,93.82) 193.7,93.82 v1(193.6,93.92)
DGPU_SELECT#: length 253.7
  TOP w0.114: v1(100.72,18.33) 100.38,17.99 99.38,17.99 98.75,18.62 98.75,38.55 94.26,43.04 93.87,43.04 92.3,44.61 92.3,48.12 88.77,51.65 86.61,51.65 84.36,53.9 83.05,53.9 82.25,54.7 82.25,56.78 83.28,57.81 83.79,57.81 84.16,58.18 84.16,59.48 83.45,60.19 83.45,62.23 R3043.1 83.73,63.47 83.73,64.99 Q3001.1
  IN2 w0.089: v1(268.06,54.57) 268.06,53.75 265.08,50.76 265.08,49.33 258.53,42.78 258.53,40.65 257.36,39.49 257.36,38.88 257.25,38.62 257.21,38.58 257.19,38.53 256.88,38.22 256.85,38.22 256.7,38.22 254.53,38.22 254,37.69 253.43,37.69 252.84,37.1 252.84,36.04 252.52,35.73 251.41,35.73 251.21,35.52 250.61,35.52 244.86,29.78 238,29.78 236.68,28.46 234.33,28.46 232.21,26.34 223.23,26.34 218.46,21.57 216.06,21.57 214.56,20.07 205.7,20.07 205.23,20.55 198.97,20.55 198.78,20.74 191.98,20.74 191.33,20.09 181.87,20.09 180.53,18.75 177.41,18.75 v1(176.74,19.42) 176.28,18.96 175.75,18.96 175.5,19.22 175.5,19.52 175.29,19.73 175.29,19.76 175.2,19.85 172.83,19.85 172.26,19.29 104.42,19.29 104.32,19.19 101.58,19.19 v1(100.72,18.33)
  BOTTOM w0.114: R9300.1 265.23,58.27 267.37,56.13 267.37,55.27 v1(268.06,54.57)
DGPU_SELECT#_R: length 4.6
  BOTTOM w0.114: U9002.AM48 262.47,62.75 263.39,61.83 263.39,60.2 264.17,59.42 R9300.2
DIGITAL_CLK1: length 352.3
  TOP w0.114: v1(334.65,15.99) 334.65,16.47 335.02,16.85 R3618.1
  IN1 w0.076: v1(45.55,60.97) 45.93,60.59 47.28,60.59 48.04,59.83 48.04,57.65 48.42,57.27 48.42,55.34 49.12,54.64 49.12,51.14 50.72,49.54 50.72,48.72 52.32,47.12 54.77,47.12 56.33,45.56 56.95,45.56 57.47,45.04 65.7,45.04 65.98,44.76 71.95,44.76 75.42,48.22 88.17,48.22 91.17,45.23 91.17,44.49 93.57,42.09 94.25,42.09 97.35,38.99 97.35,19.19 102.48,14.06 103.22,14.06 108.89,8.4 177.91,8.4 183.97,14.45 196.41,14.45 200.74,10.12 202.29,10.12 206.66,5.76 212.84,5.76 213.84,4.76 232.94,4.76 234.06,3.65 240.95,3.65 241.46,4.15 242.46,4.15 243.03,3.58 293.54,3.58 295.37,5.41 313.1,5.41 314.1,4.41 319.18,4.41 319.82,3.77 320.71,3.77 321.6,2.88 328.3,2.88 332.77,7.36 332.77,9.09 335.57,11.88 335.57,15.08 v1(334.65,15.99)
  BOTTOM w0.114: L3005.1 45.7,60.82 v1(45.55,60.97)
DIGITAL_CLK2: length 2.2
  TOP w0.114: L3003.1 R3629.1 343.17,19.63 343.17,18.62 v1(343.09,18.54)
DIGITAL_D1: length 6.6
  TOP w0.114: C3027.2 336.98,18.59 v1(337.16,18.41) 337.43,18.14 R3013.2 337.98,17.92 337.78,17.72 337.78,16.65 EC3600.2 338.36,15.79 338.03,15.46 U3600.12
DIGITAL_D2: length 7.6
  TOP w0.114: R3011.2 C3022.2 339.37,19.04 v1(339.2,18.86) 339.2,18.58 339.54,18.24 EC3604.2 339.3,17.81 339.3,15.67 338.74,15.11 338.74,14.75 338.96,14.54 339.09,14.54 339.23,14.4 U3600.9
DIMM0_CHA_EVENT_N: length 4.9
  BOTTOM w0.102: R1018.2 R1017.2 147.55,44.99 147.47,45.07 v1(147.47,45.68) 147.47,46.71 146.85,47.32 JDIM1001.134
DIMM0_CHB_EVENT_N: length 7
  BOTTOM w0.114: R1026.2 145.92,26.88 R1025.2 145.96,27.17 145.79,27.17 145.57,27.39 v1(145.57,28.79) 145.57,29.55 146.85,30.84 JDIM1002.134
DIMM1_CHA_EVENT_N: length 17.7
  TOP w0.102: JDIM1000.134 146.85,55.49 147.07,55.27 147.07,52.69 147.5,52.26 147.5,51.69 v1(147.09,51.28) ; v1(142.73,43.8) 143.57,43.8 143.89,44.13 R1000.1 R1001.2
  IN3 w0.089: v1(142.73,43.8) 143.44,43.8 144.81,45.18 144.81,46.06 147.09,48.35 v1(147.09,51.28)
DIMM1_CHB_EVENT_N: length 5
  TOP w0.102: R1044.2 R1043.2 v1(147.53,43.63) 147.53,43.42 147.11,43 147.11,41.87 146.85,41.62 JDIM1003.134
DMI_RXN0: length 100.4
  IN1 w0.076: v1(176.47,105.1) 176.59,104.97 176.59,104.71 176.82,104.48 178.24,104.48 180.33,102.38 180.33,100.27 182.64,97.97 184.09,97.97 188.78,93.28 188.78,92.32 192.82,88.28 193.7,88.28 195.2,86.78 195.54,86.78 197.52,84.8 197.52,84.57 198.3,83.78 199.92,83.78 201.5,82.21 201.88,82.21 202.46,81.62 202.47,81.62 202.75,81.34 218.29,81.34 220.8,78.83 223.22,78.83 225.75,76.3 225.75,72.1 229.51,68.34 229.51,62.99 231.84,60.66 235.66,60.66 236.21,60.11 240.62,60.11 241.46,59.27 241.46,57.96 242.09,57.33 244.47,57.33 244.66,57.15 244.66,56.95 v1(244.5,56.8)
  BOTTOM w0.102: v1(244.5,56.8) 245.34,57.63 246.39,57.63 246.45,57.69 U9002.C33
  BOTTOM w0.114: v1(176.47,105.1) 176.79,104.77 U9001.E8
DMI_RXN1: length 100.4
  IN1 w0.076: v1(242.6,56.67) 242.32,56.39 241.78,56.39 240.25,57.91 239.39,57.91 237.97,59.34 232.56,59.34 229.11,62.78 229.11,66.2 225.08,70.24 225.08,76.37 223.07,78.37 220.72,78.37 218.77,80.32 201.84,80.32 199.74,82.43 197.84,82.43 196.92,83.34 196.92,84.74 195.55,86.11 194.16,86.11 192.73,87.54 192.73,87.79 188.36,92.16 188.36,93.15 184.57,96.94 183.11,96.94 178.89,101.16 178.89,103.28 178.07,104.1 176.9,104.1 176.7,103.9 176.52,103.9 176.46,103.95 v1(176.46,104.3)
  BOTTOM w0.102: U9002.C32 246.11,58.28 246.01,58.18 245.22,58.18 244.55,57.51 242.97,57.51 242.67,57.21 242.67,56.75 v1(242.6,56.67)
  BOTTOM w0.114: U9001.F6 176.12,103.96 v1(176.46,104.3)
DMI_RXN2: length 105.6
  IN1 w0.076: v1(243.36,58.45) 243.77,58.04 245.31,58.04 246.32,57.03 246.32,56.14 245.61,55.42 241.72,55.42 241,56.15 235.46,56.15 233.14,58.47 232.41,58.47 228.37,62.52 228.37,65.64 226.75,67.25 225.62,67.25 219.3,73.57 219.3,78.41 218.14,79.56 201.47,79.56 199.54,81.5 197.74,81.5 195.07,84.16 194.6,84.16 193.83,84.93 193.83,85.33 192.15,87.01 190.99,87.01 190.15,87.85 190.15,88.61 187.61,91.15 187.61,92.87 184.71,95.77 181.57,95.77 180.77,96.58 180.77,98.09 178.09,100.77 178.09,101.78 177.79,102.08 177.79,102.38 177.57,102.61 v1(177.27,102.61)
  BOTTOM w0.102: v1(243.36,58.45) 243.82,57.99 244.33,57.99 244.98,58.64 245.58,58.64 245.66,58.72 U9002.C31
  BOTTOM w0.114: U9001.E5 177.27,102.66 v1(177.27,102.61)
DMI_RXN3: length 112.5
  IN1 w0.076: v1(175.12,105.89) 175.12,105.83 175.29,105.65 175.49,105.65 176.08,105.07 176.08,102.43 176.94,101.56 176.94,100.9 177.29,100.55 177.56,100.55 180.35,97.76 180.35,96.36 181.31,95.39 184.54,95.39 187.14,92.79 187.14,90.83 189.74,88.23 189.74,84.18 190.85,83.06 191.86,83.06 193.08,84.28 193.85,84.28 194.43,83.7 194.99,83.7 197.66,81.03 199.35,81.03 201.2,79.18 215.56,79.18 218.83,75.92 218.83,73.37 226.45,65.75 227.61,65.75 227.95,65.41 227.95,62.4 232.3,58.04 233.03,58.04 235.3,55.77 240.84,55.77 241.65,54.95 245.78,54.95 246.75,55.93 246.75,57.15 245.02,58.89 243.72,58.89 v1(243.31,59.3)
  BOTTOM w0.102: U9002.C29 244.94,59.24 244.86,59.16 244.72,59.16 244.18,59.7 243.72,59.7 v1(243.31,59.3)
  BOTTOM w0.114: v1(175.12,105.89) 174.99,105.89 U9001.J9
DMI_RXP0: length 100.4
  IN1 w0.076: v1(177.12,105.1) 176.99,105.1 176.76,104.86 176.76,104.78 176.89,104.64 178.31,104.64 180.5,102.45 180.5,100.34 182.71,98.13 184.16,98.13 188.94,93.35 188.94,92.39 192.89,88.44 193.77,88.44 195.27,86.94 195.61,86.94 197.68,84.87 197.68,84.63 198.37,83.95 199.99,83.95 201.57,82.37 201.95,82.37 202.53,81.78 202.54,81.78 202.82,81.5 218.36,81.5 220.87,79 223.29,79 225.91,76.37 225.91,72.17 229.67,68.41 229.67,63.06 231.91,60.82 235.73,60.82 236.28,60.28 240.69,60.28 241.62,59.34 241.62,58.03 242.16,57.49 244.54,57.49 245.14,56.9 v1(245.14,56.8)
  BOTTOM w0.102: U9002.B33 246.62,57.48 246.53,57.48 246.48,57.43 246.22,57.43 246.1,57.31 245.9,57.31 245.79,57.43 245.42,57.43 245.04,57.05 245.04,56.89 v1(245.14,56.8)
  BOTTOM w0.114: v1(177.12,105.1) 177.1,105.07 177.1,104.66 177.21,104.54 177.36,104.54 177.44,104.62 U9001.D8
DMI_RXP1: length 100.4
  IN1 w0.076: v1(176.47,103.52) 176.57,103.52 176.97,103.93 178,103.93 178.72,103.21 178.72,101.1 183.04,96.78 184.5,96.78 188.2,93.08 188.2,92.09 192.56,87.72 192.56,87.47 194.09,85.94 195.49,85.94 196.76,84.67 196.76,83.28 197.77,82.26 199.67,82.26 201.78,80.16 218.7,80.16 220.65,78.21 223,78.21 224.91,76.3 224.91,70.17 228.95,66.13 228.95,62.71 232.49,59.17 237.9,59.17 239.32,57.75 240.18,57.75 241.71,56.22 242.39,56.22 242.46,56.3 242.86,56.3 v1(243.23,56.67)
  BOTTOM w0.102: v1(243.23,56.67) 243.2,56.67 242.88,56.99 242.88,57.13 243.06,57.31 244.63,57.31 245.31,57.98 246.1,57.98 246.19,58.07 246.29,58.07 246.36,58 U9002.B32
  BOTTOM w0.114: v1(176.47,103.52) 176.47,103.59 U9001.E6
DMI_RXP2: length 105.6
  IN1 w0.076: v1(242.98,57.94) 243.11,58.07 243.51,58.07 243.7,57.88 245.24,57.88 246.16,56.96 246.16,56.2 245.54,55.59 241.79,55.59 241.07,56.31 235.53,56.31 233.21,58.64 232.48,58.64 228.53,62.59 228.53,65.7 226.82,67.41 225.69,67.41 219.46,73.64 219.46,78.48 218.21,79.73 201.54,79.73 199.61,81.66 197.81,81.66 195.14,84.33 194.66,84.33 194,85 194,85.4 192.22,87.17 191.06,87.17 190.32,87.92 190.32,88.68 187.78,91.22 187.78,92.94 184.78,95.94 181.64,95.94 180.93,96.65 180.93,98.16 178.25,100.84 178.25,101.85 177.96,102.15 177.96,102.45 177.12,103.29 v1(177.12,103.52)
  BOTTOM w0.102: U9002.B31 245.77,58.45 245.76,58.44 245.07,58.44 244.42,57.79 243.73,57.79 243.5,58.02 243.06,58.02 v1(242.98,57.94)
  BOTTOM w0.114: v1(177.12,103.52) 177.12,103.45 U9001.D5
DMI_RXP3: length 112.5
  IN1 w0.076: v1(175.15,105.11) 174.97,105.11 174.83,105.25 174.83,105.37 174.96,105.5 175.43,105.5 175.92,105 175.92,102.34 176.78,101.49 176.78,100.83 177.22,100.38 177.49,100.38 180.18,97.69 180.18,96.29 181.24,95.23 184.47,95.23 186.98,92.72 186.98,90.76 189.57,88.16 189.57,84.11 190.79,82.89 191.93,82.89 193.15,84.11 193.78,84.11 194.36,83.53 194.93,83.53 197.59,80.86 199.28,80.86 201.13,79.01 215.49,79.01 218.66,75.85 218.66,73.3 226.38,65.58 227.54,65.58 227.78,65.35 227.78,62.33 232.23,57.88 232.96,57.88 235.24,55.6 240.77,55.6 241.58,54.79 245.85,54.79 246.92,55.86 246.92,57.22 245.08,59.06 244.05,59.06 243.99,59.12 v1(243.99,59.3)
  BOTTOM w0.102: U9002.B29 245.2,58.98 245.14,59.04 245.02,59.04 244.94,58.96 244.64,58.96 244.22,59.37 244.06,59.37 v1(243.99,59.3)
  BOTTOM w0.114: U9001.J8 174.55,105.05 174.55,105.19 174.66,105.3 174.97,105.3 v1(175.15,105.11)
DMI_TXN0: length 104
  IN1 w0.076: v1(181.98,105.28) 181.75,105.05 181.75,104.71 181.43,104.38 181.43,103.2 181.52,103.11 181.52,100.11 182.37,99.26 182.39,99.26 182.42,99.23 186.27,99.23 187.22,98.28 187.22,95.86 189.49,93.59 189.49,92.68 193.14,89.03 193.97,89.03 195.47,87.53 196.04,87.53 197.73,85.83 199.02,85.83 201.86,82.99 202.32,82.99 203.17,82.14 218.5,82.14 221,79.63 223.44,79.63 226.5,76.58 226.5,72.35 230.23,68.62 230.23,64.07 230.74,63.57 231.9,63.57 233.86,61.6 236.02,61.6 236.77,60.85 244.18,60.85 246.77,58.26 247.68,58.26 248.57,59.15 248.57,59.92 248.9,60.25 v1(249.58,60.25)
  BOTTOM w0.079: 181.31,104.54 181.29,104.54 181.27,104.56 180.59,104.56 180.13,105.02 179.14,105.02 179.03,104.91 179.03,104.79 179.11,104.7 U9001.A8
  BOTTOM w0.102: 181.31,104.54 181.52,104.54 181.74,104.76 181.74,105.04 v1(181.98,105.28) ; U9002.K34 249.64,60.25 v1(249.58,60.25)
DMI_TXN1: length 100.3
  IN1 w0.076: v1(248.1,59.79) 248.1,59.59 247.94,59.43 247.76,59.43 247.61,59.58 246.23,59.58 244.42,61.39 239.18,61.39 238.36,62.21 234.06,62.21 230.89,65.37 230.89,68.75 227.22,72.42 227.22,78.37 224.97,80.62 220.8,80.62 218.72,82.7 205.41,82.7 204.33,83.78 202.04,83.78 199.43,86.39 198.19,86.39 196.47,88.11 196.34,88.11 196.33,88.12 195.67,88.12 194,89.79 193.17,89.79 190.91,92.04 190.91,93.16 190.28,93.8 190.28,96.21 187.6,98.88 187.39,98.88 186.49,99.78 182.65,99.78 182.15,100.27 182.15,103.47 182.21,103.53 182.36,103.53 v1(182.58,103.31)
  BOTTOM w0.079: U9001.B6 178.49,103.92 178.39,104.02 178.39,104.16 178.49,104.26 180.21,104.26 180.97,103.49 181.27,103.49 181.29,103.47 181.31,103.47
  BOTTOM w0.102: 181.31,103.47 182.42,103.47 v1(182.58,103.31) ; v1(248.1,59.79) 248.1,59.49 248.24,59.36 248.44,59.36 U9002.G33
DMI_TXN2: length 103.2
  IN1 w0.076: v1(183.17,102.04) 183.17,101.82 183.31,101.67 183.94,101.67 184.21,101.4 185.43,101.4 186,100.82 186.76,100.82 187.77,99.81 188.35,99.81 191.88,96.28 191.88,92.42 193.15,91.15 195.76,91.15 197.09,89.82 197.09,89.49 198.72,87.85 199.51,87.85 200.03,87.34 200.87,87.34 202.77,85.43 204.24,85.43 206.01,83.67 219.34,83.67 220.84,82.17 225.04,82.17 225.93,81.28 226.93,81.28 229.34,78.87 229.34,76 230.5,74.84 230.5,73.5 230.63,73.37 230.63,72.72 232.67,70.68 232.67,65.01 234.51,63.17 235.61,63.17 236.11,63.67 236.11,64.08 236.6,64.57 239.99,64.57 241.85,62.71 243.58,62.71 245.44,64.57 246.31,64.57 246.78,64.1 247.56,64.1 249.59,62.06 249.59,61.37 249.03,60.81 248.71,60.81 248.62,60.9 248.62,61.14 v1(248.69,61.21)
  BOTTOM w0.079: 181.31,102.64 181.3,102.64 181.28,102.66 180.36,102.66 179.54,103.48 179.32,103.48 179.2,103.36 179.2,103.21 179.25,103.16 U9001.A5
  BOTTOM w0.102: U9002.K32 249.03,60.77 248.85,60.77 248.67,60.95 248.67,61.19 v1(248.69,61.21) ; 181.31,102.64 183.05,102.64 183.36,102.33 183.36,102.23 v1(183.17,102.04)
DMI_TXN3: length 97.5
  IN1 w0.076: v1(247.3,60.99) 247.01,60.99 246.95,61.05 245.63,61.05 244.74,61.94 239.4,61.94 238.58,62.77 234.34,62.77 232.29,64.82 232.29,70.52 230.22,72.59 230.22,72.99 229.32,73.89 229.32,75.49 228.96,75.84 228.96,78.71 227.77,79.9 226.57,79.9 225.27,81.21 223.32,81.21 222.9,81.62 220.71,81.62 219.09,83.24 205.65,83.24 204.57,84.32 203.33,84.32 200.69,86.96 199.85,86.96 199.35,87.46 198.51,87.46 197.28,88.69 196.25,88.69 195.94,88.99 195.94,89.31 195.59,89.66 195.05,89.66 194.16,90.55 193.19,90.55 191.5,92.25 191.5,96.01 188.07,99.43 187.61,99.43 186.6,100.44 185.84,100.44 185.32,100.97 183.48,100.97 183.25,100.74 183.25,100.6 v1(182.91,100.26)
  BOTTOM w0.079: U9001.B4 178.42,102.52 178.59,102.68 179.69,102.68 180.92,101.46 180.92,101.43 180.93,101.41
  BOTTOM w0.102: v1(182.91,100.26) 183.17,100.52 183.17,100.69 183.11,100.75 181.59,100.75 180.93,101.41 ; U9002.G30 247.77,60.41 247.87,60.51 247.87,60.65 247.76,60.75 247.53,60.75 v1(247.3,60.99)
DMI_TXP0: length 104.1
  IN1 w0.076: v1(249.3,59.67) 249.3,59.96 249.18,60.09 248.97,60.09 248.74,59.85 248.74,59.08 247.75,58.09 246.7,58.09 244.11,60.68 236.7,60.68 235.95,61.43 233.8,61.43 231.83,63.4 230.67,63.4 230.07,64 230.07,68.55 226.33,72.29 226.33,76.51 223.37,79.47 220.94,79.47 218.43,81.97 203.11,81.97 202.25,82.82 201.79,82.82 198.95,85.67 197.66,85.67 195.97,87.36 195.41,87.36 193.9,88.86 193.07,88.86 189.33,92.61 189.33,93.52 187.05,95.79 187.05,98.21 186.2,99.06 182.35,99.06 182.32,99.1 182.3,99.1 181.35,100.05 181.35,103.04 181.26,103.13 181.26,104.45 181.59,104.78 181.59,105.03 v1(181.34,105.28)
  BOTTOM w0.079: 181.31,104.74 181.29,104.74 181.27,104.72 180.65,104.72 180.2,105.18 179.07,105.18 178.87,104.97 178.87,104.83 U9001.B8
  BOTTOM w0.102: v1(181.34,105.28) 181.54,105.08 181.54,104.85 181.43,104.74 181.31,104.74 ; U9002.J35 249.71,59.26 v1(249.3,59.67)
DMI_TXP1: length 100.4
  IN1 w0.076: v1(247.9,59.05) 247.55,59.41 246.17,59.41 244.35,61.23 239.11,61.23 238.29,62.04 233.99,62.04 230.73,65.31 230.73,68.68 227.06,72.35 227.06,78.31 224.91,80.46 220.73,80.46 218.65,82.53 205.34,82.53 204.26,83.61 201.97,83.61 199.36,86.23 198.12,86.23 196.4,87.95 196.27,87.95 196.26,87.96 195.6,87.96 193.93,89.63 193.1,89.63 190.75,91.98 190.75,93.09 190.11,93.73 190.11,96.14 187.53,98.72 187.32,98.72 186.43,99.61 182.58,99.61 181.98,100.21 181.98,103.54 182.14,103.69 182.33,103.69 v1(182.58,103.94)
  BOTTOM w0.079: 181.31,103.67 181.29,103.67 181.27,103.65 181.04,103.65 180.27,104.41 178.43,104.41 178.23,104.22 178.23,104.06 U9001.C6
  BOTTOM w0.102: 181.31,103.67 182.31,103.67 v1(182.58,103.94) ; U9002.F34 v1(247.9,59.05)
DMI_TXP2: length 103.2
  IN1 w0.076: v1(248.37,60.55) 248.46,60.64 249.1,60.64 249.76,61.3 249.76,62.13 247.62,64.26 246.85,64.26 246.38,64.73 245.37,64.73 243.52,62.88 241.92,62.88 240.06,64.73 236.53,64.73 235.95,64.15 235.95,63.74 235.54,63.34 234.58,63.34 232.84,65.08 232.84,70.75 230.79,72.79 230.79,73.44 230.66,73.57 230.66,74.91 229.51,76.07 229.51,78.94 227,81.45 226,81.45 225.11,82.34 220.91,82.34 219.41,83.83 206.08,83.83 204.31,85.6 202.84,85.6 200.94,87.5 200.09,87.5 199.58,88.02 198.79,88.02 197.25,89.56 197.25,89.89 195.83,91.32 193.22,91.32 192.05,92.49 192.05,96.35 188.42,99.98 187.84,99.98 186.83,100.99 186.07,100.99 185.5,101.56 184.28,101.56 v1(183.8,102.04)
  BOTTOM w0.079: U9001.B5 179.01,103.4 179.26,103.64 179.6,103.64 180.43,102.82 181.27,102.82 181.29,102.84 181.31,102.84
  BOTTOM w0.102: 181.31,102.84 182.97,102.84 183.13,102.84 183.56,102.41 183.56,102.28 v1(183.8,102.04) ; U9002.J32 v1(248.37,60.55)
DMI_TXP3: length 97.5
  IN1 w0.076: v1(183.55,100.34) 183.42,100.46 183.42,100.67 183.55,100.8 185.25,100.8 185.78,100.28 186.53,100.28 187.54,99.27 188,99.27 191.33,95.94 191.33,92.18 193.12,90.39 194.09,90.39 194.98,89.5 195.52,89.5 195.78,89.24 195.78,88.92 196.18,88.52 197.21,88.52 198.44,87.3 199.28,87.3 199.78,86.79 200.62,86.79 203.26,84.16 204.5,84.16 205.58,83.08 219.02,83.08 220.64,81.46 222.83,81.46 223.25,81.04 225.2,81.04 226.51,79.73 227.71,79.73 228.8,78.64 228.8,75.77 229.15,75.42 229.15,73.82 230.05,72.92 230.05,72.52 232.12,70.45 232.12,64.75 234.27,62.6 238.51,62.6 239.33,61.77 244.67,61.77 245.56,60.88 246.88,60.88 246.98,60.78 246.98,60.55 v1(246.92,60.48)
  BOTTOM w0.079: U9001.D4 178.3,102.84 179.76,102.84 181.03,101.57 181.06,101.57 181.08,101.56
  BOTTOM w0.102: v1(246.92,60.48) 247.06,60.34 U9002.F30 ; 181.08,101.56 181.68,100.95 183.19,100.95 183.37,100.77 183.37,100.51 v1(183.55,100.34)
DMIC_3_CLK1_R: length 349.2
  IN1 w0.076: v1(297.75,10.07) 292.4,4.73 254.93,4.73 254.21,5.45 251.41,5.45 250.69,4.73 243.62,4.73 241.93,6.42 240.01,6.42 238.58,4.99 234.93,4.99 234.02,5.91 214.33,5.91 212.78,7.46 207.31,7.46 203.12,11.65 200.83,11.65 196.88,15.6 183.5,15.6 177.44,9.54 111.87,9.54 108.36,13.04 105.85,13.04 103.55,15.35 103.01,15.35 99.98,18.38 99.98,18.85 98.5,20.33 98.5,39.48 94.7,43.27 94.04,43.27 92.36,44.95 92.36,45.65 88.65,49.37 74.94,49.37 71.51,45.94 66.71,45.94 66.43,46.22 60.59,46.22 59.6,47.21 58.33,47.21 56.91,48.62 56.91,48.73 55.95,49.68 53.31,49.68 52.51,50.48 52.51,50.89 51.47,51.94 51.47,53.94 50.78,54.62 50.78,56.94 49.38,58.34 49.38,59.96 47.96,61.38 44.81,61.38 43.09,59.65 43.09,58.36 v1(42.73,58)
  BOTTOM w0.114: CON3000.37 47.43,54.54 46.01,55.97 46.01,56.4 44.74,57.67 43.06,57.67 v1(42.73,58) 42.58,58.16 v1(42.58,59.4) 42.59,59.39 R18046.2 C3028.1 L3005.2 ; R9615.1 307,34.88 307.78,34.1 307.78,33.26 307.6,33.09 307.6,27.98 301.43,21.81 301.43,20.82 297.87,17.26 297.87,10.2 v1(297.75,10.07)
DMIC_3_CLK2_R: length 462.8
  TOP w0.114: v1(335.7,53.41) 335.97,53.41 339.2,50.18 340.77,50.18 341.42,49.53 341.88,49.53 342.5,48.91 342.5,48.1 340.75,46.34 340.75,44.65 340.04,43.94 340.04,35.42 341.34,34.11 341.34,30.93 341.83,30.44 343.41,30.44 343.81,30.04 343.81,29.63 343.6,29.42 343.6,24.58 342.81,23.8 v1(342.55,23.8) 342.42,23.8 342.18,23.55 U3607.6 ; v1(341.66,20.19) 342.17,20.7 L3003.2
  IN1 w0.076: v1(331.83,55.01) 332.34,55.01 334.58,52.76 335.06,52.76 v1(335.7,53.41) ; v1(48.57,59.65) 48.57,57.66 48.8,57.43 48.8,55.59 49.63,54.76 49.63,51.72 50.2,51.14 51.01,51.14 51.31,50.84 51.31,48.88 52.57,47.62 54.8,47.62 55.48,46.95 56.8,46.95 57.44,46.32 58.72,46.32 59.62,45.42 65.86,45.42 66.1,45.18 71.83,45.18 75.26,48.6 88.33,48.6 91.55,45.39 91.55,44.68 93.75,42.47 94.41,42.47 97.73,39.15 97.73,19.35 102.64,14.44 103.38,14.44 109.04,8.78 177.76,8.78 183.81,14.83 196.57,14.83 200.69,10.71 202.55,10.71 207.07,6.19 212.98,6.19 214.02,5.15 233.1,5.15 234.02,4.23 238.9,4.23 239.87,5.2 242.07,5.2 243.3,3.96 251,3.96 251.73,4.69 253.9,4.69 254.62,3.96 293.36,3.96 294.96,5.56 294.98,5.56 295.21,5.79 313.26,5.79 314.26,4.79 319.34,4.79 319.98,4.15 320.86,4.15 321.75,3.27 328.14,3.27 332.26,7.39 332.26,9.12 334.3,11.15 334.3,13.5 333.53,14.26 333.53,16.22 334.59,17.27 335.96,17.27 336.81,18.12 337.98,18.12 338.92,19.06 338.92,20.32 339.39,20.79 341.06,20.79 v1(341.66,20.19) 342.42,20.95 342.42,23.67 v1(342.55,23.8)
  IN3 w0.089: v1(331.83,55.01) 332.39,54.45 332.39,53.43 331.98,53.02 330.74,53.02 328.68,55.08 321.29,55.08 320.25,56.12 314.54,56.12 312.4,58.26 311.74,58.26 311.36,58.64 311.36,59.1 311.06,59.4 310.72,59.4 308.92,61.21 297.22,61.21 297.06,61.05 295.13,61.05 294.75,61.43 v1(294.75,61.53)
  BOTTOM w0.114: R9617.1 293.24,61.29 293.4,61.13 294.34,61.13 v1(294.75,61.53) ; CON3000.33 49.43,55.97 47.78,57.62 C3025.1 48.3,60.66 48.57,60.39 v1(48.57,59.65) ; v1(342.55,23.8) 342.55,23.95 341.67,24.83 R18045.2
DMIC_3_D1_R: length 451.1
  TOP w0.114: v1(336.63,51.4) 336.51,51.27 336.51,50.69 337.31,49.88 337.31,48.32 339.34,46.3 339.34,45.23 337.95,43.85 337.95,34.79 338.55,34.19 338.55,32.47 339.18,31.84 339.68,31.84 339.93,31.59 339.93,30.37 339.63,30.06 339.12,30.06 337.98,28.92 337.98,28.16 337.73,27.9 337.73,27.73 336.91,26.91 336.91,25.82 336.38,25.29 336.38,23.92 338.11,22.19 338.36,22.19 338.84,21.71 v1(338.87,21.71) 339.05,21.71 339.28,21.95 U3607.3 ; R3013.1 337.98,19.2 v1(338.33,19.55)
  IN1 w0.076: v1(46.18,60.97) 47.81,60.97 48.95,59.84 48.95,58.24 49.31,57.88 49.31,55.84 50.18,54.97 50.18,52.17 50.32,52.03 50.83,52.03 52.1,50.76 52.1,50.13 53.14,49.1 53.9,49.1 54.9,48.1 56.8,48.1 57.18,47.72 57.18,47.46 57.94,46.7 59.24,46.7 60.1,45.84 66.05,45.84 66.33,45.56 71.67,45.56 75.1,48.99 88.49,48.99 91.98,45.5 91.98,44.78 93.87,42.89 94.53,42.89 98.11,39.31 98.11,19.61 102.9,14.82 103.54,14.82 109.2,9.16 177.6,9.16 183.65,15.22 196.73,15.22 200.78,11.17 202.74,11.17 206.83,7.08 212.63,7.08 214.18,5.53 233.36,5.53 234.27,4.61 238.74,4.61 239.71,5.58 242.23,5.58 243.46,4.35 250.84,4.35 251.57,5.07 254.05,5.07 254.78,4.35 292.96,4.35 294,5.38 294.24,5.38 294.8,5.94 294.82,5.94 295.05,6.17 313.42,6.17 313.78,5.81 319.69,5.81 320.71,4.79 322.93,4.79 324.07,3.65 327.98,3.65 330.11,5.77 330.11,8.82 332.27,10.99 333.31,10.99 333.92,11.6 333.92,13.34 333.15,14.11 333.15,16.38 334.43,17.66 335.8,17.66 336.65,18.51 337.82,18.51 338.33,19.02 v1(338.33,19.55) ; v1(336.63,51.4) 336.33,51.7 335.08,51.7 332.72,54.07 v1(331.12,54.07)
  IN3 w0.089: v1(331.12,54.07) 328.78,56.41 321.18,56.41 319.38,58.21 318.9,58.21 318.89,58.22 314.56,58.22 314.54,58.24 313.97,58.24 310.21,62 296.89,62 296.82,61.93 296.24,61.93 296.08,61.77 295.62,61.77 v1(295.38,61.53)
  IN4 w0.076: v1(338.87,21.71) 338.87,20.09 v1(338.33,19.55)
  BOTTOM w0.114: CON3000.36 47.93,54.66 46.43,56.17 46.43,56.58 46.21,56.79 46.21,60.95 v1(46.18,60.97) ; v1(295.38,61.53) 294.52,62.4 R9614.1

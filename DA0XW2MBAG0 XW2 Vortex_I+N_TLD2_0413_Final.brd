# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V on TOP (solid shape): 59.54,53.74 59.54,53.23 60.11,52.66 60.11,51.19 60.23,51.07 60.23,50.81 60.17,50.75 58.97,50.75 58.71,51.02 58.4,51.02 58.38,51.03 58.34,51.03 58.24,51.04 58.2,51.05 58.04,51.05 57.94,51.14 56.8,51.14 56.75,51.19 56.75,51.22 56.75,51.3 56.75,52.29 56.75,52.34 58.62,52.34 58.62,52.28 58.63,52.23 58.65,52.18 58.68,52.13 58.71,52.09 58.75,52.05 58.79,52.02 58.84,52 58.89,51.98 58.95,51.97 59,51.97 59.05,51.98 59.1,51.99 59.15,52.01 59.2,52.04 59.24,52.07 59.28,52.11 59.31,52.16 59.33,52.21 59.35,52.26 59.35,52.31 59.35,52.37 59.35,52.42 59.33,52.47 59.31,52.52 59.28,52.56 59.24,52.6 59.2,52.64 59.15,52.67 59.1,52.69 59.05,52.7 59,52.71 58.95,52.71 58.89,52.7 58.84,52.68 58.79,52.65 58.75,52.62 58.71,52.59 58.68,52.54 58.65,52.5 58.63,52.45 58.62,52.39 58.62,52.34 56.75,52.34 56.74,52.46 56.73,52.5 56.72,52.53 56.7,52.57 56.69,52.58 56.67,52.61 56.67,52.67 56.44,52.9 56.44,54.01 56.62,54.19 59.09,54.19
+3V on TOP (solid shape): 261.04,87.84 260.98,87.48 261.3,87.3 261.3,86.13 261.37,86.05 261.38,86.03 261.38,85.97 261.4,85.89 261.44,85.82 261.66,85.61 261.68,85.58 261.72,85.56 263.1,84.19 263.11,84.15 263.1,84.12 263.08,84.09 263.06,84.09 263.06,84.08 262.98,84 262.91,84 262.89,84 262.88,84.02 262.03,84.86 262.03,84.85 261.96,84.93 261.83,84.93 261.44,84.54 261.36,84.51 261.29,84.54 261.17,84.63 261.03,84.66 260.96,84.69 260.93,84.76 260.93,86.94 260.11,87.76 260.08,87.86 260.15,87.93 260.23,87.97 260.3,88.03 260.35,88.06 260.4,88.11 260.42,88.12 260.44,88.12 260.75,88.12
+3V on TOP (solid shape): 317.18,17.29 317.18,14.47 318.17,13.48 318.17,8.98 318.68,8.47 318.68,7.57 318.49,7.39 318.48,7.38 318.46,7.37 317.33,7.37 317.26,7.3 317.23,7.29 317.15,7.31 317.06,7.32 316.69,7.11 316.75,6.7 316.78,6.63 316.75,6.56 316.69,6.15 317.06,5.95 317.22,5.96 317.35,6.04 317.42,6.13 317.46,6.24 317.48,6.27 317.51,6.28 318.63,6.28 318.66,6.27 318.68,6.23 318.68,4.79 318.25,4.37 317.81,4.3 317.44,4.03 314.48,4.03 313.34,5.17 313.34,17.28 313.67,17.62 316.85,17.62
+3V on TOP (solid shape): outline of 1261 points within 252.89,30.82 269.04,69.05
+3V on BOTTOM (solid shape): 25.81,53.2 25.81,51.12 25.71,51.02 25.31,51.02 25.18,51.14 25.18,53.28 25.25,53.35 25.66,53.35
+3V on BOTTOM (solid shape): 230.05,85.81 230,85.77 229.24,85.77 228.84,86.17 228.84,87.19 229.33,87.68 230.05,87.68
+3V on BOTTOM (solid shape): 13.37,57.24 13.37,56.22 13.11,55.97 12.35,55.97 11.46,55.08 11.08,55.08 10.95,55.21 10.95,57.49 11.21,57.75 12.86,57.75
+3V on BOTTOM (solid shape): 29.98,49.85 29.98,47.23 29.72,46.98 27.21,46.98 27.03,47.16 27.03,47.74 26.75,48.02 26.32,48.02 26.14,48.2 26.14,49.95 26.37,50.18 29.65,50.18
+3V on BOTTOM (solid shape): 264.07,10.12 264.07,7.33 263.79,7.05 262.87,7.05 262.67,7.25 262.67,8.16 262.67,8.18 262.69,8.21 262.69,8.44 263.07,8.83 263.07,9.09 263.09,9.13 263.13,9.15 263.15,9.15 263.15,10.17 263.23,10.25 263.94,10.25
+3V on BOTTOM (solid shape): 30.5,66.09 30.5,65.95 30.64,65.81 30.64,64.43 30.97,64.1 30.97,62.96 30.75,62.73 30.73,62.73 30.73,62.71 30.56,62.55 29.8,62.55 29.62,62.73 29.62,64.33 29.64,64.34 29.64,65.18 29.85,65.39 29.85,65.54 29.91,65.75 29.85,65.95 29.85,66.25 29.94,66.33 30.26,66.33
+3V on BOTTOM (solid shape): 307.25,44.03 307.25,42.51 307.12,42.24 307.25,41.96 307.25,40.02 306.66,39.44 306.66,38.84 306.11,38.29 306.11,36.67 306.1,36.67 306.1,28.3 305.71,27.9 304.71,27.9 304.58,28.03 304.58,35.4 303.69,36.29 303.69,37.43 304.77,38.51 304.77,39.83 305.59,40.65 305.59,43.91 305.8,44.11 306.64,44.11 306.69,44.16 307.12,44.16
+3V on BOTTOM (solid shape): 29.09,74.72 29.09,73.03 28.97,72.91 28.97,72.29 28.84,72.15 28.84,71.06 28.82,71.02 28.78,71.01 28.69,71.01 28.66,71.02 28.64,71.06 28.64,71.95 28.61,71.95 28.58,71.97 28.56,72 28.56,72.07 28.55,72.07 28.5,72.11 28.5,72.12 28.37,72.25 28.37,72.72 27.03,74.06 27.03,75 27.06,75.02 28.78,75.02
+3V on BOTTOM (solid shape): 176.53,26.55 176.53,25.41 176.69,25.24 176.78,25.24 176.82,25.22 177.05,25.12 177.3,25.2 177.33,25.21 177.35,25.21 177.36,25.2 177.45,25.11 177.45,24.35 177.32,24.22 172.27,24.22 172.12,24.37 172.12,24.91 172.24,25.03 173.23,25.03 173.48,25.28 173.48,26.54 173.69,26.76 174.6,26.76 174.66,26.72 174.67,26.65 174.67,26.5 174.67,26.15 174.27,25.75 174.27,25.23 174.79,25.23 175.41,25.85 175.41,26.5 175.4,26.65 175.43,26.73 175.5,26.76 176.32,26.76
+3V on BOTTOM (solid shape): outline of 128 points within 314.23,3.52 318.17,8.6
+3V on BOTTOM (solid shape): outline of 416 points within 309.12,15.58 319.01,45.81
+3V on IN1 (solid shape): 13.09,56.89 13.09,54.75 15.93,51.91 27.59,51.91 28.23,51.27 28.23,49.37 27.82,48.96 14.74,48.96 12.38,51.32 24.21,51.32 24.21,51.27 24.22,51.22 24.24,51.17 24.26,51.12 24.29,51.08 24.33,51.05 24.37,51.01 24.42,50.99 24.47,50.98 24.52,50.97 24.57,50.97 24.62,50.98 24.67,50.99 24.72,51.01 24.76,51.05 24.8,51.08 24.83,51.12 24.85,51.17 24.87,51.22 24.87,51.27 24.87,51.32 24.87,51.37 24.85,51.42 24.83,51.47 24.8,51.51 24.76,51.55 24.72,51.58 24.67,51.6 24.62,51.62 24.57,51.63 24.52,51.63 24.47,51.62 24.42,51.6 24.37,51.58 24.33,51.55 24.29,51.51 24.26,51.47 24.24,51.42 24.22,51.37 24.21,51.32 12.38,51.32 10.95,52.75 10.95,57.39 11.23,57.67 12.3,57.67
+3V on VCC (solid shape): outline of 25297 points within 25.31,13.3 329.6,74.39
+3V on IN2 (solid shape): 353.42,120.39 354.09,120.39 354.29,120.19 354.29,119.46 354.06,119.23 352.55,119.23 351.4,120.37 351.4,121.1 351.59,121.29 352.52,121.29
+3V on IN2 (solid shape): outline of 179 points within 253.3,7.23 264.5,32.3
+3V on IN2 (solid shape): outline of 1383 points within 317.7,29.05 330.98,82.64
+3V on IN4 (solid shape): outline of 127 points within 255.56,65.62 260,67.53
+3V_8409 on TOP (solid shape): outline of 514 points within 349.66,51.02 364.9,62.45
+3V_8409 on BOTTOM (solid shape): 364.03,62.82 364.78,62.82 364.9,62.7 364.9,61.18 364.78,61.05 364.4,61.05 364.14,61.3 360.97,61.3 360.84,61.43 360.84,62.19 361.47,62.83 364.03,62.83
+3V_8409 on BOTTOM (solid shape): 354.74,56.73 354.85,56.73 354.88,56.72 354.9,56.68 354.9,56.66 355.7,56.66 355.76,56.61 355.76,56.22 355.63,56.1 353.85,56.1 353.73,56.22 349.28,56.22 349.16,56.35 349.16,56.86 349.28,56.99 354.49,56.99
+3V_AR on TOP (solid shape): 353.32,119.37 353.32,117.29 353.22,117.18 352.46,117.18 352.13,116.86 352.11,116.85 352.09,116.84 351.82,116.83 351.59,116.7 351.58,116.7 351.21,116.33 351.14,116.33 351.07,116.3 351.06,116.3 350.83,116.3 350.82,116.3 350.68,116.33 350.54,116.3 350.53,116.3 349.75,116.3 349.39,116.44 349,116.3 348.96,116.31 348.92,116.31 348.64,116.31 348.6,116.31 348.57,116.3 348.39,116.3 348.36,116.33 348.35,116.36 348.36,116.38 348.33,116.72 348.01,116.84 347.92,116.86 347.89,116.94 347.89,117.31 348.01,117.44 351.31,117.44 351.57,117.69 351.57,118.66 351.21,119.01 350.88,119.01 350.7,118.84 350.43,118.84 350.3,118.96 350.3,119.47 350.43,119.6 351.24,119.6 351.38,119.45 351.43,119.41 351.49,119.39 351.52,119.36 352,119.36 352.19,119.55 352.19,119.55 352.36,119.72 352.97,119.72
+3V_AR on BOTTOM (solid shape): 351.44,116.68 351.44,116.42 351.31,116.3 350.04,116.3 349.92,116.17 349.92,116.04 349.79,115.91 349.66,115.91 349.66,115.92 349.62,116.02 349.54,116.11 349.54,116.13 349.54,116.55 349.79,116.8 351.31,116.8
+3V_AR on IN2 (solid shape): 352.15,116.78 352.15,114.7 352.01,114.55 351.43,114.55 351.19,114.8 351.19,116.1 350.96,116.33 350.54,116.33 350.41,116.46 350.41,117.03 350.66,117.28 351.66,117.28
+3V_AR on IN4 (solid shape): outline of 189 points within 347.5,114.26 351.44,117.44
+3V_CAM on TOP (solid shape): 46.82,55.77 46.82,54.6 47.05,54.37 49.38,54.37 49.51,54.24 49.51,52.72 49.47,52.68 48.84,52.68 48.57,52.41 46.97,52.41 46.74,52.64 46.08,52.64 45.9,52.82 45.9,55.46 45.98,55.63 46.02,55.81 46.03,55.82 46.77,55.82
+3V_CAM on BOTTOM (solid shape): 46.99,54.36 46.99,53.59 47.06,53.53 47.06,53.2 47.17,53.09 48.45,53.09 48.55,52.99 48.55,52.36 48.42,52.23 47.15,52.23 46.81,52.58 46.81,54.29 46.91,54.39 46.96,54.39
+3V_DEEP_SUS on TOP (solid shape): 259.87,85.94 259.87,85.56 258.63,84.32 258.06,84.32 257.75,84 257.63,84 256.7,83.07 256.7,82.76 256.65,82.71 256.65,82.6 256.06,82.01 255.68,82.01 255.3,81.62 254.31,81.62 254.11,81.83 254.11,82.95 253.97,83.08 253.98,83.11 253.92,83.36 253.69,83.51 253.65,83.52 253.65,83.9 253.71,83.97 253.78,84.04 255.05,84.04 255.06,84.05 255.21,84.05 256.2,85.04 257.19,85.04 257.97,85.82 257.97,85.84 257.99,85.86 258.09,85.92 258.16,86.01 258.23,86.06 258.28,86.13 258.31,86.18 258.71,86.58 259.24,86.58
+3V_DEEP_SUS on TOP (solid shape): 267.24,49.98 267.24,46.32 266.61,45.68 266.61,42.25 266.22,41.87 265.47,41.87 265.44,41.89 265.42,41.92 265.42,42.72 265.22,42.72 265.22,41.92 265.2,41.89 265.17,41.87 265.1,41.87 265.08,41.88 265.07,41.89 265.02,41.94 265.02,42.72 265,42.72 264.97,42.73 264.95,42.77 264.95,42.84 265.16,43.04 265.16,43.09 265.21,43.14 265.21,43.36 265.21,43.38 265.22,43.4 265.32,43.65 265.22,43.91 265.21,43.92 265.21,43.94 265.21,45.94 264.94,46.21 264.94,47.83 264.57,48.19 264.57,49.87 265.06,50.36 266.87,50.36
+3V_DEEP_SUS on TOP (solid shape): 256.53,73.49 256.53,72.94 256.22,72.63 256.22,72.07 256.88,71.41 256.88,71.26 256.6,70.98 256.47,70.98 256.22,71.24 255.93,71.24 255.51,70.81 255.51,69.86 255.33,69.69 255.18,69.69 254.03,70.83 252.97,70.83 252.76,71.03 252.76,71.29 252.94,71.46 253.47,71.46 253.63,71.63 253.63,71.83 253.65,71.85 253.65,71.97 253.52,72.1 253.52,72.61 254.03,73.12 254.06,73.09 254.13,73.09 254.67,72.56 254.67,72.41 254.46,72.2 254.4,72.11 254.4,72 254.4,71.73 254.66,71.46 255.02,71.46 255.04,71.44 255.49,71.29 255.72,71.7 255.72,72.39 255.81,72.48 255.81,73.24 255.68,73.37 255.68,73.88 255.81,74 256.01,74
+3V_DEEP_SUS on TOP (solid shape): 251.11,93.69 251.11,91.52 251.1,91.49 251.08,91.48 250.91,91.33 250.87,91.1 250.89,90.94 250.96,90.8 250.98,90.79 250.97,90.75 250.08,89.86 250.08,89.61 249.84,89.37 249.84,88.73 249.7,88.59 249.7,87.15 249.96,86.9 249.96,86.54 249.8,86.38 248.94,86.38 248.19,87.13 248.19,89.43 248.49,89.9 248.74,90.4 248.81,90.61 248.88,90.83 249.53,91.47 249.58,91.51 249.65,91.54 249.72,91.51 250.34,91.81 249.69,92.03 249.65,92.01 249.61,92.03 249.6,92.04 249.59,92.07 249.59,93.56 249.84,93.82 250.98,93.82
+3V_DEEP_SUS on TOP (solid shape): 260.99,84.55 261.03,84.55 261.12,84.52 261.21,84.46 261.29,84.4 261.39,84.39 261.41,84.39 261.71,84.1 261.71,83.87 262.47,83.12 262.77,83.12 262.86,83.06 262.85,82.95 263.25,82.55 263.25,82.47 263.88,81.85 263.88,81.83 264.26,81.45 264.26,81.44 264.28,81.38 264.32,81.33 264.53,81.12 264.57,81.09 264.57,80.52 263.67,80.52 263.67,80.78 263.42,81.04 263.4,81.13 263.46,81.2 263.58,81.72 263.05,81.61 262.99,81.54 262.89,81.56 262.25,82.21 262.23,82.3 262.29,82.37 262.41,82.89 261.89,82.77 261.82,82.71 261.73,82.73 261.06,83.39 260.68,83.39 260.68,84.32 260.93,84.57
+3V_DEEP_SUS on BOTTOM (solid shape): 270.98,50.72 271.48,50.72 277.45,44.74 277.45,42.22 277.07,41.84 276.11,41.84 275.92,42.04 275.92,43.85 271.3,48.48 269.64,48.48 269.09,49.03 266.91,49.03 265.91,50.03 265.91,50.58 266.22,50.89 270.81,50.89
+3V_DEEP_SUS on BOTTOM (solid shape): 256.06,64.48 256.06,64.23 254.67,62.83 254.41,62.83 253.44,63.8 253.44,64.1 253.63,64.3 253.96,64.3 253.96,64.3 254.1,64.3 254.36,64.55 254.36,65 254.48,65.12 255.42,65.12
+3V_DEEP_SUS on IN1 (solid shape): 251.72,94.81 251.72,94.4 251.7,94.37 251.68,94.36 251.51,94.24 251.44,94.04 251.43,94.01 251.09,93.66 251.09,92.78 250.83,92.52 249.94,92.52 249.69,92.78 249.69,94.17 250.83,95.32 251.21,95.32
+3V_DEEP_SUS on IN1 (solid shape): outline of 169 points within 187.15,150.09 194.24,159.22
+3V_DEEP_SUS on IN2 (solid shape): outline of 258 points within 259.49,75.87 269.43,84.46
+3V_DEEP_SUS on IN2 (solid shape): outline of 292 points within 248.32,85.31 260.13,89.24
+3V_DEEP_SUS on IN2 (solid shape): outline of 1636 points within 247.43,63.21 255.3,80.43
+3V_DEEP_SUS on IN3 (solid shape): outline of 775 points within 253.52,49.81 267.24,65.14
+3V_DP on TOP (solid shape): 360.71,42.13 360.71,40.35 360.46,40.1 358.55,40.1 358.3,40.35 358.3,42.13 358.55,42.38 360.46,42.38
+3V_DP on BOTTOM (solid shape): 361.35,44.16 361.35,42.13 360.33,41.11 358.68,41.11 358.55,41.24 358.55,43.02 360.08,44.54 360.97,44.54
+3V_DP on BOTTOM (solid shape): 346.87,48.22 346.87,47.59 347.12,47.33 347.5,47.33 347.63,47.21 347.63,46.95 347.5,46.83 346.62,46.83 346.23,47.21 345.35,47.21 345.22,47.33 345.22,48.22 345.35,48.35 346.74,48.35
+3V_DP on BOTTOM (solid shape): 338.69,35.83 338.69,35.74 337.87,35.74 337.87,35.54 338.69,35.54 338.69,35.21 338.61,35.14 338.61,34.41 339.12,33.9 339.12,33.39 339.05,33.31 337.55,33.31 337.54,33.32 337.45,33.44 337.34,33.53 337.33,33.55 337.33,33.86 337.34,33.87 337.34,35.32 337.47,35.45 337.47,35.64 337.73,35.9 338.61,35.9
+3V_DP on BOTTOM (solid shape): 329.45,54.71 329.49,54.69 329.51,54.66 329.51,53.96 329.71,53.96 329.71,54.66 329.72,54.69 329.76,54.71 329.97,54.71 330.12,54.56 330.12,54.54 330.23,54.29 330.48,54.18 330.5,54.18 330.81,53.87 330.86,53.8 330.93,53.75 331.5,53.18 332.85,53.18 332.97,53.06 332.97,52.11 332.83,51.98 331.39,51.98 331.01,52.11 330.73,51.82 330.68,51.78 330.33,51.78 330.23,51.88 330.23,53.23 330.03,53.43 329.59,53.43 329.34,53.68 329.32,53.7 329.31,53.74 329.31,54.66 329.32,54.69 329.36,54.71
+3V_DREAM on BOTTOM (solid shape): 18.22,58.87 18.22,56.48 17.84,56.1 14,56.1 13.82,56.28 13.82,57.16 14.54,57.88 14.54,58.82 14.61,58.89 14.97,58.89 15.02,58.84 15.02,57.85 15.2,57.67 17.53,57.67 17.71,57.85 17.71,58.82 17.84,58.94 18.14,58.94
+3V_DREAM on IN1 (solid shape): outline of 156 points within 12.1,57.16 17.66,65.24
+3V_ECACC on TOP (solid shape): 264.57,25.74 264.57,25.36 263.05,23.84 260.64,23.84 260.38,24.09 260.38,24.89 262.55,24.89 262.56,24.84 262.57,24.79 262.59,24.74 262.62,24.69 262.66,24.65 262.7,24.61 262.74,24.58 262.79,24.56 262.84,24.55 262.9,24.54 262.95,24.54 263,24.55 263.05,24.56 263.1,24.58 263.15,24.61 263.19,24.65 263.22,24.69 263.25,24.74 263.27,24.79 263.29,24.84 263.29,24.89 263.29,24.95 263.28,25 263.26,25.05 263.24,25.1 263.21,25.14 263.17,25.18 263.13,25.21 263.08,25.24 263.03,25.26 262.98,25.27 262.92,25.28 262.87,25.27 262.82,25.26 262.77,25.24 262.72,25.21 262.68,25.18 262.64,25.14 262.61,25.1 262.58,25.05 262.56,25 262.55,24.95 262.55,24.89 260.38,24.89 260.38,25.11 260.51,25.24 260.89,25.24 261.14,25.49 261.68,25.49 261.79,25.61 263.98,25.61 264.22,25.85 264.47,25.85
+3V_FP on TOP (solid shape): 291.24,11.52 291.24,10.25 291.24,10.22 291.21,10.2 291,9.87 291.21,9.54 291.24,9.52 291.24,9.49 291.24,7.98 291.22,7.95 291.2,7.95 291.09,7.92 290.99,7.86 290.93,7.83 290.86,7.86 290.26,7.71 290.62,7.22 290.66,7.2 290.68,7.16 290.66,7.13 290.61,7.08 288.83,7.08 288.58,7.33 288.58,7.96 289.34,8.73 289.34,11.9 289.47,12.03 290.74,12.03
+3V_FP on BOTTOM (solid shape): 290.35,9.36 290.35,8.78 290.34,8.7 290.34,7.84 290.32,7.82 290.29,7.78 290.27,7.73 290.25,7.67 290.24,7.62 290.24,7.56 290.25,7.5 290.26,7.45 290.28,7.4 290.1,7.2 288.45,7.2 288.2,7.46 288.2,8.05 290.05,8.05 290.05,9.35 289.85,9.35 289.85,8.05 288.2,8.05 288.2,8.71 288.22,8.74 288.27,8.75 288.32,8.76 288.37,8.78 288.41,8.81 288.45,8.84 288.49,8.88 288.52,8.93 288.54,8.98 288.56,9.03 288.56,9.08 288.56,9.14 288.56,9.19 288.54,9.24 288.52,9.29 288.49,9.33 288.45,9.37 288.41,9.42 288.41,9.44 288.45,9.49 290.23,9.49
+3V_TS on BOTTOM (solid shape): 29.93,52.01 29.93,50.61 29.8,50.48 28.05,50.48 27.85,50.69 27.85,51.98 28.07,52.21 29.72,52.21
+3V_TS on BOTTOM (solid shape): 28.84,59.81 28.84,57.32 28.61,57.09 28.61,55.29 29.22,54.68 31.32,54.68 31.48,54.52 31.48,53.76 31.25,53.53 27.67,53.53 27.51,53.68 27.51,59.81 27.59,59.88 28.76,59.88
+3V_TS on IN4 (solid shape): 29.45,54.73 29.45,50.64 29.29,50.48 27.79,50.48 27.51,50.76 27.51,54.7 28,55.18 28.99,55.18
+3V_VCC on BOTTOM (solid shape): 270.73,36.79 270.76,36.79 270.79,36.78 270.98,36.78 271.06,36.74 271.08,36.65 271.44,36.17 271.78,36.66 271.79,36.75 271.88,36.79 272.32,36.79 272.36,36.76 272.37,36.73 272.34,36.48 272.43,36.29 272.44,36.27 272.45,36.25 272.45,35.9 272.19,35.65 271.05,35.65 270.8,35.4 270.8,32.86 270.54,32.6 270.16,32.6 270.03,32.73 270.03,34.25 270.16,34.38 270.16,35.31 270.17,35.4 270.16,35.52 270.14,35.55 270.06,35.66 269.96,35.73 269.95,35.73 269.91,35.78 269.91,36.54 270.16,36.79
+3V_WLAN_P on BOTTOM (solid shape): 331.5,79.97 331.5,76.42 331.38,76.29 330.74,76.29 330.17,76.86 329.77,76.86 329.74,76.88 329.72,76.91 329.72,77.1 327.83,77.1 327.83,76.75 327.82,76.74 327.82,75.53 327.69,75.4 325.66,75.4 325.28,75.78 325.28,78.2 325.73,78.65 325.79,78.65 325.79,78.71 326.24,79.15 326.3,79.21 326.35,79.27 326.55,79.47 329.98,79.47 330.61,80.1 331.38,80.1
+3V_WWAN_P on TOP (solid shape): 343.14,27.96 343.14,24.74 342.64,24.25 340.75,24.25 340.52,24.47 340.52,27.52 341.03,28.03 343.07,28.03
+3V_WWAN_P on TOP (solid shape): outline of 412 points within 328.07,15.69 334.47,25.88
+3V_WWAN_P on BOTTOM (solid shape): 331.34,23.47 331.34,22.13 331.76,21.71 331.76,19.39 331.38,19.01 331.38,18.51 331.76,18.12 331.76,17.06 331.75,17.06 331.75,16.99 331.73,16.96 331.7,16.95 331.64,16.95 331.64,15.4 331.7,15.39 331.71,15.38 331.72,15.36 331.72,15.34 331.63,15.24 329.56,15.24 329.4,15.4 331.36,15.4 331.36,16.95 331.14,16.95 331.14,15.4 329.4,15.4 328.73,16.07 328.73,21.31 328.72,21.32 328.72,23.24 328.77,23.27 328.82,23.3 328.85,23.34 328.88,23.37 328.91,23.42 328.93,23.47 328.94,23.51 328.95,23.56 329.12,23.73 331.08,23.73
+3V_WWAN_P on BOTTOM (solid shape): 347,26.43 347,24.4 347.28,24.12 347.28,20.94 349.66,18.56 349.66,15.24 349.41,14.98 347.89,14.98 347.76,15.11 347.77,15.38 347.78,15.39 348.86,15.4 348.86,16.95 348.64,16.95 348.64,15.4 348.36,15.4 348.36,16.95 348.14,16.95 348.14,15.4 347.86,15.4 347.86,16.95 347.78,16.96 347.77,16.97 347.76,17.14 347.41,17.49 347.39,17.53 347.37,17.58 347.33,17.63 347.29,17.67 347.24,17.71 347.19,17.73 347.15,17.75 346.87,18.03 346.87,19.32 345.5,20.69 344.56,20.69 344.09,21.16 344.09,22.16 344.56,22.63 344.56,23.55 343.97,24.14 343.95,24.16 343.91,24.2 343.87,24.24 343.82,24.26 343.77,24.28 343.71,24.29 343.66,24.3 343.6,24.29 343.55,24.28 343.5,24.26 343.46,24.23 343.42,24.24 343.31,24.35 343.12,24.35 342.55,24.91 342.55,27.12 342.77,27.33 346.09,27.33
+3V_WWAN_P on IN2 (solid shape): outline of 630 points within 329.19,15.97 345.6,27.65
+3VCARD on BOTTOM (solid shape): outline of 133 points within 28.53,61.33 38.4,66.83
+3VCARD_1 on BOTTOM (solid shape): 29.72,66.42 29.72,65.45 29.52,65.24 29.52,64.39 29.43,64.3 28.61,64.3 28.51,64.4 28.51,65.09 29.19,65.78 29.19,66.26 29.52,66.59 29.56,66.59
+3VLANVCC on TOP (solid shape): 43.59,70.7 43.59,67.53 42.96,66.89 42.96,64.61 42.83,64.48 42.32,64.48 41.86,64.02 41.84,64.01 41.78,64.02 41.13,64.02 41.09,64.08 41.1,64.12 41.12,64.14 41.52,64.14 41.52,64.94 41.32,64.94 41.32,64.14 41.12,64.14 41.12,64.94 41.07,64.95 41.06,64.96 41.05,65.06 41.13,65.14 41.13,65.42 41.13,65.43 41.14,65.45 41.17,65.47 41.21,65.52 41.24,65.56 41.27,65.61 41.29,65.67 41.29,65.72 41.29,65.78 41.29,65.83 41.27,65.89 41.24,65.94 41.21,65.98 41.17,66.03 41.14,66.05 41.13,66.07 41.13,66.25 41.16,66.29 41.19,66.31 41.22,66.33 41.25,66.36 41.27,66.4 41.29,66.44 41.29,66.5 41.31,66.51 41.31,70.7 41.56,70.96 43.34,70.96
+3VLANVCC on BOTTOM (solid shape): 23.29,123.52 23.31,123.4 23.22,123.34 22.34,123.34 22.34,123.14 23.35,123.14 23.39,123.13 23.4,123.09 23.4,122.99 23.39,122.96 23.35,122.94 22.34,122.94 22.34,122.91 22.33,122.87 22.29,122.86 22.23,122.86 22.23,122.84 22.2,122.81 22.11,122.81 22.07,122.77 21.11,122.77 20.99,122.9 20.99,123.15 21.13,123.29 21.16,123.29 21.28,123.41 21.35,123.41 21.37,123.39 21.69,123.3 21.96,123.51 21.96,123.52 21.99,123.53 23.27,123.53
+3VLANVCC on BOTTOM (solid shape): 32.16,125.82 32.16,125.06 32.1,124.87 31.66,124.42 29.68,124.42 29.64,124.46 29.58,124.46 29.55,124.47 29.54,124.51 29.54,124.54 28.53,124.54 28.49,124.56 28.48,124.59 28.48,124.68 28.55,124.74 29.54,124.74 29.54,124.75 29.55,124.79 29.59,124.8 29.62,124.8 29.64,124.83 29.65,124.83 29.69,124.87 29.83,124.87 29.85,124.89 29.87,124.9 29.9,124.9 30.29,125.07 30.26,125.5 30.26,125.69 30.51,125.95 32.04,125.95
+3VLANVCC on IN2 (solid shape): outline of 779 points within 20.45,116.82 32.67,130.27
+3VLANVCC on IN4 (solid shape): outline of 1356 points within 26.08,69.29 44.38,119.08
+3VLCD_CON on TOP (solid shape): 55.71,57.22 55.71,56.33 55.45,56.07 55.42,56.06 55.39,56.06 55.35,56.08 55.3,56.08 55.02,56.08 54.92,56.06 54.85,56 54.77,55.96 54.69,56 54.61,56.06 54.52,56.08 54.24,56.08 54.09,56.02 54.02,55.87 54.02,55.79 53.96,55.73 53.96,55.16 53.92,55.11 53.9,55.04 53.9,55.03 53.87,55.01 53.19,55.01 52.97,54.78 52.97,54.17 52.69,53.89 51.11,53.89 50.93,54.07 50.93,56.5 51.75,57.32 55.61,57.32
+3VLCD_CON on BOTTOM (solid shape): 53.98,56.96 54.15,56.96 54.77,56.33 54.77,55.59 54.48,55.3 54.45,55.28 54.39,55.3 54.34,55.32 54.29,55.32 54.23,55.32 54.18,55.31 54.12,55.3 54.07,55.27 54.03,55.24 53.99,55.2 53.95,55.16 53.93,55.11 53.91,55.06 53.89,55 53.89,54.95 53.9,54.89 53.91,54.84 53.93,54.79 53.96,54.74 54,54.7 54.04,54.66 54.06,54.65 54.06,53.17 53.89,52.99 52.95,52.99 52.81,53.13 52.81,53.2 53.81,53.2 53.81,54.35 53.56,54.35 53.56,53.2 53.31,53.2 53.31,54.35 53.06,54.35 53.06,53.2 52.81,53.2 52.81,54.38 52.36,54.83 52.36,56.7 52.62,56.96 53.97,56.96
+3VPCU on TOP (solid shape): 115.89,100.06 115.89,99.66 115.73,99.5 114.89,99.5 114.67,99.73 114.67,100.09 114.98,100.4 115.54,100.4
+3VPCU on TOP (solid shape): 196.98,80.08 196.98,79.21 196.88,79.11 194.77,79.11 194.6,79.29 194.6,79.82 194.87,80.1 196.32,80.1 196.4,80.18 196.88,80.18
+3VPCU on TOP (solid shape): 263,40.62 263.17,40.62 263.2,40.6 263.22,40.57 263.22,39.76 263.42,39.76 263.42,40.57 263.43,40.6 263.47,40.62 263.54,40.62 263.62,40.54 263.62,39.76 263.63,39.76 263.67,39.75 263.68,39.71 263.68,39.64 263.48,39.44 263.48,38.5 263.43,38.44 261.14,38.44 260.89,38.7 260.89,40.6 261.02,40.73 262.89,40.73
+3VPCU on TOP (solid shape): 268.89,33.36 268.89,32.06 268.72,31.89 268.72,30.91 268.64,30.82 268,30.82 267.88,30.95 267.88,31.44 267.88,31.47 267.91,31.49 268.13,31.83 267.91,32.17 267.88,32.19 267.88,32.22 267.88,33.11 268.26,33.49 268.76,33.49
+3VPCU on TOP (solid shape): 42.32,62.57 43.09,62.57 43.21,62.45 43.21,61.3 43.2,61.26 43.2,61.2 43.2,61.14 43.21,61.11 43.21,60.92 43.09,60.8 41.59,60.8 41.05,61.34 41.05,61.94 41.06,61.96 41.07,61.98 41.52,61.99 41.52,62.79 41.32,62.79 41.32,61.99 41.12,61.99 41.12,62.79 41.1,62.8 41.09,62.85 41.13,62.9 41.78,62.9 41.79,62.93 41.8,62.95 41.94,62.96
+3VPCU on TOP (solid shape): 268.33,40.73 268.36,40.72 268.38,40.68 268.38,38.95 268.32,38.77 268.36,38.59 268.35,38.49 268.26,38.44 265.76,38.44 265.67,38.54 265.67,38.99 264.98,39.68 264.97,39.73 265.01,39.76 265.02,39.76 265.02,40.57 265.03,40.6 265.07,40.62 265.17,40.62 265.2,40.6 265.22,40.57 265.22,39.76 265.42,39.76 265.42,40.57 265.43,40.6 265.47,40.62 266.78,40.62 266.89,40.73
+3VPCU on TOP (solid shape): outline of 104 points within 272.19,34 274.86,36.92
+3VPCU on TOP (solid shape): outline of 83 points within 179.99,152.87 186.72,159.86
+3VPCU on BOTTOM (solid shape): 328.45,74.13 328.45,71.22 328.43,71.19 328.41,71.19 328.29,71.12 328.24,70.98 328.24,70.72 328.09,70.58 326.04,70.58 325.58,71.04 325.58,74.43 325.66,74.51 328.07,74.51
+3VPCU on BOTTOM (solid shape): 334.42,26.25 334.42,25.64 334.41,25.63 334.41,25.24 334.25,25.08 333.75,25.08 333.48,24.8 333.48,23.73 333.08,23.33 333.08,22.87 333.33,22.62 333.33,22.36 333.21,22.24 331.74,22.24 331.65,22.33 331.65,26.1 331.93,26.38 334.3,26.38
+3VPCU on BOTTOM (solid shape): 125,115.39 125,114.95 124.11,114.07 123.79,114.07 123.62,113.9 123.62,113.5 123.51,113.4 123.41,113.5 123.41,113.98 123.88,114.45 123.88,115.1 124.29,115.51 124.87,115.51
+3VPCU on BOTTOM (solid shape): 178.76,147.76 179.4,147.76 179.61,147.76 179.92,147.45 179.92,146.41 179.84,146.33 179.56,146.33 178.58,147.31 178.58,147.65 178.41,147.82 178.01,147.82 177.91,147.93 178.01,148.03 178.5,148.03
+3VPCU on BOTTOM (solid shape): 124.16,127.55 124.16,127.04 123.25,126.13 122.9,126.13 122.73,125.96 122.73,125.56 122.63,125.46 122.52,125.56 122.52,126.05 123.06,126.59 123.06,126.59 123.1,126.63 123.1,127.15 123.6,127.65 124.06,127.65
+3VPCU on BOTTOM (solid shape): 261.27,41.53 261.27,40.35 262.03,39.59 262.03,38.75 261.73,38.44 260.89,38.44 259.37,39.97 259.37,40.98 258.73,41.62 256.39,41.62 256.31,41.66 256.29,41.75 256.3,41.8 256.31,41.86 256.1,42.21 255.7,42.15 255.67,42.14 255.65,42.12 255.15,41.62 254.79,41.62 254.67,41.75 254.67,41.93 254.67,41.94 254.7,42.08 254.68,42.22 254.67,42.24 254.68,42.27 255.45,43.04 255.92,42.79 256.16,43.27 259.53,43.27
+3VPCU on BOTTOM (solid shape): outline of 113 points within 224.44,53.05 230.92,57.49
+3VPCU on BOTTOM (solid shape): outline of 242 points within 265.72,32.86 277.42,41.46
+3VPCU on IN1 (solid shape): outline of 503 points within 186.88,30.95 195.89,80.25
+3VPCU on VCC (solid shape): outline of 15122 points within 187.03,24.09 334.68,74.13
+3VPCU on IN2 (solid shape): outline of 4908 points within 41.31,28.16 188.58,70.58
+3VPCU_S on BOTTOM (solid shape): 224.33,54.42 224.33,52.55 227.22,52.55 227.36,52.41 227.36,51.02 227.37,51.01 227.37,50.8 227.57,50.61 227.67,50.61 227.67,50.6 227.99,50.6 228.09,50.51 228.09,47.99 227.94,47.84 221.52,47.84 221.51,47.85 221.07,47.85 220.55,48.36 220.52,48.38 220.5,48.41 220.5,49.87 220.89,50.26 222.03,50.26 222.79,51.02 222.79,53.49 222.8,53.53 222.84,53.54 223.27,53.54 223.27,54.43 223.41,54.57 224.17,54.57
+5V on TOP (solid shape): 40.67,70.58 40.67,68.8 40.55,68.67 40.16,68.67 39.4,67.91 39.4,66.02 39.38,66 39.35,65.95 39.32,65.91 39.3,65.85 39.29,65.8 39.29,65.75 39.29,65.69 39.3,65.64 39.33,65.59 39.35,65.54 39.39,65.49 39.43,65.46 39.45,65.44 39.45,65.4 39.72,65.13 39.72,64.14 39.74,64.12 39.75,64.08 39.71,64.02 39.06,64.02 39,64 38.85,64.14 39.52,64.14 39.52,64.94 39.32,64.94 39.32,64.14 38.85,64.14 38.39,64.61 37.88,64.61 37.75,64.73 37.75,65.96 37.78,65.99 37.8,65.99 37.8,67.1 37.37,67.52 37.37,67.78 37.88,68.29 37.88,70.58 38.13,70.83 40.42,70.83
+5V on TOP (solid shape): 47.25,50.67 49.91,50.67 50.07,50.51 50.07,50 49.24,49.17 48.71,49.17 48.69,49.17 48.32,48.97 48.39,48.55 48.69,48.25 48.69,48.09 48.7,48.02 48.73,47.96 48.74,47.93 48.73,47.9 48.55,47.72 46.51,47.72 46.26,47.97 44.36,47.97 44.23,48.1 44.23,49.11 44.61,49.49 44.61,50.64 45.12,51.14 46.77,51.14
+5V on TOP (solid shape): 326.84,12.7 326.92,12.66 326.94,12.58 327.25,12.17 327.67,12.47 327.71,12.53 327.78,12.55 327.84,12.55 327.95,12.44 327.95,12.44 328.45,11.93 328.45,11.17 328.36,11.07 326.15,11.07 326.09,11.25 325.94,11.37 325.92,11.39 325.91,11.42 325.91,12.57 326.04,12.7
+5V on BOTTOM (solid shape): 322.49,75.53 322.49,74.77 322.36,74.64 321.36,74.64 320.85,74.13 320.85,73.6 320.85,73.6 320.96,73.49 320.96,72.73 322.36,71.34 322.36,70.45 321.98,70.07 321.09,70.07 319.82,71.34 319.82,74.64 320.83,75.66 322.36,75.66
+5V on BOTTOM (solid shape): 48.42,50.1 48.42,49.12 48.41,49.1 48.4,49.08 48.28,48.81 48.4,48.53 48.41,48.52 48.42,48.5 48.42,47.91 48.12,47.61 44.47,47.61 44.17,47.91 44.17,49.68 44.8,50.31 48.22,50.31
+5V on BOTTOM (solid shape): outline of 83 points within 23.02,97.12 29.6,99.79
+5V on VCC (solid shape): outline of 14347 points within 46.51,6.95 350.81,50.89
+5V on IN2 (solid shape): 40.51,70.09 40.51,68.87 40.18,68.54 39.45,68.54 39.15,68.85 39.14,68.85 39.14,70.3 39.32,70.48 40.11,70.48
+5V on IN2 (solid shape): outline of 663 points within 319.06,30.19 336.58,71.46
+5V on IN4 (solid shape): outline of 2181 points within 23.37,47.48 48.85,99.3
+5V_AMP on TOP (solid shape): 228.76,158.89 228.76,157.57 228.15,156.96 225.69,156.96 225.05,157.6 225.05,158.69 225.2,158.84 226.52,158.84 227.39,159.7 227.95,159.7
+5V_AMP on BOTTOM (solid shape): 230.05,158.64 230.05,153.84 229.78,153.56 227.26,153.56 227.2,153.62 227.2,157.15 226.87,157.48 225.1,157.48 224.86,157.72 224.8,157.72 224.56,157.81 224.33,157.72 223.16,157.72 223.1,157.78 223.1,157.93 223.18,158.01 223.21,158.02 223.29,158.03 223.37,158.08 223.4,158.09 223.63,158.09 225.2,159.66 229.03,159.66
+5V_AMP on BOTTOM (solid shape): 199.98,159.7 199.98,159.35 199.68,159.04 199.68,157.8 198.91,157.03 198.91,156.05 198.92,156.04 198.92,155.98 199.1,155.8 199.1,155.5 199.04,155.44 198.87,155.44 198.82,155.5 198.81,155.52 198.81,155.53 198.76,155.7 198.61,155.78 198.59,155.78 198.46,155.91 198.45,155.94 198.45,155.96 198.1,156.4 197.76,155.96 197.76,155.95 197.75,155.92 197.71,155.88 196.18,155.88 196.03,156.02 196.03,158.9 196.44,159.31 196.49,159.35 196.56,159.37 196.63,159.35 197.09,159.32 197.18,159.78 197.18,159.88 197.27,159.93 199.76,159.93
+5V_AMP on IN2 (solid shape): outline of 1030 points within 197.26,152.14 228.76,159.86
+5V_AUDIO on TOP (solid shape): 334.32,11.04 334.55,10.98 334.77,11.04 335.43,10.38 336.07,10.38 336.07,10.18 335.53,10.18 335.44,10.09 334.63,10.09 334.56,10.16 333.25,10.16 332.91,9.82 332.88,9.83 332.46,9.08 333.2,9.5 333.2,9.53 333.42,9.76 333.58,9.76 333.66,9.7 333.66,9.6 333.62,9.5 333.61,9.4 333.96,8.97 334.44,9.23 334.45,9.25 334.5,9.28 335.42,9.28 335.42,9.27 335.52,9.27 335.53,9.25 335.53,9.23 335.53,9.18 336.07,9.18 336.07,8.98 335.53,8.98 335.53,8.96 335.48,8.9 335.42,8.9 335.42,8.89 334.95,8.89 334.26,8.2 334.23,8.19 334.2,8.2 334.18,8.21 333.79,8.38 333.44,8.12 327.97,8.12 327.88,8.18 327.88,8.28 327.9,8.63 327.61,8.84 327.54,8.89 327.53,8.98 327.54,9.21 327.4,9.41 327.36,9.49 327.4,9.57 327.53,9.99 327.16,10.24 327.09,10.27 327.06,10.34 327.06,10.54 327.29,10.77 331.35,10.77 331.38,10.79 332.98,10.79 333.24,11.04
+5V_HDD on BOTTOM (solid shape): 45.73,46.95 45.73,45.14 45.7,45.07 45.63,45.04 45.26,44.67 45.63,44.3 45.7,44.27 45.73,44.2 45.73,44.16 44.61,43.04 44.61,42.84 44.6,42.82 44.52,42.65 44.5,42.46 44.51,42.33 44.55,42.2 44.55,42.19 44.36,42 41.18,42 40.8,42.38 40.8,43.14 38.39,45.56 38.39,46.98 38.49,47.08 45.6,47.08
+5V_HDMIC on BOTTOM (solid shape): outline of 151 points within 354.38,88.15 362.11,92.55
+5V_IR_LED on TOP (solid shape): 44.36,51.91 44.36,49.49 43.09,48.22 41.18,48.22 40.8,48.6 40.8,51.27 41.82,52.29 43.97,52.29
+5V_IR_LED on BOTTOM (solid shape): 43.72,52.08 43.72,50 43.47,49.75 41,49.75 40.93,49.82 40.93,51.53 41.64,52.24 43.57,52.24
+5V_IR_LED_L on BOTTOM (solid shape): 46.56,54.51 46.56,51.46 46.27,51.17 44.51,51.17 44.3,51.38 44.3,53.2 46.31,53.2 46.31,54.35 46.06,54.35 46.06,53.2 44.3,53.2 44.3,54.52 44.42,54.64 46.43,54.64
+5V_LED_KBLIGHT on TOP (solid shape): 192.48,48.3 192.68,48.3 192.68,49.49 192.98,49.49 192.98,48.3 193.06,48.3 193.06,48.19 195.1,48.19 195.1,48.3 195.18,48.3 195.18,49.49 195.48,49.49 195.48,48.3 195.68,48.3 195.68,49.49 195.99,49.49 195.99,48.15 195.84,48 195.26,48 194.85,47.59 194.85,46.57 195.1,46.32 195.99,46.32 196.12,46.19 196.12,45.46 195.71,45.05 194.98,45.05 194.6,44.67 194.09,44.67 193.2,45.56 193.2,47.57 193.07,47.69 192.2,47.69 192.15,47.75 192.15,49.49 192.48,49.49
+5V_USBP1 on TOP (solid shape): 359.29,72.07 359.29,70.19 358.76,69.66 358.25,69.66 357.66,70.25 357.66,70.58 358.05,70.96 358.05,72.02 358.35,72.33 359.04,72.33
+5V_USBP1 on TOP (solid shape): outline of 118 points within 348.14,78.58 356.14,83.4
+5V_USBP1 on IN4 (solid shape): outline of 181 points within 354.84,69.69 361.52,83.81
+5V_USBP2 on TOP (solid shape): 22.48,103.55 22.48,103.53 22.48,103.52 22.56,103.19 22.87,103.07 22.87,102.13 22.87,102.1 22.88,102.06 22.88,101.72 22.87,101.7 22.86,101.69 22.84,101.67 21.06,101.67 20.81,101.92 20.41,101.92 20.35,101.92 20.3,101.92 19.71,101.92 19.69,101.93 19.67,101.95 19.34,102.14 19.02,101.95 19,101.93 18.98,101.92 18.62,101.92 18.57,101.92 18.51,101.92 14.54,101.92 14.23,102.22 14.23,105.07 14.76,105.6 20.43,105.6
+5V_USBP2 on IN2 (solid shape): outline of 309 points within 10.09,101.82 19.16,112.87
+5V_USBP3 on TOP (solid shape): 19.21,94.83 19.21,93.66 20.17,92.7 20.66,92.7 20.94,92.42 20.94,90.03 20.43,89.52 17.1,89.52 16.8,89.83 16.8,92.14 16.31,92.62 14.26,92.62 13.24,93.64 12.45,93.64 11.97,93.16 11.97,92.06 11.59,91.68 10.65,91.68 10.29,92.04 10.29,93.66 10.93,94.3 12.68,94.3 13.34,94.96 19.08,94.96
+5V_USBP3 on IN2 (solid shape): outline of 142 points within 8.77,90.95 17.96,97.35
+5V_USBSRC on TOP (solid shape): 352.2,140.43 352.2,139.61 352.25,139.56 352.25,136.92 352.2,136.87 351.67,136.87 351.57,136.77 351.57,134.91 351.44,134.79 350.83,134.79 350.55,134.51 350.55,132.93 350.48,132.86 348.09,132.86 347.38,132.15 346.67,132.15 346.46,132.35 346.46,133.87 346.69,134.1 348.24,134.1 348.57,134.43 348.57,138.01 348.49,138.09 348.49,138.93 348.62,139.05 350.12,139.05 350.23,138.94 350.59,138.94 350.81,139.16 350.81,140.4 350.96,140.55 352.08,140.55
+5V_USBSRC on TOP (solid shape): 352.84,91.33 352.84,89.37 353.09,89.12 353.09,86.32 353.22,86.2 353.6,86.2 353.73,86.07 353.73,84.98 353.44,84.69 352.06,84.69 351.06,85.69 351.03,85.69 350.02,86.7 350.02,87.6 349.68,87.95 349.65,88.05 349.73,88.12 349.99,88.65 349.41,88.76 349.35,88.73 349.28,88.76 349.08,88.85 348.86,88.81 348.83,88.8 348.52,89.11 348.52,92.72 348.86,93.07 351.1,93.07
+5V_USBSRC on BOTTOM (solid shape): 352.58,90.74 352.58,87.47 352.33,87.21 350.3,87.21 350.17,87.34 350.17,89.04 349.97,89.24 348.47,89.24 348.14,89.58 348.14,93.69 348.28,93.83 349.5,93.83
+5V_USBSRC on BOTTOM (solid shape): 224.01,41.47 224.01,38.11 223.78,37.89 222.99,37.89 222.54,37.43 220.76,37.43 220.12,38.06 220.12,40.78 220.38,41.04 222.89,41.04 223.4,41.54 223.93,41.54
+5V_USBSRC on VCC (solid shape): outline of 24709 points within 219.23,32.35 354.11,139.28
+5V_USBSRC_P1 on BOTTOM (solid shape): 346.91,94.07 347.12,93.99 347.33,94.07 347.62,94.07 347.88,93.82 347.88,93.17 347.76,93.05 346.68,93.05 346.64,93.15 346.58,93.23 346.35,93.31 346.13,93.21 346.09,93.2 346.05,93.21 345.8,93.46 345.33,93.46 345.26,93.54 345.26,93.86 345.3,93.9 345.33,93.91 345.35,93.9 345.43,93.88 345.52,93.9 345.55,93.92 345.6,93.97 345.62,94.02 345.63,94.03 345.68,94.07
+5V_USBSRC_P2 on BOTTOM (solid shape): 345.18,93.01 345.27,92.97 345.29,92.94 345.32,92.92 345.36,92.84 345.32,92.75 345.28,92.72 345.25,92.49 345.45,92.38 345.54,92.41 345.61,92.48 345.68,92.53 345.76,92.5 346.23,92.04 346.44,92.04 346.51,92.01 346.54,91.93 346.65,91.67 346.92,91.59 347.02,91.62 347.11,91.68 347.14,91.72 347.17,91.77 347.19,91.78 347.63,91.78 347.88,91.54 347.88,90.9 347.6,90.62 347.23,90.62 346.82,91.02 346.8,91.03 346.6,91.09 346.4,91.02 346.18,91.02 346.05,91.08 345.92,91.08 345.91,91.08 345.89,91.09 344.84,92.14 344.84,92.78 344.94,92.88 344.96,92.89 345.04,92.91 345.1,92.97
+5V_USBSRC_S on TOP (solid shape): 224.95,36.29 224.95,35.02 224.57,34.63 223.3,34.63 223.04,34.38 223.04,33.87 222.92,33.75 222.16,33.75 221.9,34 221.9,36.41 222.41,36.92 224.31,36.92
+5V_USBSRC_S on BOTTOM (solid shape): 227.16,41.01 227.16,35.4 227.04,35.27 225.66,35.27 225.66,35.19 225.64,35.16 225.61,35.14 225.33,35.14 224.7,34.51 224.7,34.13 224.57,34 222.16,34 221.9,34.25 221.9,36.55 222.91,37.56 224.17,37.56 224.46,37.85 224.46,41.43 224.52,41.49 226.68,41.49
+5VPCU on TOP (solid shape): 106.59,27.78 106.59,23.84 106.2,23.46 104.65,23.46 104.48,23.53 104.29,23.51 104.26,23.51 104.24,23.52 104.17,23.59 104.17,25.62 104.68,26.13 104.68,27.65 105.06,28.03 106.33,28.03
+5VPCU on TOP (solid shape): 149.05,155.13 149.41,155.13 149.53,155 149.41,154.88 149.05,154.88 148.95,154.78 147.33,154.78 147.2,154.9 147.2,155.51 147.27,155.59 148.59,155.59
+5VPCU on TOP (solid shape): 156.93,155.13 157.28,155.13 157.41,155 157.28,154.88 156.93,154.88 156.7,154.65 155.19,154.65 155.05,154.79 155.05,155.32 155.16,155.42 156.63,155.42
+5VPCU on TOP (solid shape): 165.05,155.13 165.41,155.13 165.54,155 165.41,154.88 165.05,154.88 164.85,154.67 163.3,154.67 163.18,154.79 163.18,155.25 163.29,155.35 164.83,155.35
+5VPCU on TOP (solid shape): 141.41,155.13 141.53,155 141.41,154.88 141.03,154.88 140.88,154.72 140.88,153.66 140.72,153.51 139.78,153.51 139.66,153.63 139.66,153.76 140.1,154.41 140.42,155.13
+5VPCU on TOP (solid shape): 22.89,99.28 22.89,97.88 22.08,97.07 22.08,94.6 21.77,94.3 21.77,93.18 21.6,93 20.23,93 20.07,93.16 20.07,95.39 19.46,96 18.47,96 18.02,96.46 18.02,98.57 18.35,98.9 20.48,98.9 20.49,98.91 20.51,98.91 20.74,99.02 20.85,99.25 20.85,99.27 20.99,99.4 22.77,99.4
+5VPCU on TOP (solid shape): 303.69,64.62 303.81,64.74 303.94,64.62 303.94,64.18 303.96,64.18 304.54,63.59 304.54,63.28 304.54,63.26 304.53,63.24 304.45,62.83 304.79,62.61 304.82,62.6 305.09,62.33 305.09,61.69 304.83,61.43 304.32,61.43 303.82,60.92 303.82,59.91 303.71,59.8 303.2,59.8 303.05,59.95 303.05,61.18 303.56,61.69 303.56,62.96 303.68,63.08 303.68,64.18 303.69,64.18
+5VPCU on TOP (solid shape): 39.04,62.95 39.05,62.93 39.06,62.9 39.71,62.9 39.75,62.85 39.74,62.8 39.72,62.79 39.72,61.99 39.76,61.98 39.78,61.96 39.63,61.7 39.59,61.66 39.58,61.64 39.2,61.26 39.2,61.03 38.95,60.79 38.95,60.75 38.91,60.72 38.87,60.7 38.66,60.7 38.62,60.73 38.58,60.75 38.54,60.75 38.38,60.76 37.69,60.76 37.6,60.67 37.37,60.67 36.99,61.05 36.99,61.99 39.52,61.99 39.52,62.79 39.32,62.79 39.32,61.99 36.99,61.99 36.99,62.32 37.24,62.57 38.51,62.57 38.89,62.96
+5VPCU on BOTTOM (solid shape): 210.34,57.84 210.34,56.45 210.22,56.32 209.96,56.32 209.33,56.95 209.33,57.84 209.46,57.97 210.22,57.97
+5VPCU on BOTTOM (solid shape): 231.78,152.9 231.78,151.84 231.56,151.7 231.49,151.45 231.48,151.42 231.19,151.12 230.09,151.12 229.78,151.44 228.85,151.44 228.56,151.73 228.56,152.96 228.68,153.08 230.2,153.08 230.22,153.09 231.59,153.09
+5VPCU on BOTTOM (solid shape): outline of 85 points within 188.02,38.67 201.07,48.45
+5VPCU on VCC (solid shape): outline of 23836 points within 18.96,26 232.19,161.49
+VCC0V9_LVR_OUT on TOP (solid shape): 346.46,117.21 346.47,117.13 346.49,117.07 346.49,116.64 346.49,116.63 346.5,116.39 346.68,116.23 346.69,116.23 346.72,116.19 346.89,116.19 347.01,116.3 347.12,116.42 347.12,117.06 347.25,117.18 347.63,117.18 347.76,117.06 347.76,116.31 347.75,116.28 347.68,116.2 347.65,116.1 347.65,115.8 347.65,115.75 347.66,115.73 347.66,115.7 347.65,115.68 347.5,115.53 346.86,115.53 346.78,115.55 346.7,115.53 345.85,115.53 345.73,115.66 345.73,116.17 345.35,116.55 345.2,116.55 345.16,116.56 345.15,116.59 345.05,116.75 344.88,116.84 344.84,116.89 344.84,117.18 344.96,117.31 346.36,117.31
+VCC0V9_PCIE on TOP (solid shape): 342.74,114.93 342.81,114.93 342.86,114.91 342.93,114.9 343.06,114.77 343.06,114.39 342.93,114.26 340.77,114.26 340.65,114.14 340.64,113.93 340.65,113.89 340.65,110.71 340.27,110.33 340.27,110.07 340.14,109.95 339.63,109.95 339.5,110.07 339.5,110.58 340.01,111.09 340.01,114.64 340.27,114.9 341.02,114.9 341.04,114.89 341.14,114.81 341.23,114.79 341.53,114.79 341.63,114.81 341.72,114.89 341.75,114.9 341.79,114.9 341.79,114.9 341.99,114.9 342.02,114.89 342.02,114.88 342.1,114.81 342.2,114.79 342.5,114.79 342.6,114.82 342.68,114.89
+VCC0V9_PCIE on BOTTOM (solid shape): 342.73,115.64 342.73,115.48 342.72,115.46 342.71,115.44 342.62,115.14 342.86,114.94 342.88,114.94 343.06,114.75 343.11,114.72 343.17,114.7 343.19,114.7 343.25,114.63 343.26,114.61 343.26,114.6 343.28,114.46 343.4,114.33 343.4,114.3 343.4,114.23 343.26,114.09 343.14,114.09 343.12,114.09 343.1,114.1 342.89,114.2 342.67,114.1 342.66,114.09 342.64,114.09 342.49,114.09 342.47,114.09 342.45,114.1 342.24,114.2 342.02,114.1 342.01,114.09 341.99,114.09 341.84,114.09 341.82,114.09 341.7,114.18 341.57,114.2 341.54,114.21 341.46,114.29 341.44,114.35 341.41,114.39 341.41,114.64 342.46,115.7 342.67,115.7
+VCC0V9_SVR on TOP (solid shape): 347.55,113.5 347.62,113.47 347.65,112.47 347.76,112.36 347.76,111.72 347.63,111.6 347.25,111.6 347.12,111.72 347.12,113.37 347.25,113.5
+VCC0V9_SVR on TOP (solid shape): 347.76,119.34 347.76,118.84 347.63,118.71 347.56,118.71 347.55,118.71 347.31,118.74 347.12,118.59 347.12,118.58 347,118.45 347,117.69 346.87,117.57 346.74,117.57 346.62,117.69 346.62,118.33 346.4,118.54 346.4,118.55 346.34,118.64 346.26,118.71 346.25,118.72 346.23,118.74 346.23,119.34 346.36,119.47 347.63,119.47
+VCC0V9_SVR on TOP (solid shape): 343.69,118.45 343.69,117.06 343.95,116.8 344.69,116.8 344.72,116.77 344.72,116.76 345.04,116.44 345.05,116.41 345.04,116.37 344.84,116.17 344.84,115.53 345.09,115.28 345.09,112.49 345.22,112.36 345.31,112.36 345.32,112.35 345.48,112.31 345.64,112.35 345.65,112.36 345.73,112.36 345.85,112.49 345.85,113.37 345.98,113.5 346.23,113.5 346.36,113.37 346.36,111.85 346.23,111.72 342.93,111.72 342.68,111.98 342.68,112.61 342.81,112.74 344.46,112.74 344.58,112.87 344.58,113.5 344.46,113.63 344.08,113.63 343.95,113.76 343.95,114.14 344.08,114.26 344.33,114.26 344.58,114.52 344.58,115.28 344.46,115.41 343.95,115.41 343.69,115.66 342.81,115.66 342.72,115.75 342.71,116.06 342.71,116.1 342.74,116.19 342.83,116.21 343.15,116.35 343.15,116.71 343.14,116.72 343.14,116.76 343.19,116.8 343.19,117.71 343.19,117.72 343.2,117.82 343.19,117.92 343.19,117.93 343.19,118.45 343.31,118.58 343.57,118.58
+VCC0V9_SVR on BOTTOM (solid shape): outline of 155 points within 352.08,115.79 356.27,125.19
+VCC0V9_SVR on BOTTOM (solid shape): outline of 213 points within 342.68,111.72 347.89,116.68
+VCC0V9_SVR on IN3 (solid shape): outline of 2113 points within 341.54,111.47 355.51,126.33
+VCC3P3_SX on TOP (solid shape): 355,117.95 355,115.91 354.82,115.74 353.85,115.74 353.8,115.68 353.69,115.68 353.69,115.57 353.68,115.56 353.68,113.98 353.73,113.93 353.73,112.94 354.79,111.88 354.79,108.84 354.89,108.74 354.89,108.72 355,108.38 355.34,108.3 355.35,108.3 355.38,108.29 356.01,108.29 357.29,107.01 357.3,106.99 357.4,106.76 357.63,106.66 357.65,106.66 358.05,106.26 358.05,105.24 357.96,105.16 357.48,105.16 357.35,105.29 357.26,105.29 357.26,105.83 356.83,106.26 356.01,106.26 355.63,105.88 355.6,105.88 355.19,106.12 354.88,105.77 354.62,105.5 354.36,105.5 354.11,105.75 354.11,106.26 354.25,106.41 355.2,106.41 355.2,106.41 355.49,106.49 355.58,106.94 355.47,107.07 355.43,107.15 355.47,107.23 355.5,107.26 355.53,107.29 355.53,107.77 355.05,107.84 355,107.8 354.87,107.8 354.12,108.55 353.98,108.55 353.66,108.87 353.66,112.3 353.47,112.49 352.58,112.49 352.43,112.64 351.97,112.64 351.59,113.02 351.59,113.4 351.68,113.48 351.76,113.48 351.79,113.51 352.34,113.51 352.93,114.1 352.93,116.35 353.62,117.05 353.62,117.89 353.8,118.07 354.87,118.07
+VCC_CORE on TOP (solid shape): outline of 2559 points within 134.91,108.3 171.62,139.92
+VCC_CORE on BOTTOM (solid shape): outline of 703 points within 154.42,107.92 174.45,110.21
+VCC_CORE on BOTTOM (solid shape): outline of 2804 points within 136.81,120.49 171.63,140.04
+VCC_CORE on VCC (solid shape): outline of 4346 points within 136.3,108.12 173.13,140.17
+VCC_CORE on IN2 (solid shape): outline of 4516 points within 135.67,108.26 173.17,140.79
+VCC_CORE on IN3 (solid shape): outline of 4040 points within 134.89,108.26 171.78,139.92
+VCC_CORE on IN4 (solid shape): outline of 4089 points within 135.57,111.09 171.23,139.92
+VCC_GT on TOP (solid shape): outline of 1298 points within 130.23,109.31 154.97,129.73
+VCC_GT on BOTTOM (solid shape): outline of 3947 points within 130.21,107.88 154.08,130.65
+VCC_GT on VCC (solid shape): outline of 4749 points within 129.7,107.53 153.96,129.88
+VCC_GT on IN2 (solid shape): outline of 4524 points within 127.21,109.02 153.88,129.73
+VCC_GT on IN3 (solid shape): outline of 4047 points within 130.33,108.99 153.88,129.73
+VCC_GT on IN4 (solid shape): outline of 4068 points within 130.33,111.97 153.88,129.73
+VCC_IO on TOP (solid shape): 189.36,133.87 189.36,130.34 189.26,130.24 185.15,130.24 184.89,130.49 184.89,131.33 185.4,131.84 185.41,131.84 186.19,132.33 186.86,132.97 187.92,134.03 189.21,134.03
+VCC_IO on TOP (solid shape): outline of 145 points within 173.26,110.93 175.55,119.31
+VCC_IO on BOTTOM (solid shape): 189.52,130.49 189.52,129.6 189.14,129.22 186.22,129.22 184.92,130.52 184.31,130.52 184.11,130.72 184.11,130.75 184.11,130.76 184.17,131.08 184.06,131.38 184.06,131.4 184.06,131.66 184.11,131.72 184.13,131.72 184.77,131.87 185.38,132.12 185.52,132.19 185.66,132.27 187.74,132.27
+VCC_IO on BOTTOM (solid shape): outline of 162 points within 172.81,110.04 175.69,119.98
+VCC_IO on VCC (solid shape): outline of 2904 points within 171.74,108.68 189.01,132.3
+VCC_IO on IN2 (solid shape): outline of 1638 points within 173.27,110.83 187.27,131.79
+VCC_IO on IN3 (solid shape): outline of 236 points within 259.01,85.64 262.95,90.82
+VCC_IO on IN3 (solid shape): outline of 240 points within 173.77,103.69 175.17,108.14
+VCC_IO on IN4 (solid shape): outline of 177 points within 173.08,111.29 174.82,119.56
+VCC_IO_S on BOTTOM (solid shape): outline of 184 points within 183.8,130.24 191.29,142.2
+VCC_SA on TOP (solid shape): outline of 1511 points within 170.75,109.87 180.12,140.77
+VCC_SA on BOTTOM (solid shape): outline of 151 points within 171.48,120.34 179.48,140.01
+VCC_SA on VCC (solid shape): outline of 1885 points within 171.23,119.98 180.5,140.17
+VCC_SA on IN2 (solid shape): outline of 626 points within 171.48,111.47 178.5,140.77
+VCC_SA on IN3 (solid shape): outline of 862 points within 171.48,116.3 178.8,140.77
+VCC_SA on IN4 (solid shape): outline of 784 points within 171.48,119.82 179.99,139.38
+VCCA_XTAL on TOP (solid shape): 241.08,74 241.08,71.32 241.05,71.28 241.01,71.25 240.94,71.23 240.88,71.26 240.34,71.24 240.4,70.7 240.44,70.62 240.41,70.54 239.53,69.67 239.51,69.65 239.49,69.65 239.4,69.66 239.31,69.65 239.24,69.66 239.19,69.71 238.84,69.97 238.49,69.71 238.59,69.33 238.97,69.25 239.01,69.25 239.04,69.22 239.04,69.18 239.03,69.16 238.75,68.88 238.72,68.86 238.69,68.87 238.27,68.79 238.2,68.38 238.2,68.35 238.19,68.32 237.93,68.07 237.6,67.98 237.49,67.65 237.49,67.64 237.48,67.61 237.4,67.53 237.2,67.53 237.18,67.53 237.16,67.54 236.89,67.67 236.61,67.54 236.59,67.53 236.57,67.53 233.97,67.53 233.71,67.78 233.71,68.44 234.02,68.75 235.79,68.75 236.02,68.98 236.02,69.37 236.4,69.75 236.82,69.75 238.1,71.03 238.12,71.04 238.22,71.03 238.29,71.04 238.38,71.07 238.51,71.16 238.56,71.25 238.59,71.35 238.58,71.51 238.5,71.65 238.48,71.72 238.5,71.78 238.56,71.88 238.59,71.98 238.6,72 239.44,72.84 239.45,72.84 239.56,72.92 239.63,73.03 239.64,73.04 239.68,73.08 239.68,74 239.94,74.26 240.82,74.26
+VCCA_XTAL on BOTTOM (solid shape): 231.25,69.31 232.96,69.31 232.98,69.28 232.99,69.26 233.02,69.16 233.07,69.07 233.1,69 233.07,68.93 233.13,68.37 233.67,68.53 233.75,68.59 233.84,68.56 233.97,68.43 234.33,68.43 234.47,68.29 234.47,67.81 234.43,67.77 231.47,67.77 230.34,68.9 230.34,69.11 230.68,69.46 230.7,69.47 230.72,69.47 231.08,69.47
+VCCAMPHYPLL on BOTTOM (solid shape): outline of 104 points within 252.38,48.07 256.95,52.99
+VCCAPLL on BOTTOM (solid shape): 232.85,70.73 232.92,70.73 233.03,70.64 233.1,70.6 233.18,70.58 233.22,70.58 233.29,70.6 233.34,70.64 233.43,70.73 234.21,70.73 236.09,68.86 236.38,68.86 236.5,68.74 236.5,68.67 236.25,68.42 236.02,68.42 235.93,68.47 235.7,68.71 235.53,68.71 235.49,68.72 235.45,68.73 235.4,68.73 235.34,68.72 234.77,68.72 234.57,68.91 234.17,68.91 233.88,69.2 233.86,69.3 233.94,69.37 234.14,70.01 233.52,69.77 233.48,69.7 233.41,69.68 233.37,69.68 233.3,69.69 232.57,69.69 232.21,70.04 232.21,70.17 231.99,70.39 231.99,70.4 231.93,70.54 231.82,70.64 231.6,70.8 231.33,70.78 231.32,70.77 231.29,70.78 230.66,71.4 230.66,71.66 231.17,72.16 231.42,72.16
+VCCPLL on BOTTOM (solid shape): 188.22,122.77 188.22,121.91 188.14,121.83 186.72,121.83 186.28,121.4 183.35,121.4 183.33,121.38 183.17,121.38 183.11,121.32 183.1,121.31 182.88,121.12 182.9,120.82 182.91,120.81 182.91,120.74 182.84,120.66 182.43,120.66 182.38,120.61 182.28,120.61 182.15,120.74 182.15,121.38 182.27,121.49 182.27,121.49 182.5,121.73 182.52,121.74 182.54,121.74 182.74,121.74 182.74,122.12 182.75,122.15 182.79,122.17 182.82,122.17 183.5,122.85 183.52,122.86 183.54,122.86 183.6,122.86 184.34,122.86 184.46,122.98 188.01,122.98
+VCCPLL on IN1 (solid shape): outline of 435 points within 174.53,116.39 179.23,118.68
+VCCPLL_OC on TOP (solid shape): 151.92,110.33 151.92,109.56 151.8,109.44 150.87,109.44 150.85,109.46 150.84,109.47 150.5,109.7 150.11,109.44 149.27,109.44 149.24,109.46 149.24,109.48 148.88,109.77 148.51,109.48 148.51,109.46 148.38,109.46 147.46,109.46 147.02,109.89 147.02,109.94 146.98,109.94 146.97,109.95 146.81,109.95 146.8,109.95 146.72,109.96 146.64,109.95 146.63,109.95 145.57,109.95 144.56,108.93 144.56,107.79 144.43,107.66 144.05,107.66 143.92,107.79 143.92,109.07 143.93,109.1 143.96,109.12 144.18,109.33 144.17,109.63 144.16,109.65 144.16,109.68 144.94,110.45 151.8,110.45
+VCCPLL_OC on IN4 (solid shape): outline of 340 points within 173.77,103.56 176.18,108.29
+VCCSTG on IN1 (solid shape): outline of 414 points within 174.4,113.98 179.1,115.88
+VCCSTPLL on BOTTOM (solid shape): 187.1,128.61 187.1,127.47 186.72,127.09 182.91,127.09 182.15,127.85 182.15,128.54 182.28,128.67 182.61,128.67 183.55,127.73 184.31,127.73 185.33,128.74 186.98,128.74
+VDD_I2S on TOP (solid shape): 335.33,12.77 335.33,12.17 335.42,12.08 335.42,12.07 335.44,12.06 335.48,12.06 335.52,12.05 335.53,12.01 335.53,11.98 336.53,11.98 336.57,11.97 336.58,11.93 336.58,11.83 336.57,11.8 336.53,11.78 335.53,11.78 335.53,11.74 335.52,11.7 335.48,11.69 335.43,11.69 335.43,11.68 334.92,11.68 334.55,11.86 334.18,11.68 332.87,11.68 332.39,12.16 332.39,12.7 332.51,12.82 333.41,12.82 333.66,12.57 334.17,12.57 334.52,12.92 335.19,12.92
+VIN on TOP (solid shape): 179.61,160.01 179.61,157.01 179.28,156.68 174.61,156.68 174,156.07 171.43,156.07 171.2,156.3 171.2,159.76 171.71,160.26 179.36,160.26
+VIN on TOP (solid shape): 237.52,155.46 237.52,154.65 236.63,153.76 236.02,153.76 235.92,153.86 235.92,155.36 236.15,155.59 237.4,155.59
+VIN on TOP (solid shape): 77.51,51.6 77.51,48.88 76.64,48 75.98,47.5 75.48,46.84 75.04,46.41 74.09,46.41 73.7,46.8 73.7,49.95 74.39,50.65 74.39,51.36 74.2,51.55 73.97,51.55 73.87,51.65 73.87,52.19 74.1,52.41 76.69,52.41

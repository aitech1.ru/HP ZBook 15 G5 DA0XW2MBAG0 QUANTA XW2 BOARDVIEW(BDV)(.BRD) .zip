# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V_VCCSPI: length 1.3
  TOP w0.381: R9339.2 261.66,64.52 v1(261.66,64.35)
  BOTTOM w0.254: U9002.AN44 261.6,64.29 v1(261.66,64.35)
+3V_WLAN_EN: length 14.2
  TOP w0.114: v1(330.69,72.23) 330.69,71.77 330.94,71.52 332.47,71.52 332.66,71.71 U12005.4
  BOTTOM w0.114: U4101.4 329.25,73.37 328.97,73.09 R4127.1 329.6,72.86 v1(329.81,72.65) 329.91,72.54 330.37,72.54 v1(330.69,72.23) 331.38,71.54 331.38,69.18 329.72,67.53 328.33,67.53 328.06,67.8 Q4106.6
+3V_WLAN_P: length 93.9
  TOP w0.508: v1(350.35,67.1) 349.89,66.63 349.03,66.63 348.44,66.05 348.44,63.88 v1(347.51,62.95)
  IN1 w0.508: v1(331.07,76.59) 331.07,76.63 331.63,77.18 v1(337.47,77.18)
  IN2 w0.254: v1(350.35,67.1) 347.76,67.1 347.45,66.79 347.45,64.53 346.95,64.02 344.51,64.02 342.42,61.94 342.02,61.94 341.03,62.93 v1(341.03,63.16)
  IN2 w0.508: v1(349.71,75.53) 350.43,74.82 v1(350.43,73.12) 350.43,71.74 349.79,71.11 349.79,69.56 350.35,69 v1(350.35,67.1) ; v1(349.71,75.53) 347.43,77.81 346.23,77.81 345.35,76.93 337.73,76.93 v1(337.47,77.18) ; v1(349.71,75.53) 349.71,79.24 v1(351.64,81.17)
  BOTTOM w0.254: R4118.2 341.28,62.91 v1(341.03,63.16) ; v1(350.43,73.12) 351.41,73.12 351.57,72.96 R4101.2
  BOTTOM w0.279: Q4101.2 353.85,69.12 354.05,68.92 354.59,68.92 354.6,68.92 R4125.1
  BOTTOM w0.381: R4123.2 v1(347.51,62.95)
  BOTTOM w0.508: R4110.1 351.7,75.53 R4122.1 350.94,75.14 350.55,75.53 v1(349.71,75.53) ; R4125.1 355.87,68.92 357.13,67.65 359.19,67.65 359.82,68.29 359.82,82.84 358.77,83.9 355.27,83.9 354.04,82.67 353.14,82.67 v1(351.64,81.17)
  vias: v1(329.09,77.69)
+3V_WWAN_P: length 21.2
  IN1 w0.508: v1(330.77,19.37) 330.77,21.43 v1(333.94,24.61)
  BOTTOM w0.508: R4205.2 328.68,5.94 328.68,15.69 329.22,16.22 ; v1(334.8,18.4) 334.43,18.03 R4223.2 ; R4202.2 334.17,24.38 v1(333.94,24.61) ; 344.23,21.21 344.23,19.87 344.84,19.27 R4226.1
  vias: v1(329.6,19.98) v1(329.55,19.32) v1(330.16,19.55) v1(330.23,20.79) v1(342.81,26.91) v1(342.81,26.28) v1(342.81,25.64) v1(342.81,25.01)
+3VCARD: length 1.3
  TOP w0.508: v1(35.59,63.44) 35.19,63.44 35.02,63.27 CON7301.4
  vias: v1(34.32,62.57)
+3VCARD_1: length 1.5
  BOTTOM w0.203: U7301.12 v1(29.54,65.75)
+3VLANVCC: length 364.5
  TOP w0.457: R4023.2 28.47,125.1 29.25,125.88 R4022.1
  TOP w0.508: C4003.1 22.88,124.03 v1(21.88,123.03) ; v1(26.14,128.18) 26.07,128.11 C4004.1 ; v1(22.51,119.34) 22.64,119.47 R4003.2 ; R9549.1 v1(17.42,111.72) ; R4010.2 R4014.1 31.05,130.9 v1(31.93,130.02) 31.03,129.12 R4013.1 ; R4002.2 29.5,117.87 v1(29.45,117.82) ; v1(32.16,127.6) 31.66,127.6 30.39,126.33 29.5,126.33 R4022.1 ; R4001.2 R4024.2 R4023.2 ; R9550.1 v1(14.51,136.23)
  IN2 w0.254: v1(276.1,65.01) 275.46,64.38 275.46,62.99 274.74,62.27 274.74,62.21 274.69,62.17 274.69,61.87 274.56,61.73 274.56,61.25 272.34,59.04 272.34,57.34 271.35,56.35 271.35,55.48 271.5,55.34 271.5,54.14 270.59,53.23 269.94,53.23 268.22,51.5 268.22,49.64 266.92,48.34 266.92,47.39 264.57,45.03 263.61,45.03 260.38,41.8 260.38,40.02 259.9,39.54 259.9,38.25 259.76,38.1 259.76,38.09 258.24,36.58 255.69,36.58 253.19,34.08 252.31,34.08 250.78,32.55 250.78,31.42 247.47,28.11 238.66,28.11 237.38,26.83 235,26.83 232.88,24.71 223.95,24.71 219.18,19.94 216.76,19.94 215.16,18.34 205.13,18.34 204.55,18.92 196.37,18.92 195.79,18.34 182.45,18.34 180.87,16.76 175.85,16.76 174.99,15.9 171.99,15.9 171.73,16.17 163.73,16.17 162.6,17.3 107.79,17.3 107.02,16.52 104.8,16.52 103.96,17.36 102.45,17.36 101.94,16.85 101.37,16.85 100.23,18 100.23,19.28 98.38,21.13 98.38,38.51 94.2,42.7 93.62,42.7 92.42,43.9 92.42,46.62 89.13,49.92 70.28,49.92 69.54,49.18 66.9,49.18 64.21,46.48 62.83,46.48 61.01,44.67 v1(56.67,44.67)
  IN2 w0.508: v1(22.51,119.34) 22.1,118.94 22.1,116.4 v1(17.42,111.72) ; v1(14.51,136.23) 17.3,133.44 24.92,133.44 25.56,132.81 25.56,128.74
  IN4 w0.254: v1(43.19,69.97) 49.82,63.34 49.82,60.29 49.26,59.73 49.26,50.69 52.48,47.46 53.88,47.46 v1(56.67,44.67)
  BOTTOM w0.203: U4000.19 v1(26.14,128.18) ; U4000.15 24.54,128.49 v1(24.29,128.74)
  BOTTOM w0.254: R9104.2 273.68,70.65 274.35,70.65 275.49,69.51 275.49,69.22 276.76,67.95 276.76,65.22 276.52,64.99 276.17,64.99 276.15,65.01 v1(276.1,65.01)
  BOTTOM w0.508: v1(22.51,119.34) 22.51,119.46 R4004.2
  vias: v1(21.24,123.03) v1(28.81,117.79) v1(28.85,118.45) v1(29.45,117.18) v1(31.86,125.69) v1(31.86,125.06) v1(42.2,70.58) v1(42.5,69.97) v1(42.83,70.58) v1(43.34,67.91)
+3VLCD_CON: length 13.1
  TOP w0.508: 51.47,56.48 49.56,58.38 49.56,59.77 R18006.1 49.01,60.32 48.21,60.32 47.33,61.2 D9003.1
  BOTTOM w0.381: R3039.2 52.75,59.22 51.92,59.22 51.7,58.99 51.7,57.93 v1(53.27,56.35)
  vias: v1(52.48,55.72) v1(53.27,55.72) v1(53.91,56.35) v1(54.54,56.35)
+3VPCU: length 1170.8
  TOP w0.203: v1(272.19,19.14) 272.19,18.38 271.81,18 R6412.1 R6413.1 ; R6078.1 260.83,28.51 v1(260.89,28.53) 261.06,28.41 261.2,28.27 261.45,28.27 262.42,27.3 R6062.1 264.19,27.3 R6050.1 ; v1(277.02,30.29) 277.02,30.24 276.31,30.95 R6068.1 R6165.2 ; v1(261.09,38.8) 261.09,37.91 260.15,36.97 R6045.1 ; 243.08,51.17 242.59,50.68 R17940.1 ; 243.08,51.17 243.19,51.27 R17939.2 ; 243.08,51.17 v1(243.08,51.17) ; v1(256.45,27.27) 256.37,27.19 255.46,27.19 R6079.1
  TOP w0.254: U12005.5 331.36,73.18 v1(331.71,73.52) 332.68,73.52 333.2,73 333.2,70.02 333.71,69.51 333.71,68.67 333.36,68.32 332.54,68.32 332.25,68.02 R4137.2 ; R6031.2 R6028.2 276.59,26.25 v1(277.04,25.8) ; R6167.1 v1(272.19,19.14)
  TOP w0.381: R8682.2 337.04,97.83 v1(336.96,97.75) 336.84,97.75 336.25,97.17 336.25,96.36 336.76,95.85 R8681.2 ; R6358.1 97.72,5.93 97.39,6.26 97.39,6.97 v1(97.72,7.3) ; R6805.1 236.75,58.64 v1(236,58.64) ; R17943.2 245.59,47.21 246.16,46.65 246.16,46.07 247.6,44.62 247.6,43.99 247.39,43.78 R17953.2 ; R17942.2 262.02,14.57 v1(262.54,14.57) 262.92,14.19 263.42,14.19 R6184.2 263.42,14.04 264.2,13.26 C6029.1 ; v1(112.07,9.95) 112.07,11.47 109.76,13.78 109.76,28.74 v1(109.79,28.77) ; C6029.1 264.2,13.05 263.42,12.27 R6183.2 ; C6029.1 U6003.5 ; v1(260.26,48.22) 260.53,48.5 260.53,49.72 260.99,50.18 260.99,50.79 260.69,51.09 260.03,51.09 257.4,53.72 Q6006.2 ; v1(186.93,158.71) 186.93,159.04 187.37,159.48 PR20070.2 ; R6807.1 R17965.2 ; v1(239.63,49.85) 239.43,50.05 R6808.1 ; PQ12006.2 305.09,37.76 305.09,39.82 PQ12007.2 ; PR20068.2 192.56,159.1 192.82,158.84 192.82,158.08 v1(192.31,157.57) 192.31,156.8 PR24001.2 ; R17941.2 242.72,41.48 v1(243.11,41.87) ; v1(180.63,156.17) 180.75,156.05 181.52,156.05 181.64,155.92 PR20066.2 ; R17964.2 239.12,47 239.47,46.65 239.47,45.35 239.16,45.04 R6802.1 238.92,44.54 v1(239.05,44.41) 239.05,43.93 239.48,43.5 239.48,42.92 239.24,42.68 238.3,42.68 237.99,42.37 R17938.2 ; v1(239.68,48.86) 239.5,48.86 239.33,49.04 R6806.1 R17966.2
  TOP w0.508: v1(237.14,57.37) 237.28,57.23 R6804.1 238.23,56.9 R6803.1 ; LED6000.3 v1(364.88,150.23) ; v1(269.78,68.67) 269.78,68.68 R9367.1 ; v1(256.83,5.88) 255.61,7.1 253.12,7.1 250.3,4.28 244.64,4.28 244.26,4.65 PR11034.2 ; v1(344.96,87.47) 343.95,88.48 343.95,92.04 345.35,93.44 345.35,96.31 346.01,96.97 346.01,98.95 v1(345.42,99.53) 346.07,100.18 R8680.2 ; v1(259.57,20.85) 260.41,21.68 L6000.2 ; R17953.2 247.39,42.23 ; 247.39,42.23 247.39,41.93 248.01,41.31 251.32,41.31 251.36,41.27 254.39,41.27 v1(254.97,41.85) 254.97,43.58 255.43,44.03 R6178.1 ; 247.39,42.23 247.35,42.19 R912.1 ; v1(235.61,9.74) PC11024.2 235.61,8.35 235.62,8.34 PR11030.2 234.97,7.85 234.41,8.41 PU11001.4 ; R6040.2 276.29,29.02 277.22,29.02 277.63,28.62 v1(277.76,28.62) ; v1(225.08,8.35) 226.47,8.35 228.25,10.12 228.25,11.9 228.56,12.22 PC12011.2 229.04,12.74 228.33,13.45 PQ12011.1 229.93,14.42 PQ12012.1 ; R6402.2 121.05,114.13 121.57,114.64 124.11,114.64 v1(124.7,115.23) 125.15,114.77 127.16,114.77 128.56,113.37 R6403.1 ; v1(204.5,23.93) 204.5,24.6 202.22,26.89 202.22,29.94 202.85,30.57 v1(202.85,32.35) ; v1(270.74,14.7) 269.98,13.93 R6182.1 R6181.1 ; R6807.1 237.89,51.53 v1(237.9,51.53) ; PQ12006.2 304.25,34.18 303.71,33.64 v1(303.13,33.64) ; v1(354.05,114.14) 354.05,114.77 R8044.1 ; PR16009.2 v1(298.57,11.31) ; v1(119.86,100.22) 119.86,100.42 118.97,101.31 116.36,101.31 v1(114.97,99.91) ; v1(299.32,15.76) 299.19,15.89 PR16008.2 ; v1(130.45,151.86) PC19002.1 130.46,152.63 PR19005.2 PR19006.2 PR19007.2 ; PR14000.2 v1(94.26,66.88) ; v1(268.95,67.02) 268.95,66.48 269.31,66.12 C9248.2 270.41,66.12 272.45,68.16 272.98,68.16 274.35,66.79 274.35,66.09 R9592.2 275.18,65.26 275.46,65.26 v1(275.47,65.27)
  IN1 w0.508: v1(270.74,14.7) 269.27,14.7 268.69,15.28 263.25,15.28 v1(262.54,14.57) ; v1(256.83,5.88) 255.62,5.88 254.4,7.1 252.18,7.1 v1(251.14,8.14) ; v1(340.57,20.31) 340.57,19.88 340.98,19.47 341.97,19.47 344.48,21.99 344.48,26.66 343.64,27.5 342.04,27.5 341.27,26.72 v1(340.09,26.72) ; v3(275.33,70.83) 275.13,71.03 274.38,71.03 v1(272.57,72.84) ; v1(326.42,71.46) 325.51,70.55 325.51,68.72 325.15,68.37 323.35,68.37 322.18,69.53 319.82,69.53 316.24,65.95 312.33,65.95 311.69,65.32 311.69,62.83 311.11,62.24 309.2,62.24 308.96,62 302.86,62 v1(301.66,60.8) ; v1(204.5,23.93) 204.5,23.66 205.98,22.19 207.02,22.19 207.37,21.83 v1(207.37,21.53) ; v1(42.7,61.66) 44.13,63.08 48.93,63.08 51.52,60.49 51.52,54.9 52.2,54.22 52.2,52.29 v1(52.77,51.72) ; v1(225.08,8.35) 225.67,8.94 233.55,8.94 234.35,9.74 v1(235.61,9.74)
  IN2 w0.381: v1(243.08,51.17) 242.6,50.69 242.6,49.65 241.53,48.58 240.85,48.58 240.57,48.86 v1(239.68,48.86) ; v1(97.72,7.3) 97.31,6.9 97.31,4.66 98.36,3.62 102.09,3.62 102.65,4.18 102.65,5.09 102.98,5.42 102.98,6.77 103.89,7.69 109.81,7.69 v1(112.07,9.95)
  IN2 w0.508: v1(274.74,14.71) 274.23,14.19 271.25,14.19 v1(270.74,14.7) 270.16,15.28 270.16,17.24 270.67,17.74 271.69,17.74 272.19,18.25 v1(272.19,19.14) 274.22,21.17 275.03,21.17 v1(276.18,22.32) 277.04,23.18 v1(277.04,25.8) 276.59,25.8 276.13,26.25 276.13,29.4 v1(277.02,30.29) ; 134.93,151.37 134.93,149.34 134.52,148.93 v1(134.52,147.78) 134.76,147.54 135.16,147.54 135.67,147.03 135.67,143.09 133,140.43 128.68,140.43 123.1,134.84 123.1,130.01 123.7,129.4 123.7,127.55 v1(123.91,127.34) 124.37,126.89 124.37,123.41 125.64,122.14 125.64,118.45 124.7,117.52 v1(124.7,115.23) 122.33,112.87 120.68,112.87 119.41,111.6 119.41,106.11 118.02,104.71 118.02,102.06 v1(119.86,100.22) ; 134.93,151.37 v1(134.09,151.37) 133.36,151.37 132.11,152.62 130.97,152.62 130.45,152.1 v1(130.45,151.86) ; 134.93,151.37 135.16,151.6 152.81,151.6 154.21,153 154.21,155.16 155.48,156.43 156.37,156.43 157.39,157.44 161.07,157.44 161.83,156.68 170.59,156.68 171.38,157.47 179.33,157.47 v1(180.63,156.17) ; 351.8,131.13 356.65,135.98 v1(356.65,139.03) 359.95,139.03 362.36,141.44 362.36,149.32 363.27,150.23 v1(364.88,150.23) ; 351.8,131.13 353.3,129.63 354.87,129.63 355.86,128.64 355.86,123.39 354.92,122.45 354.92,115.46 354.05,114.58 v1(354.05,114.14) 354.05,114.13 352.44,112.52 352.44,110.68 351.61,109.84 351.61,106.17 350.68,105.25 350.68,104.15 350.13,103.6 347.63,103.6 346.49,102.45 346.49,100.55 345.47,99.54 v1(345.42,99.53) ; 351.8,131.13 348.94,128.27 339.33,128.27 335.31,124.26 335.31,120.78 337.59,118.51 337.59,104.83 336.31,103.55 336.31,98.41 v1(336.96,97.75) ; v1(52.77,51.72) 52.77,50.73 53.75,49.75 57.06,49.75 58.2,48.6 59.72,48.6 60.05,48.27 v1(60.05,47.59) ; v1(298.57,11.31) 298.25,11.62 298.25,14.7 v1(299.32,15.76) 299.42,15.76 300.89,17.24 300.89,19.52 301.53,20.16 301.53,26.13 303.13,27.73 v1(303.13,33.64) ; v1(114.97,99.91) 114.97,99.65 113.2,97.88 110.92,97.88 110.03,96.99 110.03,94.82 110.4,94.45 v1(110.4,90.48) ; v1(260.26,48.22) 261.04,49.01 261.04,52.06 261.81,52.83 261.81,53.05 268.84,60.08 268.84,66.9 v1(268.95,67.02) ; v1(256.45,27.27) 257.73,27.27 258.44,26.56 258.44,24.17 257.89,23.62 257.89,23.28 258.63,22.55 258.63,21.86 259.57,20.92 v1(259.57,20.85) 259.57,20.63 259.71,20.49 259.71,19.19 260.01,18.88 260.01,16.46 261.91,14.57 v1(262.54,14.57) ; v1(344.96,87.47) 344.08,86.58 341.41,86.58 336.2,81.37 336.2,79.54 331.71,75.05 v1(331.71,73.52) 330.18,73.52 328.76,72.1 v1(327.06,72.1) ; v1(186.93,158.71) 187.31,159.09 190.41,159.09 191.93,157.57 v1(192.31,157.57) ; v1(107.73,90.48) 107.58,90.34 107.58,84.14 103.28,79.85 103.28,77.81 99.55,74.08 97.44,74.08 96.67,73.31 96.67,72.58 96.88,72.37 96.88,71.03 95.28,69.43 ; v1(239.05,44.41) 239.05,48.22 v1(239.68,48.86) 237.9,50.64 v1(237.9,51.53) 237.9,56.61 v1(237.14,57.37)
  IN3 w0.508: v1(346.87,138.52) 350.93,138.52 351.44,139.03 v1(356.65,139.03) ; v1(268.95,67.02) 269.27,67.34 269.27,68.16 v1(269.78,68.67) ; v1(115.48,90.26) 115.09,89.88 111,89.88 v1(110.4,90.48) v1(107.73,90.48) ; v1(251.14,8.14) 254.04,11.05 254.04,11.74 256.39,14.09 262.06,14.09 v1(262.54,14.57) ; v1(239.05,44.41) 241.59,41.87 v1(243.11,41.87) 243.11,35.84 241.09,33.82 237.95,33.82 v1(235.39,31.26) ; v1(340.09,26.72) 339.91,26.72 339.42,26.23 336.36,26.23 335.75,25.62 v1(334.04,25.62) v1(333.41,25.62) 332.8,25.62 v1(332.77,25.65) v1(332.77,24.98) ; v1(186.93,158.71) 186.42,158.21 184.06,158.21 183.67,158.59 181.64,158.59 180.63,157.57 v1(180.63,156.17) 180.63,154.4 v1(180.88,154.14) 180.88,153 180.63,152.74 180.63,151.53 v1(180.07,150.97) 181.01,150.03 181.01,148.3 179.67,146.96 v1(179.67,146.58)
  IN4 w0.508: v1(237.14,57.37) 236,58.51 v1(236,58.64) ; v1(34.46,143.35) 32.93,141.81 32.93,139.16 30.39,136.62 30.39,130.9 29.5,130.01 29.5,128.61 28.23,127.34 28.23,122.52 27.72,122.01 24.29,122.01 21.93,119.65 21.93,116.22 20.35,114.64 20.35,106.77 21.75,105.37 21.75,99.35 21.24,98.85 21.24,89.75 21.88,89.12 21.88,85.94 24.8,83.02 24.8,75.05 25.94,73.91 25.94,73.62 27.08,72.48 27.08,68.16 27.72,67.53 33.94,67.53 34.45,67.02 35.85,67.02 36.33,66.54 36.33,63.87 37.5,62.7 39.28,62.7 40.32,61.66 v1(42.07,61.66) ; v1(256.45,27.27) 257.66,27.27 258.97,28.58 v1(260.89,28.53) ; v1(225.08,8.35) 223.81,9.62 215.3,9.62 212.12,12.79 207.54,12.79 v1(207.05,13.27) ; v1(218.5,77.74) 218.45,77.69 218.45,73.42 219.82,72.05 222.46,72.05 225.48,69.03 225.48,65.72 227.46,63.74 227.46,59.17 226.73,58.43 v4(226.73,57.11) ; v1(353.65,12.54) 353.7,12.54 352.64,13.61 352.64,13.91 350.42,16.13 349.77,16.13 348.8,17.11 348.8,17.69 346.4,20.1 343.72,20.1 340.44,23.38 340.44,24.54 340.68,24.77 340.68,26.31 340.27,26.72 v1(340.09,26.72)
  BOTTOM w0.203: R6037.1 275.72,21.94 275.8,21.94 v1(276.18,22.32) 275.8,22.7 R6036.1 ; PR23026.2 195.51,16.96 195.26,17.21 190.2,17.21 187.53,19.88 187.53,24.73 188.07,25.26 188.07,28.36 187.2,29.22 187.2,31.33 v1(187.38,31.51) ; PR23024.2 110.65,90.74 v1(110.4,90.48)
  BOTTOM w0.254: 276.86,29.68 276.26,29.68 276,29.94 R6018.1 ; JCN9000.22 v1(270.74,14.7) ; R6130.1 266.89,37.15 266.86,37.17 ; v1(268.95,67.02) 268.65,66.72 267.47,66.72 U9002.BE49 267.15,67.04 U9002.BE48 ; JCN9000.30 v1(274.74,14.71) ; R9278.1 200.53,25.59 200.06,25.11 200.06,24.25 201.23,23.08 204.25,23.08 204.5,23.33 v1(204.5,23.93) ; 343.39,98.06 343.43,98.02 U8500.A5
  BOTTOM w0.305: U4200.5 341.28,20.57 341.13,20.42 341.13,19.79 C4203.1 340.81,19.69 340.57,19.93 v1(340.57,20.31) ; v1(243.11,41.87) 242.98,42 RP6800.10 ; CON6000.5 34.73,143.61 v1(34.46,143.35) 34.23,143.58 CON6000.4 ; v1(254.97,41.85) 254.97,41.54 254.9,41.47 CON401.7 ; v1(239.05,44.41) 239.17,44.54 RP6800.5 ; 256.9,42.33 CON401.3
  BOTTOM w0.381: R6029.1 277.4,28.79 277.58,28.62 v1(277.76,28.62) ; PR25023.2 274.99,39.79 275.01,39.76 ; R6204.2 301.66,60.04 v1(301.66,60.8) ; v1(272.57,72.84) 272.52,72.79 271.48,72.79 R9090.2 ; v1(237.9,51.53) 237.64,51.26 C6800.1 237.64,50.65 237.98,50.31 239.17,50.31 v1(239.63,49.85) 239.66,49.87 239.68,49.85 v1(239.68,48.86) ; v1(275.47,65.27) 275.5,65.09 275.5,64.61 275.7,64.4 276.55,64.4 277.19,65.04 277.19,68.25 275.99,69.45 275.99,70.18 v3(275.33,70.83) 275.1,71.06 R9092.2 ; R8511.1 337.86,97.75 v1(336.96,97.75) ; PR25022.2 269.02,39.21 ; PR15007.2 204.5,24.05 v1(204.5,23.93)
  BOTTOM w0.508: PQ10010.1 346.74,138.39 v1(346.87,138.52) ; 355.23,139.03 v1(356.65,139.03) ; v1(272.19,19.14) R6020.2 R6230.1 ; R3080.1 52.36,50.88 52.77,51.29 v1(52.77,51.72) ; PR19029.2 133.94,151.53 v1(134.09,151.37) ; R4200.2 v1(353.65,12.54) ; R4216.1 333.03,22.31 333.03,21.71 333.27,21.47 R4219.1 ; 256.83,43.02 256.83,46.19 257.94,47.31 258.32,47.31 259.24,48.22 v1(260.26,48.22) ; R6822.2 230.54,52.03 229.8,52.77 229.8,53.63 ; v1(277.02,30.29) 276.86,30.13 R6029.1 ; PR17006.1 180.38,150.97 v1(180.07,150.97) ; R3008.2 60.75,48.28 v1(60.05,47.59) ; R17879.1 220,79.39 218.5,77.89 v1(218.5,77.74) ; v1(235.61,9.74) 235.48,9.62 PR11031.2 ; 343.39,98.06 343.39,98.71 343.58,98.9 343.87,99.19 344.08,99.39 344.08,99.83 344.41,100.16 C8580.2 345.06,99.55 345.09,99.55 345.1,99.53 v1(345.42,99.53) ; PR15009.2 PR15010.2 207.8,21.96 v1(207.37,21.53) 207.37,21.25 205.75,19.62 205.75,15.48 207.05,14.18 v1(207.05,13.27) ; R8501.1 R8508.1 344.2,88.23 v1(344.96,87.47) ; PR26000.1 121.4,95.43 121.83,95.85 121.83,96.86 120.56,98.13 120.56,99.52 v1(119.86,100.22) ; v1(134.52,147.78) PR19000.2 ; PR26005.1 115.17,89.96 v1(115.48,90.26) ; PR11025.2 251.12,8.16 v1(251.14,8.14) ; PR15000.1 203,32.2 v1(202.85,32.35) ; v1(275.47,65.27) 275.47,65.14 275.12,65.49 R9094.2 ; PR12013.2 v1(225.08,8.35)
  vias: v1(42.07,61.03) v1(42.7,61.03) v1(187.38,32.78) v1(187.38,32.15) v1(189.41,67.78) v1(189.41,67.15) v1(194.86,79.51) v1(195.51,79.51) v1(261.09,39.44) v1(261.73,39.44) v1(261.73,38.8) v1(265.97,39.08) v1(266.61,39.08) v1(267.24,39.08) v1(267.75,39.97) v1(267.88,39.08) v1(268.64,33.16) v1(273.97,36.54) v1(274.61,36.54) v1(326.42,72.1) v1(327.06,72.73) v1(327.06,71.46) v4(226.09,56.73) v4(226.09,55.97) v4(226.09,55.21) v4(226.73,56.35) v4(226.73,55.59) v4(226.73,54.83) v4(227.36,56.73) v4(227.36,55.97) v4(227.36,55.21)
+3VPCU_S:
  vias: v1(224.82,51.27)
+5V: length 300
  TOP w0.508: v1(178.47,15.84) 180.19,15.84 183.67,19.32 183.67,29.94 v1(183.29,30.32) ; v1(280.7,12.69) C7308.1 C7307.1 ; L3604.2 349.54,29.66 v1(350.04,30.16) ; Q6806.1 192.06,44.92 v1(191.17,45.81) 191.17,46.19 190.79,46.57 190.15,46.57 189.9,46.83 R6827.2 ; PR22004.2 286.3,30.37 v1(285.92,29.99) 285.92,28.28 286.42,27.78 286.42,26.66 284.94,25.19 284.94,22.41 284.66,22.13 284.66,18.1 286.68,16.08 C7300.1 286.68,13.61 v1(286.65,13.58)
  IN1 w0.508: v1(191.17,45.81) 191.42,45.56 191.42,41.8 190.71,41.09 190.71,30.98 190.05,30.32 v1(183.29,30.32) ; v1(297.72,30.06) 297.11,30.67 295.22,30.67 294.7,31.19 292.49,31.19 292.04,31.64 288.68,31.64 287.56,30.52 286.49,30.52 285.96,29.99 v1(285.92,29.99)
  IN2 w0.508: v1(54.97,65.52) 53.8,64.35 50.15,64.35 46.49,68.01 41.66,68.01 40.85,68.82 40.24,68.82 v1(40.19,68.87)
  IN3 w0.508: v1(286.65,13.58) 286.65,12.16 286.39,11.9 281.18,11.9 280.7,12.38 v1(280.7,12.69) ; v1(219.49,53.89) 219.49,51.87 218.47,50.86 211.61,50.86 210.73,49.97 208.69,49.97 207.93,49.21 207.93,46.19 206.79,45.05 202.72,45.05 201.84,45.94 191.29,45.94 v1(191.17,45.81) ; v1(97.7,80.55) 98.14,80.55 98.23,80.46 99.78,80.46 107.09,87.77 107.09,90.77 107.86,91.53 107.86,91.6 108.41,92.16 108.41,92.87 109.94,94.41 109.94,96.13 110.29,96.48 112.45,96.48 118.17,102.2 v1(121.44,102.2)
  IN4 w0.508: v1(97.7,80.55) 97.38,80.55 90.08,73.24 88.81,73.24 86.01,70.45 86.01,69.69 84.61,68.29 78.39,68.29 76.24,66.14 72.56,66.14 70.01,63.59 67.72,63.59 66.91,62.78 66.91,61.3 67.75,60.47 70.09,60.47 70.39,60.16 70.39,59.68 68.74,58.03 68.74,56.9 66.22,54.39 59.88,54.39 56.67,57.6 56.67,61.94 54.97,63.64 v1(54.97,65.52) ; v1(333.56,93.74) 333.56,93.49 332.87,92.8 332.87,89.04 331.91,88.08 331.91,81.02 328.45,77.56 327.31,77.56 323.63,73.88 323.63,72.61 v1(322.1,71.08)
  BOTTOM w0.381: U7300.13 280.81,12.58 v1(280.7,12.69) ; U7300.4 286.66,13.56 v1(286.65,13.58)
  BOTTOM w0.508: PR9032.1 v1(219.49,53.89) ; EC9011.1 190.96,46.02 v1(191.17,45.81) ; v1(333.56,93.74) 334.35,94.53 334.53,94.53 CON6301.3 ; PR25001.2 297.59,30.19 v1(297.72,30.06) ; PQ26003.2 121.83,92.17 122.08,92.42 122.59,92.42 122.84,92.67 122.84,97.37 121.83,98.39 PQ26000.2 121.83,99.53 122.84,100.55 122.84,101.94 122.59,102.2 v1(121.44,102.2) ; v1(253.18,7.8) 252.54,7.8 252.34,8.01 R9503.2
  vias: v1(24.85,98.52) v1(25.18,99.07) v1(25.48,98.52) v1(37.62,67.65) v1(39.45,70.19) v1(39.45,69.56) v1(39.53,68.92) v1(40.09,70.14) v1(40.09,69.51) v1(46.74,49.37) v1(46.74,48.73) v1(46.74,48.1) v1(47.38,49.37) v1(47.38,48.73) v1(47.38,48.1) v1(48.01,49.37) v1(48.01,48.73) v1(48.01,48.1) v1(321.47,71.59) v1(321.72,70.58) v1(326.3,11.42) v1(326.93,11.42) v1(335.62,30.7) v1(336.25,30.7)
+5V_ALW: length 484.2
  TOP w0.178: PU22000.4 PC22013.1 ; PU22001.4 PC22012.1 ; PU22002.4 264.32,39.21
  TOP w0.508: PR23013.1 114.47,87.85 v1(113.44,87.85) 112.05,87.85 111.42,88.47 PR23009.1 ; PR26010.1 215.91,31.66 v1(215.29,32.28) ; v1(39.91,60.8) 40.41,60.3 PC22013.1 ; PC22012.1 284.66,32.1 284.89,32.33 v1(284.89,32.7) ; v1(168.66,12.54) 168.66,13.65 169.32,14.31 169.32,21.3 169.6,21.58 169.6,25.24 v1(166.28,28.56) ; v1(264.95,38.75) 264.95,38.2 PC22024.1 264.69,38.07 264.32,38.44 264.32,39.21
  IN1 w0.508: v1(39.91,60.8) 40.85,60.8 42.15,59.5 42.15,57.14 44.99,54.29 44.99,48.1 47.66,45.43 53.37,45.43 55.1,43.7 v1(71.15,43.7) ; v1(198.15,36.31) 198.38,36.54 202.98,36.54 203.61,37.17 204.76,37.17 206.09,35.84 206.09,34.83 206.79,34.13 208.69,34.13 210.14,32.68 214.89,32.68 v1(215.29,32.28)
  IN2 w0.508: v1(71.15,43.7) 71.71,43.7 76.87,48.86 88.6,48.86 90.84,46.62 90.84,43.91 93.15,41.59 93.78,41.59 97.27,38.11 97.27,19.32 102.14,14.44 105.19,14.44 105.82,15.08 141.76,15.08 144.3,12.54 166.53,12.54 167.16,11.9 168.31,11.9 168.66,12.26 v1(168.66,12.54) 168.66,13.04 169.3,13.68 180.37,13.68 183.38,16.69 196.4,16.69 196.97,17.26 203.9,17.26 206.69,14.47 218.47,14.47 220.83,12.11 237.1,12.11 238.73,10.48 247.3,10.48 248.74,11.91 248.74,13.43 249.1,13.79 249.1,17.11 249.94,17.95 249.94,28.13 253.04,31.23 253.04,31.95 254.66,33.57 258.05,33.57 258.32,33.85 260.89,33.85 262.07,35.03 262.07,35.52 262.59,36.04 262.59,36.17 264.95,38.53 v1(264.95,38.75) ; v1(98.08,72.99) 99.93,72.99 104.3,77.36 104.3,79.77 112.38,87.85 v1(113.44,87.85)
  IN3 w0.508: v1(166.28,28.56) 166.28,28.54 167.21,29.48 186.44,29.48 192.23,35.27 197.64,35.27 198.15,35.78 v1(198.15,36.31) ; v1(284.89,32.7) 284.03,32.7 282.49,34.24 281.1,34.24 280.66,33.81 279.62,33.81 279.52,33.91 271.65,33.91 270.67,34.89 270.67,35.46 267.65,38.48 265.22,38.48 v1(264.95,38.75)
  IN4 w0.508: v1(98.08,72.99) 98.08,71.85 97.06,70.83 94.01,70.83 91.85,68.67 91.85,62.96 92.74,62.07 92.74,60.92 89.57,57.75 89.57,53.41 87.92,51.75 79.03,51.75 78.47,52.31 72.83,52.31 71.15,50.64 v1(71.15,43.7)
  BOTTOM w0.254: 198.91,36.16 199.05,36.3 PU13000.6
  BOTTOM w0.508: v1(198.15,36.31) 198.03,36.19 PC13000.2 198.61,35.65 198.91,35.96 198.91,36.16 ; v1(113.44,87.85) 112.68,87.09 PR23015.1
+5V_AMP:
  vias: v1(197.54,159.6) v1(198.03,157.32) v1(198.23,159.63) v1(198.66,157.14) v1(198.91,159.63) v1(199.55,159.6) v1(225.33,158.59) v1(225.33,157.82) v1(226.6,158.21) v1(227.36,159.27) v1(227.36,158.61) v1(227.36,157.95) v1(227.92,158.94) v1(227.92,158.31) v1(228.51,158.61) v1(228.51,157.95)
+5V_AMP_HP: length 22.1
  TOP w0.254: C3637.2 349.05,23.83 U3601.12 ; 353.35,20.41 352.95,20.81 U3601.20
  TOP w0.381: R3639.1 349.55,27.14 L3604.1 348.44,27.13 v1(348.39,27.18)
  TOP w0.508: C3637.2 347.86,25.02 347.86,26.64 v1(348.39,27.18) ; 353.35,20.41 353.73,20.03 C3631.2 v1(354.58,19.74)
  IN1 w0.508: v1(348.39,27.18) 349.25,27.18 350.93,25.49 352.97,25.49 354.11,24.35 354.11,20.21 v1(354.58,19.74)
+5V_AUDIO: length 16.2
  TOP w0.203: C3618.2 340.83,4.77 U3600.41 ; U3600.26 335.06,9.08
  TOP w0.254: C3618.2 341.31,4.86 v1(341.31,5.18)
  IN3 w0.508: v1(341.31,5.18) 340.82,5.66 340.82,7.57 340.39,8 334.8,8 332.98,9.83 v1(332.01,9.83)
  vias: v1(329.22,8.98)
+5V_HDD:
  vias: v1(44.36,45.18)
+5V_HDMIC: length 3.7
  TOP w0.508: R3200.1 R3203.1 357.53,87.35 v1(356.01,88.86)
  vias: v1(355.25,89.63)
+5V_IR_LED:
  vias: v1(41.82,51.78) v1(41.82,51.14) v1(42.45,51.78) v1(42.45,51.14) v1(42.45,50.51) v1(43.21,50.38)
+5V_IR_LED_L:
  vias: v1(46.01,51.91)
+5V_LED_KBLIGHT:
  vias: v1(194.47,44.92)
+5V_USBP1:
  vias: v1(353.73,80.48) v1(355.51,81.12) v1(355.51,80.48) v1(355.51,79.85) v1(358.17,70.55) v1(358.53,70.02) v1(358.93,70.53)
+5V_USBP2:
  vias: v1(16.31,104.48) v1(17.13,104.51) v1(18.27,104.54) v1(18.27,103.72) v1(19.59,103.72)
+5V_USBP3:
  vias: v1(15.45,93.66) v1(15.45,92.98) v1(16.29,93.66) v1(16.26,92.95) v1(17.69,93.31)
+5V_USBSRC: length 59.3
  TOP w0.381: R18020.2 341.86,95.2 341.64,95.42 v3(341.46,95.42) ; C7147.1 350.29,132.94 350.58,132.65 350.58,132.2 349.79,131.41 R7189.2
  TOP w0.508: v1(354.51,144.92) 354.49,144.9 351.26,144.9 350.91,144.54 R7187.1 ; v1(339.32,105.93) 339.32,105.73 340.16,104.89 340.16,103.64 341.33,102.48 343.54,102.48 v1(344.08,101.94) 344.08,101.32 R18021.2 ; R7154.1 339.5,129.25 339.25,129.5 v1(339.25,130.27)
  IN1 w0.254: v1(346.36,92.98) 346.2,92.82 343.28,92.82 341.94,91.48 v1(341.38,91.48)
  IN1 w0.508: v1(340.01,88.36) 340.39,88.36 341.54,89.5 343.19,89.5 343.95,90.26 343.95,91.92 344.38,92.36 345.6,92.36 346.62,91.34 346.62,91.33 347.4,91.33 347.83,90.9 v4(349.03,90.9)
  IN2 w0.508: v1(350.04,136.59) 350.53,136.59 351.36,137.43 351.36,141.52 354.51,144.67 v1(354.51,144.92)
  BOTTOM w0.089: v1(346.36,92.98) 346.06,92.98 345.7,93.33 345.33,93.33 345.18,93.33 U8500.J2
  BOTTOM w0.254: 340.9,88.9 340.9,90.69 341.38,91.18 v1(341.38,91.48) 341.18,91.68 341.18,92.33 U8500.L9
  BOTTOM w0.508: R7142.1 v1(339.25,130.27) ; C8587.2 C8586.1 339.51,88.36 v1(340.01,88.36) 340.36,88.36 340.9,88.9 ; R3201.2 356.51,85.82 v1(353.47,85.82)
  vias: v1(347.12,133.82) v1(347.12,133.19) v1(347.25,132.42) v1(347.76,133.82) v1(347.76,133.19) v1(348.39,133.82) v1(348.39,133.19) v1(349.03,133.82) v1(349.03,133.19) v1(350.04,137.25) v1(350.04,135.96) v1(350.04,135.32) v1(350.04,134.69) v1(350.73,138.17) v1(351.7,87.97) v4(220.5,38.5) v4(220.89,39.13) v4(220.89,37.86) v4(221.27,38.5) v4(221.65,39.13) v4(221.65,37.86) v4(222.03,38.5) v4(222.41,39.13) v4(222.41,37.86) v4(222.79,38.5) v4(349.03,92.42) v4(349.03,91.66) v4(349.79,92.42) v4(349.79,91.66) v4(349.79,90.9)
+5V_USBSRC_P1:
  vias: v1(346.74,93.82)
+5V_USBSRC_S:
  vias: v1(224.7,35.27) v1(225.97,41.23) v4(222.41,36.41) v4(222.41,35.65)
+5VPCU: length 405.3
  TOP w0.178: PU9501.4 195.61,83.12
  TOP w0.203: v1(118.11,99.28) 117.76,99.63 PR23023.2
  TOP w0.508: PR9521.1 188.63,73.88 187.99,74.51 v1(187.48,74.51) ; R7019.1 27.22,97.88 26.96,98.14 R7008.1 26.78,98.76 v1(26.27,99.27) ; v1(216.06,53.65) 215.81,53.91 215.29,53.91 PD9002.2 ; PC9507.2 195.61,82 v1(195.1,82.51) 195.61,83.02 195.61,83.12 ; v1(308.67,58.87) 308.67,58.04 309.71,57 309.71,48.58 308.7,47.57 308.7,45.63 309.4,44.92 309.4,43.99 308.53,43.12 303.94,43.12 302.9,42.08 300.97,42.08 300.59,41.7 299.02,41.7 298.56,41.24 v1(297.97,41.24) ; v1(26.83,87.47) 26.7,87.34 v1(26.7,85.43) ; PR26011.1 236.77,145.75 v1(236.51,146.01)
  IN1 w0.508: v1(236.51,146.01) 236.51,146.8 234.88,148.43 233.18,148.43 v1(231.88,149.72) 231.78,149.72 230.89,150.61 v4(230.89,151.47) ; v1(163.5,155.01) 162.33,156.17 156.52,156.17 v1(155.35,155.01) 153.42,156.94 149.15,156.94 v1(147.5,155.28) 146.08,155.28 145.19,156.17 141.26,156.17 140.24,155.16 140.24,154.01 v1(139.99,153.76) ; v4(197.64,47.97) 196.52,47.97 195.71,48.78 195.71,50.21 191.42,54.5 v1(191.42,55.97)
  IN2 w0.508: v1(105.95,87.85) 105.95,91.02 108.5,93.57 108.5,98.11 109.29,98.9 111.5,98.9 113.53,100.93 116.46,100.93 v1(118.11,99.28) ; v1(282.68,69.43) 282.94,69.43 284.59,67.78 287.05,67.78 292.06,62.78 293.35,62.78 293.96,62.17 297.03,62.17 297.72,61.48 302.06,61.48 v1(303.44,60.11) ; v1(195.1,82.51) 195.07,82.54 195.07,82.86 194.73,83.21 194.23,83.21 193.88,82.86 193.88,82.1 193.49,81.71 192.55,81.71 187.48,76.65 v1(187.48,74.51)
  IN3 w0.508: v1(191.42,55.97) 190.68,56.46 190.68,58.88 188.12,61.44 188.12,74.13 187.74,74.51 v1(187.48,74.51)
  IN4 w0.508: v1(26.27,99.27) 26.2,99.27 25.05,100.42 25.05,100.93 24.04,101.94 24.04,105.96 21.88,108.12 21.88,115.34 23.39,116.85 23.39,118.72 23.27,118.84 23.27,120.17 24.53,121.43 27.96,121.43 28.99,122.45 28.99,125.44 32.67,129.12 32.67,134.58 v1(32.29,134.96) ; v1(282.68,69.43) 280.77,69.43 278.08,72.13 276.19,72.13 275.95,72.37 275.16,72.37 273.02,74.51 271.56,74.51 270.89,75.18 270.89,75.3 265.5,80.7 265.5,81.51 259.37,87.64 259.37,88.71 253.19,94.88 253.19,118.98 252.2,119.98 252.2,129.05 250.02,131.23 250.02,137.2 246.86,140.36 240.63,140.36 238.41,142.58 238.41,143.48 237,144.9 237,145.52 v1(236.51,146.01) ; v4(199.93,47.97) 199.93,53.05 200.82,53.94 203.11,53.94 204.12,54.95 208.31,54.95 209.93,56.57 v1(210.09,56.57) 211.14,56.57 212.5,55.21 v1(215.04,55.21) 216.06,54.19 v1(216.06,53.65)
  BOTTOM w0.203: PR23027.2 190.32,16.65 187.22,19.75 187.22,25.94 v1(187.56,26.28) ; v1(105.95,87.85) 110.01,87.85 111.16,88.99 111.16,90.9 111.41,91.15 PR23025.2
  BOTTOM w0.381: PU25000.8 v1(297.97,41.24) 298.61,41.24 298.98,40.87 PC25003.2
  BOTTOM w0.457: v1(231.88,149.72) 232.01,149.72 232.04,149.7 232.06,149.7 232.58,149.18 PR8010.1
  BOTTOM w0.508: v1(19.21,97.12) 19.2,97.11 EC9023.1 ; v1(215.04,55.21) 215.04,55.97 216.03,56.95 PR9035.1 ; EC9024.1 39.45,61.66 v1(39.17,61.38) ; v1(105.95,87.85) 104.93,88.86 104.01,88.86 103.25,88.1 103.25,87.8 102.69,87.24 102.69,86.78 101.42,85.51 101.42,79.9 103.66,77.66 v1(103.66,71.46) ; v1(308.67,58.87) 308.67,59.6 307.5,60.77 304.1,60.77 v1(303.44,60.11) ; v1(32.29,134.96) 32.54,135.22 R6096.1
  vias: v1(19.21,96.48) v1(19.84,97.12) v1(19.84,96.48) v1(20.48,97.12) v1(20.48,96.48) v1(37.34,61.71) v1(37.98,61.69) v1(37.98,61.05) v1(38.61,61.69) v1(38.61,61.05) v1(105.57,25.11) v1(106.33,27.4) v1(106.33,26.76) v1(106.33,26.13) v4(198.03,47.33) v4(198.41,47.97) v4(198.41,46.7) v4(198.79,47.33) v4(199.17,47.97) v4(199.17,46.7) v4(199.55,47.33) v4(199.93,46.7) v4(200.31,47.33) v4(200.69,46.7) v4(229.47,151.78) v4(230.16,152.72) v4(230.16,151.47) v4(230.69,152.21) v4(231.43,152.21)
+V3.3DX_ADO: length 4.5
  TOP w0.114: R9258.2 254.79,80.24 C9228.1 255.12,79.65 255.12,78.49 254.59,77.96 v1(254.31,77.96)
  BOTTOM w0.114: v1(254.31,77.96) 254.17,78.1 253.79,78.1 U9002.BB14
+VCC0V9_LC: length 1.3
  TOP w0.254: v3(346.78,115.23) 346.78,115.22 C8087.2
  BOTTOM w0.254: v3(346.78,115.23) 347.1,115.55 U8001.J8
+VCC0V9_LVR_OUT: length 15.5
  TOP w0.381: R7322.2 359.58,119.25 v1(359.49,119.17)
  IN3 w0.508: v3(347.43,115.88) 348.23,115.88 350.15,117.79 356.11,117.79 357.49,119.17 v1(359.49,119.17)
  BOTTOM w0.254: U8001.H6 347.75,116.2 v3(347.43,115.88) U8001.H8 347.1,116.2 v3(346.78,115.88)
+VCC0V9_PCIE: length 1
  TOP w0.114: C8073.2 v1(339,110.21)
  vias: v3(341.59,114.57) v3(342.24,114.57) v3(342.89,114.57)
+VCC0V9_SVR: length 0.5
  BOTTOM w0.254: U8001.E8 v3(346.79,117.82)
  vias: v1(352.97,118.58) v3(342.94,115.85) v3(343.53,112.63) v3(343.54,116.52) v3(343.54,115.88) v3(343.54,111.98) v3(344.19,116.52) v3(344.83,115.23) v3(344.83,114.58) v3(344.83,113.93) v3(344.83,113.28) v3(344.83,112.63) v3(344.84,116.52) v3(344.84,111.98) v3(346.13,113.28) v3(346.13,112.63) v3(346.14,111.98) v3(347.43,113.28) v3(347.43,112.63) v4(353.73,124.2) v4(354.46,124.2) v4(355.2,124.2)
+VCC3P3_LC: length 11.5
  TOP w0.381: v3(348.08,111.28) 347.88,111.28 347.56,110.96 C8091.2 347.35,110.8 347.35,109.87 346.79,109.31 345.35,109.31 344.84,108.8 v1(344.84,107.91) 345.17,107.58 345.17,106.59 344.7,106.13 R8017.2 R8016.2 R8015.2 R8014.2
  BOTTOM w0.254: U8001.V6 347.76,111.6 v3(348.08,111.28)
+VCC3P3_SX: length 131.3
  TOP w0.254: 354.87,107.91 354.24,107.28 352.29,107.28 352.07,107.05 U12002.5 ; v3(348.08,112.58) 347.96,112.69 C8079.2
  TOP w0.305: C8078.2 340.38,118.82 340.8,118.4 340.8,118.23 341.15,117.88 341.25,117.88 341.49,117.64 341.78,117.64 342.24,117.19 v3(342.24,117.17)
  TOP w0.508: 341.28,105.49 342.94,105.49 343.31,105.12 R8041.1 ; 341.28,105.49 341.19,105.49 340.16,106.52 340.16,106.9 339.7,107.36 v1(339.3,107.36) ; 341.28,105.49 341.28,104.1 341.79,103.6 348.55,103.6 348.55,103.6 349.26,103.6 349.27,103.6 349.55,103.6 349.55,103.6 350.26,103.6 350.48,103.38 350.48,102.95 350.77,102.66 351.8,102.66 353.35,104.21 353.35,104.6 354.37,105.62 R8025.1
  IN1 w0.508: v1(339.3,107.36) 339.02,107.36 338.33,106.67 338.33,102.43 336.99,101.09 336.99,99.68 336.33,99.02 336.33,90.74 335.63,90.05 335.63,87.4 330.23,82.01 327.57,82.01 324.26,78.7 324.26,77.31 316.01,69.05 v1(314.1,69.05)
  IN2 w0.508: 342.24,118.39 340.97,118.39 340.27,117.69 340.27,110.07 339.3,109.1 v1(339.3,107.36) ; 342.24,118.39 343.06,119.22 349.54,119.22 350.02,118.73 350.02,113.48 349.79,113.25 348.39,113.25 348.08,112.93 v3(348.08,112.58) ; 342.24,118.39 v3(342.24,117.17)
  BOTTOM w0.254: v3(348.08,112.58) 348.08,112.63 U8001.R6 ; R8036.1 R8037.1 R8034.1 314.87,66 315.12,66.26 315.12,67.87 314.88,68.17 C8052.1 ; U8001.F18 v3(342.24,117.17)
  BOTTOM w0.508: R8010.1 357.16,105.5 v1(357.66,105.5) ; U8000.8 305.87,67.42 306.99,68.54 313.1,68.54 R8039.1 C8052.1 314.66,68.22 314.66,68.82 314.43,69.05 v1(314.1,69.05)
+VCC_CORE: length 42.5
  TOP w0.203: v1(172.61,108.52) 172.53,108.6 C9290.2
  IN2 w0.254: v1(155.23,109.41) 154.31,109.41 153.58,108.68 148.5,108.68 147.1,110.07 145.19,110.07 144.08,108.96 138.26,108.96 136.58,107.28 126.14,107.28 123.01,104.14 122.93,104.14 122.49,103.7 118.95,103.7 v1(118.79,103.87)
  BOTTOM w0.254: U9001.L13 v1(172.61,108.52) ; PR26002.1 v1(118.79,103.87)
  vias: v1(147.61,134.2) v1(155.14,126.69) v1(155.14,126.04) v1(155.14,125.39) v1(155.14,124.74) v1(155.14,123.44) v1(155.14,122.79) v1(155.24,108.52) v1(156.12,109.41) v1(156.71,126.04) v1(156.71,125.39) v1(156.71,123.44) v1(156.71,122.79) v1(158.02,109.41) v1(158.29,126.04) v1(158.29,125.39) v1(158.29,124.74) v1(158.29,124.09) v1(158.29,123.44) v1(158.66,113.37) v1(158.66,112.74) v1(158.66,111.6) v1(158.91,109.41) v1(159.29,116.68) v1(159.29,116.04) v1(159.29,115.03) v1(159.29,114.39) v1(159.86,123.44) v1(159.93,109.41) v1(160.56,119.34) v1(160.81,109.41) v1(161.44,127.34) v1(161.44,126.69) v1(161.44,126.04) v1(161.44,125.39) v1(161.44,123.44) v1(161.44,122.79) v1(161.44,122.14) v1(161.7,109.41) v1(162.59,109.41) v1(163.01,126.04) v1(163.01,125.39) v1(163.01,124.74) v1(163.01,124.09) v1(163.01,123.44) v1(163.48,109.41) v1(163.8,127.34) v1(163.8,126.69) v1(163.8,126.04) v1(163.8,125.39) v1(163.8,123.44) v1(164.37,109.58) v1(165.31,118.94) v1(165.28,109.48) v1(165.37,126.04) v1(165.37,125.39) v1(165.37,124.74) v1(165.37,124.09) v1(165.37,123.44) v1(165.37,122.79) v1(165.36,117.31) v1(165.77,115.58) v1(165.77,114.87) v1(165.74,114.14) v1(165.74,113.4) v1(166.16,127.34) v1(166.16,126.69) v1(166.16,126.04) v1(166.16,125.39) v1(166.16,123.44) v1(167.19,109.46) v1(167.73,126.04) v1(167.73,125.39) v1(167.73,124.74) v1(167.73,124.09) v1(167.73,123.44) v1(167.73,122.79) v1(168.08,109.46) v1(168.52,127.34) v1(168.52,126.69) v1(168.52,126.04) v1(168.52,125.39) v1(168.52,123.44) v1(168.52,122.79) v1(168.97,109.46) v1(169.86,109.46) v1(170.1,126.04) v1(170.1,125.39) v1(170.1,124.74) v1(170.1,124.09) v1(170.1,123.44) v1(170.1,122.79) v1(170.88,127.34) v1(170.88,126.69) v1(170.88,126.04) v1(170.88,125.39) v1(170.88,123.44) v1(170.88,122.79) v4(137.32,139.54) v4(138.08,139.54) v4(138.08,138.77) v4(138.84,138.77) v4(139.61,135.35) v4(139.99,135.98) v4(139.99,134.71) v4(140.37,135.35) v4(140.37,134.08) v4(140.75,135.98) v4(140.75,134.71) v4(141.13,135.35) v4(141.13,134.08) v4(141.51,135.98) v4(141.51,134.71) v4(141.89,135.35) v4(141.89,134.08) v4(142.27,135.98) v4(142.27,134.71) v4(143.8,139.41) v4(144.56,138.77) v4(144.56,138.01) v4(144.56,137.25) v4(144.56,136.49) v4(144.56,135.73) v4(145.19,138.39) v4(145.19,137.63) v4(145.19,136.87) v4(145.19,136.11) v4(145.83,138.77) v4(145.83,138.01) v4(145.83,137.25) v4(145.83,136.49) v4(145.83,135.73) v4(146.46,139.16) v4(146.46,138.39) v4(146.46,137.63) v4(146.46,136.87) v4(146.46,136.11) v4(147.73,136.08) v4(148.11,134.96) v4(148.5,134.33) v4(148.88,136.08) v4(148.88,134.96) v4(149.26,134.33) v4(149.64,134.96) v4(150.15,135.98) v4(150.91,135.98) v4(151.04,139.38) v4(151.8,138.36) v4(151.8,137.6) v4(151.8,136.84) v4(151.8,135.98) v4(152.31,139.38) v4(152.81,137.98) v4(152.81,136.84) v4(152.81,135.82) v4(153.83,138.36) v4(153.83,137.6) v4(153.83,136.84) v4(153.83,135.82) v4(154.34,139.41) v4(154.85,138.77) v4(154.85,137.98) v4(154.85,136.84) v4(154.85,135.82) v4(155.73,138.36) v4(155.73,137.6) v4(155.73,136.84) v4(155.73,135.82) v4(156.37,139.03) v4(156.5,135.82) v4(157.26,135.82) v4(158.02,135.82) v4(158.27,134.96) v4(158.27,134.2) v4(158.27,133.44) v4(158.78,135.82) v4(158.91,134.58) v4(158.91,133.82) v4(158.91,133.06) v4(159.54,135.85) v4(159.54,134.96) v4(159.54,134.2) v4(159.54,133.44) v4(159.54,132.68) v4(160.18,139.38) v4(160.56,138.23) v4(160.56,137.47) v4(160.56,136.71) v4(160.56,135.82) v4(161.7,138.23) v4(161.83,137) v4(161.83,136.23) v4(162.72,138.62) v4(162.72,137.85) v4(162.72,137.09) v4(162.72,136.33) v4(163.74,139.03) v4(163.74,138.23) v4(163.74,136.86) v4(163.74,136.11) v4(163.99,131.03) v4(164.37,131.66) v4(164.37,130.39) v4(164.62,138.23) v4(164.62,137.47) v4(164.62,136.71) v4(164.75,131.03) v4(164.88,135.73) v4(165.13,131.66) v4(165.13,130.39) v4(165.51,138.9) v4(165.51,131.03) v4(165.64,135.78) v4(165.89,131.66) v4(165.89,130.39) v4(166.28,138.9) v4(166.28,131.03) v4(166.4,135.78) v4(166.66,131.66) v4(166.66,130.39) v4(167.04,131.03) v4(167.16,135.78) v4(167.42,130.39) v4(167.8,131.03) v4(167.93,135.78) v4(168.18,130.39) v4(168.56,131.03) v4(168.69,135.73) v4(168.94,130.39)
+VCC_GT: length 0.9
  BOTTOM w0.203: PR19040.2 150.15,129.38
  vias: v1(130.72,128.61) v1(139.09,110.38) v1(139.74,110.38) v1(140.39,110.38) v1(141.04,110.38) v1(141.69,111.96) v1(141.69,110.38) v1(143.33,127.39) v1(143.33,126.04) v1(143.92,119.57) v1(143.92,118.8) v1(143.89,117.07) v1(143.89,116.28) v1(143.89,114.71) v1(143.89,113.92) v1(143.92,113.14) v1(143.92,111.06) v1(144.11,125.39) v1(144.11,124.09) v1(144.56,119.57) v1(144.56,118.8) v1(144.56,117.03) v1(144.56,116.26) v1(144.56,114.74) v1(144.56,113.85) v1(144.56,113.09) v1(144.56,111.06) v1(144.9,127.34) v1(144.9,126.04) v1(144.9,123.44) v1(145.69,126.69) v1(145.69,125.39) v1(145.69,124.09) v1(145.69,122.79) v1(145.96,119.47) v1(145.96,118.84) v1(145.96,117.82) v1(145.96,117.18) v1(145.96,116.17) v1(145.96,115.53) v1(145.96,114.01) v1(145.96,113.37) v1(145.96,112.23) v1(146.13,109.31) v1(146.47,126.04) v1(146.47,124.74) v1(146.47,123.44) v1(147.26,126.69) v1(147.26,125.39) v1(147.26,122.79) v1(148.05,127.34) v1(148.05,126.04) v1(148.05,124.74) v1(148.05,123.44) v1(148.84,125.39) v1(148.84,124.09) v1(148.88,109.41) v1(149.62,127.34) v1(149.62,126.04) v1(149.62,123.44) v1(150.41,125.39) v1(150.41,124.09) v1(150.41,122.79) v1(150.41,122.14) v1(151.2,126.04) v1(151.2,124.74) v1(151.2,123.44) v1(151.99,126.69) v1(151.99,125.39) v1(152.31,117.44) v1(152.31,116.8) v1(152.31,110.17) v1(152.31,109.54) v1(152.77,127.34) v1(152.77,126.04) v1(152.77,124.74) v1(152.77,123.44) v1(152.94,117.44) v1(152.94,116.8) v1(152.94,116.17) v1(152.94,115.53) v1(152.94,114.9) v1(152.94,110.17) v1(152.94,109.54) v1(153.56,126.69) v1(153.56,125.39) v1(153.56,124.09) v1(153.58,110.17) v1(153.58,109.53) v4(130.72,121.38) v4(130.72,120.61) v4(130.72,119.85) v4(130.84,126.2) v4(130.84,125.44) v4(131.48,121.38) v4(131.48,120.61) v4(131.48,119.85) v4(131.6,125.44) v4(131.71,128.49) v4(131.71,127.73) v4(131.73,126.96) v4(131.73,126.2) v4(132.24,120.61) v4(132.37,128.86) v4(132.37,128.1) v4(132.37,127.34) v4(132.37,126.58) v4(132.37,125.44) v4(133,126.96) v4(133.13,128.49) v4(133.13,125.44) v4(133.76,126.96) v4(133.89,125.44) v4(134.53,126.96) v4(135.29,126.96) v4(135.92,128.87) v4(135.92,128.11) v4(135.92,127.34) v4(135.92,126.58) v4(136.56,128.49) v4(136.56,127.73) v4(136.56,126.96) v4(136.56,126.2) v4(137.19,128.11) v4(137.19,127.34) v4(137.19,126.58) v4(137.19,125.82)
+VCC_IO: length 381.3
  TOP w0.508: 186.87,131.71 188.71,133.55 EC9030.1 191.24,133.86 v1(191.24,134.18)
  IN1 w0.508: v1(160.73,107.9) 161.66,108.82 170.21,108.82 172.92,111.54 v1(173.61,111.54)
  IN2 w0.508: v1(283.24,67.86) 283.67,67.86 284.34,67.19 286.81,67.19 291.81,62.18 292.6,62.18 293.85,60.93 296.74,60.93 298.02,59.65 303.05,59.65 303.3,59.4 306.36,59.4 306.83,59.86 306.83,59.87 308.72,61.76 313.16,61.76 313.98,62.57 v1(313.98,63.34)
  IN3 w0.483: v1(283.24,67.86) 283.02,67.86 278.4,72.48 277.75,72.48 276.22,74.01 275.28,74.01 273.6,75.69 272.15,75.69 270.8,77.05 270.23,77.05 266.03,81.25 266.03,81.54 263.3,84.27 263.3,84.8 261.4,86.69
  IN3 w0.508: 259.39,89.78 257.86,91.31 256.44,91.31 255.21,92.53 251.68,92.53 251.59,92.62 251.11,93.1 251.11,94.83 252.67,96.4 252.67,106.13 253.22,106.68 253.22,119.65 252.71,120.15 252.71,122.44 252.16,122.99 252.16,125.29 251.72,125.74 251.72,128.64 247.81,132.55 242.98,132.55 241.46,134.08 241.46,137.12 239.71,138.88 238.46,138.88 230.45,146.89 230.45,148.64 225.97,153.13 218.01,153.13 217.12,152.24 214.54,152.24 214.03,152.74 212.25,152.74 210.76,151.26 204.64,151.26 204.1,150.71 197.26,150.71 197.16,150.61 195.51,150.61 193.35,148.45 193.35,135.85 191.68,134.18 v1(191.24,134.18) ; 174.4,108.01 174.4,110.75 v1(173.61,111.54) ; 174.66,103.82 174.28,103.44 174.28,101.15 175.88,99.54 175.88,96.53 173.55,94.2 v1(171.28,94.2) 170.85,94.2 169.58,92.93 169.58,90.77 161.2,82.39 102.63,82.39 100.1,79.86 97.98,79.86 97.96,79.89 v1(97.72,79.89)
  IN4 w0.508: v1(313.98,63.34) 313.98,64.61 317.66,68.29 317.66,70.32 325.15,77.81 325.79,77.81 v1(328.07,80.1) ; v1(97.72,79.89) 90.19,72.35 89.19,72.35 87.41,70.58 87.41,69.56 80.68,62.83 79.53,62.83 78.77,62.07 78.77,60.67 79.15,60.29 79.15,59.4 v1(80.8,57.75)
  BOTTOM w0.203: v1(160.73,107.9) 160.6,107.87 U9001.AG12
  BOTTOM w0.381: v1(80.8,57.75) 80.8,59.27 80.93,59.4 R407.1
  BOTTOM w0.508: v1(328.07,80.1) R6302.1 ; R9037.1 172.24,94.04 172.08,94.2 v1(171.28,94.2) 171.27,94.21 EC9013.1
  vias: v1(173.6,119.01) v1(173.6,118.37) v1(173.62,114.46) v1(173.62,113.62) v1(173.62,112.94) v1(173.62,112.18) v1(173.64,117.66) v1(173.64,116.9) v1(174.4,117.95) v1(175.17,115.33) v1(175.17,114.55) v1(175.17,113.76) v1(175.17,112.18) v4(185.38,131.23) v4(185.83,130.55) v4(186.14,131.23) v4(186.6,130.55) v4(186.87,131.23)
+VCC_IO_S:
  vias: v1(189.26,133.82)
+VCC_SA: length 77
  IN2 w0.254: v1(114.71,93.53) 115,93.53 127.8,106.33 v1(127.8,106.64)
  IN4 w0.254: v1(127.8,106.64) 129.2,108.04 132.56,108.04 137.06,112.55 142.59,112.55 143.5,111.64 154.67,111.64 155.56,110.75 171.02,110.75 171.48,111.22 171.48,120 v1(172.01,120.53)
  BOTTOM w0.203: U9001.J30 U9001.K29
  BOTTOM w0.254: PR26007.1 v1(114.71,93.53)
  vias: v1(172.46,124.09) v1(172.46,122.79) v1(172.8,127.57) v1(172.88,117.69) v1(172.88,117.06) v1(172.88,114.47) v1(172.88,113.63) v1(172.88,112.99) v1(172.88,112.23) v1(173.25,126.04) v1(173.25,123.44) v1(173.25,122.14) v1(176.56,138.65) v4(173.01,136.62) v4(173.01,135.85) v4(173.77,135.85) v4(174.53,135.85) v4(175.29,135.85) v4(176.05,135.85) v4(176.82,135.85) v4(177.58,135.85) v4(177.58,135.09) v4(177.58,134.33) v4(177.98,139.03) v4(177.98,138.14) v4(178.34,136.62) v4(178.34,135.85) v4(178.34,135.06) v4(178.34,134.3)
+VCCA_BCLK: length 3.2
  TOP w0.114: v1(246.79,69.38) 247.2,69.38 R9265.1
  TOP w0.508: C9231.2 247.05,68.19 v1(247.05,68.57) 247.21,68.57 R9265.1
  BOTTOM w0.254: v1(247.05,68.57) 247.14,68.48 U9002.V19
+VCCA_XTAL: length 1.1
  BOTTOM w0.152: v1(239.86,72.65) 239.86,72.58 U9002.P2 240.46,71.97 U9002.P3
  vias: v1(234.18,68.07) v1(236.38,69.05)
+VCCAMPHYPLL:
  vias: v1(254.9,49.21)
+VCCAPLL:
  vias: v1(231.93,71.08)
+VCCDPHY_1P24: length 12.9
  TOP w0.381: R17904.1 253.57,80.7 253.1,80.23 v1(252.89,80.23) ; v1(251.03,72.46) 251.31,72.18 251.31,71.26 251.63,70.95 R17903.1
  IN2 w0.381: v1(251.03,72.46) 251.03,73.06 250.68,73.42 250.68,74.92 249.93,75.66 249.93,76.13 250.25,76.44 250.5,76.44 250.83,76.77 250.83,77.15 251.37,77.69 251.68,77.69 252.01,78.02 252.01,78.33 252.89,79.2 v1(252.89,80.23)
+VCCDPHY_1P24_P1: length 7.3
  TOP w0.381: R17903.2 252.25,71.73 252.44,71.53 252.44,70.77 v1(252.6,70.61) 252.07,70.08 v1(252.07,70.07) 252.25,69.89 C12026.2 251.8,68.98 v1(251.8,68.49) 251.87,68.42 C12027.2
  BOTTOM w0.254: U9002.AJ23 v1(252.07,70.07) 252.07,70.07 U9002.AJ22 ; U9002.AK22 252.62,70.63 v1(252.6,70.61) U9002.AK23
+VCCDPHY_1P24_P3: length 3.9
  TOP w0.381: v1(252.2,83.91) 252.81,83.31 252.81,82.87 253.04,82.63 253.04,82.24 R17904.2
  BOTTOM w0.203: U9002.BG5 252.51,82.94 252.51,83.61 v1(252.2,83.91)
+VCCDSW_1.05V: length 5.8
  BOTTOM w0.102: 268.64,68.46 268.61,68.46 266.94,68.46 U9002.BG46
  BOTTOM w0.114: C9222.1 271.16,68.38 270.53,67.76 269.55,67.76 268.85,68.46 268.64,68.46 ; U9002.BG45 266.92,68.48 U9002.BG46
+VCCDUSB: length 1.9
  TOP w0.508: R9257.1 248.61,66.62 v1(248.77,66.78)
  BOTTOM w0.254: U9002.W23 v1(248.77,66.78) 248.78,66.79 U9002.W22
+VCCPLL: length 9.8
  IN1 w0.381: v1(173.69,120.07) 174.05,120.07 174.63,119.5 174.63,118.19 ; 178.69,117.91 180.97,117.91 181.9,118.84 181.9,120.45 v1(182.5,121.06)
  BOTTOM w0.254: U9001.H28 U9001.J28 173.76,120.07 v1(173.69,120.07)
  vias: v1(184.21,122.59)
+VCCPLL_OC: length 38.1
  TOP w0.203: v1(175.17,107.46) 174.81,107.82 C9256.2
  TOP w0.254: R9043.1 151.29,109.84 152.28,108.85 v1(152.58,108.85)
  IN4 w0.508: 174.4,108.01 174.4,108.55 173.8,109.15 171.23,109.15 170.72,108.64 157.35,108.64 156.62,107.91 153.7,107.91 153.04,108.57 148.77,108.57 147.15,110.2 145.89,110.2 144.27,108.58 v1(144.27,107.9)
  BOTTOM w0.203: v1(144.27,107.9) 144.15,107.89 U9001.BH13
  BOTTOM w0.254: U9001.G11 175.17,107.39 v1(175.17,107.46) ; U9001.BJ13 143.63,108.2 U9001.BH13
+VCCPRIM_MPHY: length 2.7
  TOP w0.508: R9259.1 252.56,63.48 v1(252.07,63.48) 252.07,62.77 C9223.2
  BOTTOM w0.254: U9002.W31 v1(252.07,63.48)
+VCCST: length 513.9
  TOP w0.508: R9311.1 R9318.2 v1(128.81,117.95) ; v1(188.63,145.66) 188.98,145.3 PQ23004.1 ; R9034.1 R9304.1 132.1,115.16 132.11,115.15 ; v1(184.99,100.4) 185.2,100.19 185.2,97.85 188.21,94.83 189.03,94.83 R9309.2 ; v1(170.47,137.89) 168.55,137.89 R9019.2 R9018.1 ; v1(130.99,115.15) 132.11,115.15 ; 132.11,115.15 133.13,115.15 133.89,115.91 133.89,116.69 v1(134.77,117.57) 134.79,117.56 R9305.1 ; R9303.1 v1(135.55,115.16) R9000.2 ; v1(122.21,152.49) 123.34,153.63 PC19001.1 PR19003.1 PR19001.1 PR19002.1 PR19004.1 ; v1(169.32,12.54) 169.96,13.17 v1(169.96,19.9)
  IN1 w0.508: v1(123.6,142.97) 123.89,143.25 126.37,143.25 130.08,139.54 135.54,139.54 138.59,136.49 138.59,134.51 140.67,132.42 148.09,132.42 148.62,132.96 154.44,132.96 156.62,130.77 162.06,130.77 163.28,129.55 169.32,129.55 169.7,129.94 169.7,137.12 v1(170.47,137.89) 170.97,137.38 178.72,137.38 179.2,136.9 v1(179.2,134.41)
  IN2 w0.508: v1(123.6,142.97) 123.98,143.35 123.98,149.52 122.88,150.62 122.88,152.22 122.6,152.49 v1(122.21,152.49) ; v1(182.79,49.24) 184.06,50.51 184.06,54.83 183.38,55.51 183.38,64.06 179.81,67.63 179.81,87.27 178.13,88.95 178.13,97.54 179.46,98.87 183.71,98.87 184.96,100.12 184.96,100.36 v1(184.99,100.4) 185.25,100.65 185.25,121.7 186.29,122.74 v1(186.29,124.53) 188.45,126.68 v1(188.45,127.22) 187.74,127.93 187.74,131.54 186.7,132.58 181.49,132.58 180.5,133.57 180.04,133.57 v1(179.2,134.41) ; v1(169.32,12.54) 180.07,12.54 183.63,16.09 198.54,16.09 198.68,15.95 201.09,15.95 201.23,16.09 203.09,16.09 204.31,14.87 205.44,14.87 206.44,13.87 207.74,13.87 208.82,12.79 214.61,12.79 215.89,11.51 236.86,11.51 238.53,9.83 243.61,9.83 244.72,8.71 248.01,8.71 250.07,10.78 250.07,14.42 250.57,14.92 250.57,26.04 252.6,28.07 252.6,29.9 254.18,31.49 254.59,31.49 255,31.89 255,32.58 255.39,32.97 258.29,32.97 258.57,33.25 261.14,33.25 262.39,34.51 262.92,34.51 263.29,34.87 263.29,35.17 264.17,36.05 264.97,36.05 265.33,36.4 v1(265.33,36.66) ; v1(128.81,117.95) 128.57,117.71 128.57,117.7 128.19,117.32 128.19,117.32 127.72,116.85 125.67,116.85 125.29,116.47 125.29,109.68 125.81,109.16 125.81,107.84 v1(122.71,104.74)
  IN3 w0.508: v1(111.78,97.09) 111.78,98.35 116.52,103.09 119.54,103.09 120.3,103.85 121.83,103.85 v1(122.71,104.74) 122.71,105.09 122.28,105.53 120.38,105.53 118.8,107.1 118.8,109.97 116.78,111.98 116.78,127.73 122.21,133.16 122.21,140.13 122.79,140.71 123.65,140.71 124.11,141.16 124.11,142.46 v1(123.6,142.97) ; v1(130.99,115.15) 129.7,116.45 129.7,117.06 v1(128.81,117.95) ; v1(179.2,134.41) 179.28,134.48 179.28,136.92 181.77,139.41 186.24,139.41 187.76,140.93 187.76,144.79 v1(188.63,145.66)
  IN4 w0.508: v1(182.79,49.24) 183.04,49.24 183.67,48.6 183.67,40.36 184.18,39.85 184.18,35.65 180.12,31.59 172.24,31.59 171.74,31.08 171.74,29.05 169.58,26.89 169.58,24.88 168.33,23.64 168.33,20.89 169.32,19.9 v1(169.96,19.9)
  BOTTOM w0.381: v1(135.55,115.16) 134.39,115.16 134.17,115.38 134.17,117.34 134.41,117.57 v1(134.77,117.57)
  BOTTOM w0.508: R9317.2 130.1,99 124.37,104.74 v1(122.71,104.74) ; v1(186.29,124.53) 186.66,124.53 R9045.2 ; R6187.1 265.97,35.65 265.33,36.29 v1(265.33,36.66) ; PC23010.1 111.7,97.18 v1(111.78,97.09) PC23009.1 111.78,94.34 PR23016.1 ; v1(188.45,127.22) 188.45,128.01 188.35,128.11 R9046.2 ; R9302.2 v1(134.77,117.57)
+VCCST_ON: length 8
  BOTTOM w0.114: PQ23008.2 113.19,92.64 112.52,93.31 111.28,93.31 110.94,93.66 109.35,93.66 v1(109.25,93.56) 108.83,93.14 PR23011.2 108.36,92.63 108.48,92.51 PU23001.4
+VCCSTG: length 52.9
  TOP w0.254: C9098.2 174.15,119.18 173.77,119.57 173.18,119.57 v1(173.05,119.69)
  TOP w0.508: v1(188.37,138.04) 188.88,138.55 PQ23003.1 189.44,139.22 PC23008.1 187.94,140.71 187.94,140.71 187.83,140.82 PC23007.1 186.33,140.82 PR23010.1
  IN1 w0.381: 178.98,115.12 180.34,115.12 182.56,117.34 v1(182.56,119.32) ; 174.53,115.12 174.53,116.26 174.17,116.62 174.17,119.22 173.85,119.54 173.21,119.54 v1(173.05,119.69)
  IN2 w0.508: v1(182.56,119.32) 183.24,119.32 184,120.08 184,121.71 v1(182.56,123.15)
  IN3 w0.508: v1(182.56,123.15) 180.88,123.15 180.37,123.66 180.37,124.32 181.56,125.51 182.71,125.51 183.07,125.15 v1(184.72,125.15) 185.16,125.6 185.16,129.95 184.59,130.52 184.59,131.41 187.24,134.06 187.24,136.9 v1(188.37,138.04)
  BOTTOM w0.114: v1(184.72,125.15) 184.69,125.18 R9320.1
  BOTTOM w0.254: U9001.G30 175.21,121.75 175.21,121.61 U9001.H29 174.57,120.96 174.07,120.96 173.69,120.58 173.44,120.58 173.05,120.2 v1(173.05,119.69)
+VCCSTG_ON: length 14.7
  TOP w0.114: 111.91,93.31 v1(110.14,93.31) 109.52,93.31 109.08,92.88 PQ23005.2 ; 111.91,93.31 111.91,92.98 111.87,92.95 111.87,92.18 112.17,91.88 112.17,90.86 112.3,90.74 112.94,90.74 113.19,90.99 PQ23007.2 ; 111.91,93.31 PR23008.2 111.91,96.6 112.68,97.37 112.81,97.37 113.17,97.74 PU23000.4

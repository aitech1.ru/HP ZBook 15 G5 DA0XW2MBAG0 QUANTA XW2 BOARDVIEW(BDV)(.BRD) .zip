# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PR20019  *Short_0201  [S0201]  149.26 138.55 270 bottom
PR20020  *0_2/S  [S0201]  150.53 158.96 270 top
PR20021  *0_2/S  [S0201]  153.22 156.68 270 top
PR20022  *0_2/S  [S0201]  151.29 158.96 270 top
PR20023  1.33K_1%_4  [R0402]  149.51 142.93 0 top
PR20024  10K_NTC_4_1%  [R0402]  153.19 140.77 90 bottom
PR20025  1.07K_1%_4  [R0402]  151.29 140.77 180 top
PR20026  392_1%_4  [R0402]  148.11 157.54 90 top
PR20027  590_1%_4  [R0402]  151.29 142.81 0 top
PR20028  12K_1%_4  [R0402]  151.29 141.79 0 top
PR20029  392_1%_4  [R0402]  149.13 157.54 90 top
PR20030  1_5%_6  [R0603]  153.7 150.68 270 bottom
PR20031  *0_2/S  [S0201]  159.93 158.99 270 top
PR20032  *0_2/S  [S0201]  158.4 158.99 270 top
PR20033  *2.2_5%_6  [R0603]  158.53 144.24 0 top
PR20034  *Short_0201  [S0201]  158.15 142.97 90 bottom
PR20035  *Short_0201  [S0201]  158.15 138.54 270 bottom
PR20036  *0_2/S  [S0201]  161.22 156.68 270 top
PR20037  *0_2/S  [S0201]  159.16 158.99 270 top
PR20038  1.33K_1%_4  [R0402]  158.4 142.93 0 top
PR20039  10K_NTC_4_1%  [R0402]  162.08 140.77 90 bottom
PR20040  1.07K_1%_4  [R0402]  160.18 140.77 180 top
PR20041  392_1%_4  [R0402]  155.99 157.54 90 top
PR20042  590_1%_4  [R0402]  160.18 142.81 0 top
PR20043  12K_1%_4  [R0402]  160.18 141.79 0 top
PR20044  392_1%_4  [R0402]  157 157.54 90 top
PR20045  *0_2/S  [S0201]  168.05 158.83 270 top
PR20046  1_5%_6  [R0603]  162.85 150.68 270 bottom
PR20047  *0_2/S  [S0201]  166.53 158.83 270 top
PR20048  *2.2_5%_6  [R0603]  167.8 144.24 0 top
PR20049  *Short_0201  [S0201]  167.29 142.97 90 bottom
PR20050  *Short_0201  [S0201]  167.29 138.55 270 bottom
PR20051  *0_2/S  [S0201]  169.25 156.68 270 top
PR20052  *0_2/S  [S0201]  167.29 158.83 270 top
PR20053  1.33K_1%_4  [R0402]  167.55 142.81 0 top
PR20054  10K_NTC_4_1%  [R0402]  171.23 140.65 90 bottom
PR20055  1.07K_1%_4  [R0402]  169.32 140.65 180 top
PR20056  392_1%_4  [R0402]  164.12 157.54 90 top
PR20057  590_1%_4  [R0402]  169.32 142.68 0 top
PR20058  12K_1%_4  [R0402]  169.32 141.66 0 top
PR20059  392_1%_4  [R0402]  165.13 157.54 90 top
PR20060  *0_5%_2  [R0201]  183.17 158.33 270 top
PR20061  *0_5%_2  [R0201]  182.15 155.03 0 top
PR20062  *0_5%_2  [R0201]  188.63 159.09 0 top
PR20063  *0_5%_2  [R0201]  186.21 159.6 0 top
PR20064  *8.25K_1%_4  [R0402]  183.17 159.35 0 top
PR20065  *100K_NTC_4_1%  [R0402]  138.59 153.13 0 top
PR20066  *8.25K_1%_4  [R0402]  182.4 155.92 0 top
PR20067  *100K_NTC_4_1%  [R0402]  147.76 153.13 180 top
PR20068  *8.25K_1%_4  [R0402]  190.02 158.71 270 top
PR20069  *100K_NTC_4_1%  [R0402]  155.61 153.13 180 top
PR20070  *8.25K_1%_4  [R0402]  187.61 159.09 270 top
PR20071  *100K_NTC_4_1%  [R0402]  163.76 153.13 180 top
PR20072  *8.25K_1%_4  [R0402]  183.29 153.76 90 top
PR21000  *0_2/S  [S0201]  120.3 127.09 270 bottom
PR21001  *0_2/S  [S0201]  121.7 128.11 270 bottom
PR21002  *0_2/S  [S0201]  121.06 127.09 270 bottom
PR21003  *2.2_5%_6  [R0603]  123.98 118.96 90 bottom
PR21004  *0_2/S  [S0201]  122.46 128.11 270 bottom
PR21005  *0_2/S  [S0201]  120.89 115.03 270 bottom
PR21006  *0_2/S  [S0201]  122.46 116.37 270 bottom
PR21007  *0_2/S  [S0201]  121.75 116.37 270 bottom
PR21008  *2.2_5%_6  [R0603]  127.79 107.53 0 bottom
PR21009  *0_2/S  [S0201]  123.22 116.37 270 bottom
PR21010  *0_2/S  [S0201]  179.36 150.81 180 bottom
PR21011  *0_2/S  [S0201]  179.36 149.28 180 bottom
PR21012  *0_2/S  [S0201]  179.36 150.05 180 bottom
PR21013  *2.2_5%_6  [R0603]  173.39 147.12 0 bottom
PR21014  *0_2/S  [S0201]  179.61 148.52 180 bottom
PR22004  *0_4/S  [S0402]  285.91 31.08 180 top
PR22005  *0_4/S  [S0402]  41.94 59.27 180 top
PR22006  *0_4/S  [S0402]  38.77 59.43 0 top
PR22007  *0_4/S  [S0402]  282.86 31.08 0 top
PR22008  *0_4/S  [S0402]  262.67 37.68 90 top
PR22010  *0_4/S  [S0402]  266.86 37.68 90 top
PR22012  *RC0603-R010  [R0603]  288.01 41 90 top
PR22013  *RC0603-R010  [R0603]  276.61 41.62 90 bottom
PR23007  *0_4/S  [S0402]  108.74 98.64 270 top
PR23008  47K/F_4  [R0402]  112.3 96.32 0 top
PR23009  1M_4  [R0402]  111.03 88.61 0 top
PR23010  150_1%_8  [R0805]  185.71 142.33 270 top
PR23011  47K/F_4  [R0402]  108.36 93.53 90 bottom
PR23012  2M_4  [R0402]  111.03 89.63 180 top
PR23013  1M_4  [R0402]  114.84 88.61 270 top
PR23014  150_1%_8  [R0805]  114.71 94.45 0 top
PR23015  *1M_4  [R0402]  112.17 87.09 0 bottom
PR23016  *22_5%_8  [R0805]  112.68 94.32 180 bottom
PR23017  2M_4  [R0402]  114.84 90.39 270 top
PR23018  *2M_4  [R0402]  112.17 88.07 0 bottom
PR23020  *0_4/S  [S0402]  110.27 98.13 0 top
PR23021  *0_4/P  [R0402]  110.27 99.15 0 top
PR23022  *0_5%_2  [R0201]  115.6 99.4 90 top
PR23023  *0_2/S  [S0201]  116.36 99.4 90 top
PR23024  *0_5%_2  [R0201]  110.65 92.17 270 bottom
PR23025  *0_2/S  [S0201]  111.41 92.17 270 bottom
PR23026  *0_5%_2  [R0201]  195.51 16.42 90 bottom
PR23027  *0_2/S  [S0201]  194.75 16.42 90 bottom
PR23028  *0_4/S  [S0402]  197.87 15.64 90 bottom
PR24000  *0_4/P  [R0402]  193.2 157.06 270 top
PR24001  *0_4/P  [R0402]  191.8 156.68 180 top
PR24002  *100K/F_4  [R0402]  191.29 154.27 270 bottom
PR24003  *0_4/P  [R0402]  187.23 154.01 270 bottom
PR24004  *0_4/P  [R0402]  190.51 152.36 270 bottom
PR25000  *4.7K/F_4  [R0402]  301.15 31.21 270 bottom
PR25001  115K/F_4  [R0402]  297.59 31.21 90 bottom
PR25002  76.8K/F_4  [R0402]  298.61 31.21 90 bottom
PR25003  51.1K/F_4  [R0402]  292.01 44.54 180 bottom
PR25004  41.2K/F_4  [R0402]  296.58 31.21 90 bottom
PR25005  28K/F_4  [R0402]  292.01 43.52 180 bottom
PR25007  3.3K/F_4  [R0402]  292.01 41.49 0 bottom
PR25008  3.3K/F_4  [R0402]  295.18 32.6 180 bottom
PR25009  57.6K/F_4  [R0402]  297.21 33.62 0 bottom
PR25010  31.6K/F_4  [R0402]  297.21 34.63 0 bottom
PR25011  3.3K/F_4  [R0402]  292.01 47.46 0 bottom
PR25012  1K/F_4  [R0402]  295.31 28.16 90 bottom
PR25013  3.3K/F_4  [R0402]  294.29 28.16 90 bottom
PR25014  10K/F_4  [R0402]  295.18 35.65 180 bottom
PR25015  10K/F_4  [R0402]  295.18 44.92 90 bottom
PR25016  18.7K/F_4  [R0402]  295.18 33.62 180 bottom
PR25017  22.6K/F_4  [R0402]  293.78 45.56 180 bottom
PR25018  1M_4  [R0402]  299.24 33.62 0 bottom
PR25019  1M_4  [R0402]  296.32 46.75 90 bottom
PR25020  20K/F_4  [R0402]  299.24 34.63 180 bottom
PR25021  20K/F_4  [R0402]  296.37 44.92 90 bottom
PR25022  100K/F_4  [R0402]  269.02 40.6 90 bottom
PR25023  10K/F_4  [R0402]  274.99 41.37 90 bottom
PR25024  10/F_4  [R0402]  268 40.6 90 bottom
PR25025  3.3K/F_4  [R0402]  292.01 45.68 0 bottom
PR25026  3.3K/F_4  [R0402]  292.01 42.51 0 bottom
PR26000  15K_1%_4  [R0402]  121.19 95.82 270 bottom
PR26001  *0_5%_4  [R0402]  120.17 95.82 270 bottom
PR26002  1K_1%_4  [R0402]  118.4 102.71 0 bottom
PR26003  100_1%_4  [R0402]  115.6 99.12 90 bottom
PR26004  15K_1%_4  [R0402]  116.62 99.12 270 bottom
PR26005  *15K_1%_4  [R0402]  115.17 89.02 90 bottom
PR26006  *0_5%_4  [R0402]  114.74 87.54 0 bottom
PR26007  1K_1%_4  [R0402]  116.11 93.53 180 bottom
PR26008  100_1%_4  [R0402]  115.6 91.63 90 bottom
PR26009  15K_1%_4  [R0402]  116.62 91.63 270 bottom
PR26010  5.1_1%_6  [R0603]  216.06 32.25 270 top
PR26011  5.1_1%_6  [R0603]  237.52 145.15 90 top
PR26013  200K_1%_4  [R0402]  343.19 135.09 90 bottom
PR26014  300K_1%_4  [R0402]  342.17 135.09 270 bottom
PR26015  200K_1%_4  [R0402]  331.96 137.99 90 bottom
PR26016  300K_1%_4  [R0402]  332.57 139.41 0 bottom
PR26017  10K_1%_4  [R0402]  343.8 147.49 180 top
PR26018  *Short_0402  [S0402]  228.2 79.75 0 bottom
PU8001  AOZ2263QI-18  [QFN23-4X4-5-SMT]  238.92 148.52 90 bottom
PU9001  RT8813DGQW  [WQFN24-4X4-5-25P-RT8813AGQW]  207.55 53.4 270 bottom
PU9002  RT9610BZQW  [DFN8-2X2-5-9P]  217.71 53.78 180 bottom
PU9501  AOZ1331DI  [SON14-3X2-4-15P-SMT]  195.61 85.02 0 top
PU9502  SY8002ABC  [SOT23-2_85-95-6P-1_4H]  201.68 81.09 90 top
PU9503  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  202.6 84.93 180 bottom
PU9802  *PAC1934T-I/JQ  [QFN16-4X4-65-17P-LM26420]  196.5 52.16 270 bottom
PU11000  BQ24780SRUYR  [QFN28-4X4-4-38P]  246.56 12.59 270 bottom
PU11001  G753T11U  [SOT23-5-2_8-95-5P-G708]  233.46 7.28 270 top
PU13000  NB679AGD-Z  [QFN12-2X3-5]  199.8 38.32 270 bottom
PU13001  NB680AGD-Z  [QFN12-2X3-5]  218.35 43.91 90 bottom
PU13002  AOZ2261QI-18  [QFN23-4X4-5-20P]  212.84 36.14 180 bottom
PU14000  NB685AGQ-Z  [QFN16-3X3-5-1H]  97.95 63.59 180 top
PU15000  NB681AGD-Z  [QFN13-2X3-5]  206.66 28.51 270 bottom
PU16000  NB681AGD-Z  [QFN13-2X3-5]  294.69 15.62 0 top
PU16001  G9661MF11U  [SOP8-6-1_27-9P-G5795F11U]  102.52 27.9 0 top
PU17000  NB681AGD-Z  [QFN13-2X3-5]  184.82 150.59 0 bottom
PU18000  AOZ2263QI-18  [QFN23-4X4-5-SMT]  303.56 66.38 90 top
PU19000  MP2949AGQKT-009A-Z  [QFN48-6X6-4-49P-MP2939]  127.29 148.93 180 bottom
PU20000  MP8693GDT-Z  [QFN12-3X2-5-13P]  142.91 155.25 90 top
PU20001  MP8693GDT-Z  [QFN12-3X2-5-13P]  150.91 155.25 90 top
PU20002  MP8693GDT-Z  [QFN12-3X2-5-13P]  158.78 155.25 90 top
PU20003  MP8693GDT-Z  [QFN12-3X2-5-13P]  166.91 155.25 90 top
PU20004  *G717R41U  [QFN16-3X3-5-17P-G717R41U]  185.71 156.3 0 top
PU21000  MP86903-CGLT-Z  [QFN21-3X4-4-15P]  121.83 123.66 180 bottom
PU21001  MP86903-CGLT-Z  [QFN21-3X4-4-15P]  122.71 111.6 180 bottom
PU21002  MP86901-AGQT-Z  [QFN13-3X3-4]  176.56 148.73 180 bottom
PU22000  AOZ1331DI  [SON14-3X2-4-15P-SMT]  40.42 63.46 0 top
PU22001  AOZ1331DI  [SON14-3X2-4-15P-SMT]  284.39 35.02 0 top
PU22002  AOZ1331DI  [SON14-3X2-4-15P-SMT]  264.32 41.24 0 top
PU23000  74AHCT1G08SE-7  [SOT353-2_1-65-5P-1_1H]  113.06 98.39 180 top
PU23001  74AHCT1G08SE-7  [SOT353-2_1-65-5P-1_1H]  109.13 90.61 270 bottom
PU23002  AOZ1335DI_2  [SON8-3X3-65-7P]  200.92 10.71 90 bottom
PU24000  *SN74AUP1G97DCKR  [SC70-2_1-65-6P-SN74AVC1T45]  188.63 156.17 180 bottom
PU25000  AS393MTR-G1  [SOIC8-6-1_27]  296.07 40.1 180 bottom
PU25001  TC7SZ07FU  [SOT353-2_1-65-5P-1_1H]  272.57 41.24 180 bottom
PU25002  M74VHC1GT32DFT2G  [SOT353-1-2_125-65-5P]  228.38 82.23 0 bottom
Q2000  DMG1012T-7  [D-SOT523_213-1_6-1]  195.23 86.93 0 bottom
Q2006  DMG1012T-7  [D-SOT523_213-1_6-1]  195.87 89.09 270 bottom
Q2008  DMG1012T-7  [D-SOT523_213-1_6-1]  214.79 86.93 0 top
Q2010  DMG1012T-7  [D-SOT523_213-1_6-1]  224.19 88.36 90 bottom
Q2011  DMG1012T-7  [D-SOT523_213-1_6-1]  193.58 92.55 270 bottom
Q2012  DMG1012T-7  [D-SOT523_213-1_6-1]  195.6 93.17 90 bottom
Q2013  DMG1012T-7  [D-SOT523_213-1_6-1]  222.43 90.23 90 bottom
Q2014  DMG1012T-7  [D-SOT523_213-1_6-1]  216.41 90 90 bottom
Q2015  DMG1012T-7  [D-SOT523_213-1_6-1]  218.6 89.97 90 bottom
Q2016  DMG1012T-7  [D-SOT523_213-1_6-1]  232.7 65.24 270 top
Q2017  DMG1012T-7  [D-SOT523_213-1_6-1]  232.57 86.98 0 top
Q2018  DMG1012T-7  [D-SOT523_213-1_6-1]  235.62 74.77 270 top
Q2019  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  217.3 90.08 0 top
Q2020  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  207.47 50.43 0 top
Q2021  DMG1012T-7  [D-SOT523_213-1_6-1]  211.11 50.51 180 top
Q2022  PJE138K  [SOT523_213-1_6-1-0_6H]  228.25 88.36 90 top
Q2023  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  221.77 88.23 180 top
Q2024  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  205.9 90.77 180 bottom
Q2500  DMG1012T-7  [D-SOT523_213-1_6-1]  231.05 142.17 90 top
Q2501  DMG1012T-7  [D-SOT523_213-1_6-1]  236.63 92.04 270 bottom
Q3000  PJX138K  [SOT563-1_6-5-6P-PJX138K]  51.85 46.7 90 top
Q3001  2N7002KW  [UMT_213-3-1_3]  84.36 66 180 top
Q3002  2N7002KW  [UMT_213-3-1_3]  80.93 64.94 90 top
Q3003  2N7002KW  [UMT_213-3-1_3]  77.48 64.89 270 top
Q3004  *2N7002KW  [UMT_213-3-1_3]  55.91 62.83 0 top
Q3005  *2N7002KW  [UMT_213-3-1_3]  57.44 56.71 270 top
Q3006  2N7002KTB  [D-SOT523_213-1_6-1]  52.1 48.73 90 bottom
Q3007  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  12.61 64.86 180 bottom
Q3008  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  16.16 64.86 180 bottom
Q3009  PJX138K  [SOT563-1_6-5-6P-PJX138K]  58.33 49.11 0 bottom
Q3010  2N7002KTB  [D-SOT523_213-1_6-1]  49.05 45.81 270 top
Q3600  *2N7002KTB  [SOT523_213-1_6-1-0_6H]  344.58 3.09 180 top
Q3602  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  193.33 153.76 270 bottom
Q3603  *PJE138K  [SOT523_213-1_6-1-0_6H]  356.14 18.63 0 top
Q3606  PJE138K  [SOT523_213-1_6-1-0_6H]  349.16 4.21 0 top
Q4000  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  31.02 130.01 90 bottom
Q4001  MMBT3904T-7-F/SOT523  [D-SOT523_213-1_6-1]  28.48 130.27 0 top
Q4101  2N7002KDW  [SC70-2_1-65-6P]  353.85 70.83 270 bottom
Q4102  METR3904-G  [SOT23_213-3_3-2]  349.16 78.83 0 bottom
Q4103  METR3904-G  [SOT23_213-3_3-2]  350.04 82.64 90 bottom
Q4104  2N7002KTB  [D-SOT523_213-1_6-1]  339.76 59.32 270 bottom
Q4105  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  342.17 59.78 0 bottom
Q4106  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  328.71 68.92 90 bottom
Q4200  2N7002K  [SOT23_213-3_3-2]  352.51 6.57 270 bottom
Q4201  2N7002K  [SOT23_213-3_3-2]  336.71 24.22 90 bottom
Q5101  2N7002KTB  [D-SOT523_213-1_6-1]  309.66 39.77 270 bottom
Q5102  2N7002KTB  [D-SOT523_213-1_6-1]  326.42 18.63 0 bottom
Q6001  2N7002KTB  [D-SOT523_213-1_6-1]  277.65 24.09 270 top
Q6002  2N7002KDW  [SOT363-2_1-65-6P]  32.29 139.03 90 bottom
Q6003  *2N7002KTB  [D-SOT523_213-1_6-1]  252.25 44.79 270 top
Q6004  *2N7002KTB  [D-SOT523_213-1_6-1]  250.1 45.71 90 top
Q6005  *2N7002KTB  [D-SOT523_213-1_6-1]  249.33 49.27 90 top
Q6006  PJE138K  [SOT523_213-1_6-1-0_6H]  253.91 53.05 90 top
Q6007  2N7002KTB  [D-SOT523_213-1_6-1]  256.57 50.26 0 top
Q6008  2N7002KTB  [D-SOT523_213-1_6-1]  257.46 47.41 270 top
Q6300  2N7002KTB  [D-SOT523_213-1_6-1]  324.77 79.47 0 bottom
Q6301  MMBT3904T-7-F/SOT523  [D-SOT523_213-1_6-1]  323.88 76.8 0 bottom
Q6351  PJX138K  [SOT563-1_6-5-6P-PJX138K]  98.99 3.04 180 top
Q6401  METR3904-G  [SOT23_213-3_3-2]  189.01 44.54 90 top
Q6402  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  190.02 90.64 270 bottom
Q6500  2N7002KDW  [SOT363-2_1-65-6P]  302.93 43.65 0 bottom
Q6501  2N7002KTB  [D-SOT523_213-1_6-1]  294.24 44.19 180 top
Q6800  2N7002KTB  [D-SOT523_213-1_6-1]  188.12 49.87 90 top
Q6801  2N7002KTB  [D-SOT523_213-1_6-1]  240.57 56.73 0 top
Q6802  2N7002KTB  [D-SOT523_213-1_6-1]  239.43 60.67 90 top
Q6803  2N7002KTB  [D-SOT523_213-1_6-1]  241.71 48.07 270 top
Q6804  2N7002KTB  [D-SOT523_213-1_6-1]  240.32 52.67 0 top
Q6805  2N7002KTB  [D-SOT523_213-1_6-1]  241.97 45.51 270 top
Q6806  PJA3413  [SOT23_213-3_3-2]  193.33 45.94 180 top
Q7120  PJE138K  [SOT523_213-1_6-1-0_6H]  340.65 134.08 90 bottom
Q7130  *PJX138K  [SOT563-1_6-5-6P-PJX138K]  359.32 123.53 0 top
Q7146  PJE138K  [SOT523_213-1_6-1-0_6H]  340.14 131.79 180 top
Q7151  *MMBT3904T-7-F-01  [D-SOT523_213-1_6-1]  358.98 121.38 0 top
Q7300  2N7002K  [SOT23_213-3_3-2]  36.35 79.97 0 top
Q7301  2N7002K  [SOT23_213-3_3-2]  28.35 78.7 0 top
Q8000  2N7002KTB  [SOT523_213-1_6-1-0_6H]  351.19 98.39 270 top
Q8012  *MMBT3904W  [UMT_213-3-1_3]  355.61 103.8 180 top
Q9000  METR3904-G  [SOT23_213-3_3-2]  170.72 137.89 180 top
Q9001  *PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  132.62 112.87 270 top
Q9002  PJX138K  [SOT563-1_6-5-6P-PJX138K]  190.79 94.55 0 top
Q9003  2N7002KTB  [D-SOT523_213-1_6-1]  129.45 104.74 0 bottom
Q9004  METR3904-G  [SOT23_213-3_3-2]  132.62 104.07 0 bottom
Q9006  BSS84  [SOT23_213-3_3-2]  255.86 87.06 270 top
Q9007  BSS84  [SOT23_213-3_3-2]  252.15 87.26 270 top
Q9008  2N7002KDW  [SC70-2_1-65-6P]  263.3 83.78 315 top
Q9009  PJX138K  [SOT563-1_6-5-6P-PJX138K]  284.77 53.68 180 top
Q9010  *2N7002K  [SOT23_213-3_3-2]  353.65 15.97 180 bottom
Q9032  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  193.58 20.92 0 top
Q9035  METR3904-G  [SOT23_213-3_3-2]  123.23 88.76 0 bottom
Q9036  *PJX138K  [SOT563-1_6-5-6P-PJX138K]  237.01 45.05 270 top
Q9037  *PJX138K  [SOT563-1_6-5-6P-PJX138K]  244.71 51.65 90 top
Q9038  *PJX138K  [SOT563-1_6-5-6P-PJX138K]  240.44 42.28 270 top
Q9039  *PJX138K  [SOT563-1_6-5-6P-PJX138K]  263.46 15.84 180 top
Q9040  *PJX138K  [SOT563-1_6-5-6P-PJX138K]  246.79 50.26 270 top
Q9042  *PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  193.33 153.76 270 top
Q9043  2N7002KTB  [D-SOT523_213-1_6-1]  348.95 102.15 270 top
Q9046  PJX138K  [SOT563-1_6-5-6P-PJX138K]  54.39 60.16 90 top
Q9047  *PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  349.8 61.12 90 bottom
R106  *0_4/S  [S0402]  261.53 29.68 90 top
R288  0_5%_4  [R0402]  265.97 20.54 270 top
R400  1K_1%_4  [R0402]  87.79 59.53 90 bottom
R401  300_4  [R0402]  71.53 65.62 180 bottom
R402  2.2K_5%_4  [R0402]  82.46 70.83 180 bottom
R403  *0_4  [R0402]  78.26 59.4 180 bottom
R404  1K_1%_4  [R0402]  82 56.81 90 bottom
R405  1K_1%_4  [R0402]  86.52 59.53 270 bottom
R406  1K_1%_4  [R0402]  71.53 66.64 180 bottom
R407  150/F_4  [R0402]  80.93 60.16 270 bottom
R408  1K_1%_4  [R0402]  268.51 55.97 270 top
R409  2.2K_5%_4  [R0402]  269.7 54.78 90 top
R500  *0_6/S  [S0603]  331.91 51.83 270 bottom
R501  *0_4/S  [S0402]  328.2 61.18 90 bottom
R502  *4.7K/F_4  [R0402]  317.28 67.4 90 bottom
R503  *4.7K/F_4  [R0402]  316.26 67.4 90 bottom
R504  4.7K/F_4  [R0402]  317.28 64.61 90 bottom
R505  4.7K/F_4  [R0402]  316.26 64.61 90 bottom
R506  *4.7K/F_4  [R0402]  319.31 67.4 90 bottom
R507  4.7K/F_4  [R0402]  319.31 64.61 90 bottom
R508  *4.7K/F_4  [R0402]  318.29 67.4 90 bottom
R509  4.7K/F_4  [R0402]  318.29 64.61 90 bottom
R510  *4.7K/F_4  [R0402]  336.25 47.97 90 bottom
R511  *4.7K/F_4  [R0402]  334.68 49.09 90 bottom
R512  *4.7K/F_4  [R0402]  335.57 51.78 180 bottom
R513  *4.7K/F_4  [R0402]  313.63 60.16 180 bottom
R514  *4.7K/F_4  [R0402]  317.41 56.76 0 bottom
R515  4.7K/F_4  [R0402]  317.41 55.77 0 bottom
R516  4.7K/F_4  [R0402]  317.41 54.78 180 bottom
R517  *0_4/S  [S0402]  336.91 49.37 180 bottom
R518  4.7K/F_4  [R0402]  314.99 60.52 270 bottom
R519  4.7K/F_4  [R0402]  317.41 57.75 0 bottom
R520  100K/F_4  [R0402]  332.21 58.89 180 bottom
R522  4.99K/F_4  [R0402]  317.41 60.03 0 bottom
R523  100K/F_4  [R0402]  332.21 57.75 180 bottom
R524  4.7K/F_4  [R0402]  321.98 68.87 270 bottom
R525  *4.7K/F_4  [R0402]  322.99 68.87 270 bottom
R526  *0_4/S  [S0402]  346.49 36.79 0 bottom
R527  *4.7K/F_4  [R0402]  347.78 47.08 180 bottom
R528  4.7K/F_4  [R0402]  348.14 45.68 180 bottom
R529  *4.7K/F_4  [R0402]  345.98 47.08 90 bottom
R530  4.7K/F_4  [R0402]  346.36 45.68 0 bottom
R532  *4.7K/F_4  [R0402]  348.39 44.54 0 bottom
R533  4.7K/F_4  [R0402]  346.36 44.54 0 bottom
R534  *4.7K/F_4  [R0402]  350.37 45.4 0 bottom
R535  4.7K/F_4  [R0402]  350.43 44.41 0 bottom
R536  *4.7K/F_4  [R0402]  334.8 39.21 0 bottom
R537  *4.7K/F_4  [R0402]  332.01 36.79 270 bottom
R538  *4.7K/F_4  [R0402]  334.8 36.16 0 bottom
R539  *4.7K/F_4  [R0402]  334.37 47.49 0 bottom
R540  *4.7K/F_4  [R0402]  339.38 47.72 270 bottom
R541  4.7K/F_4  [R0402]  337.29 47.97 90 bottom
R542  100K/F_4  [R0402]  343.57 32.86 90 bottom
R543  4.7K/F_4  [R0402]  338.33 46.98 270 bottom
R544  100K/F_4  [R0402]  342.42 32.86 90 bottom
R545  *0_4/S  [S0402]  332.62 38.29 0 bottom
R546  4.7K/F_4  [R0402]  341.03 49.49 180 bottom
R547  4.7K/F_4  [R0402]  340.39 47.72 270 bottom
R548  4.99K/F_4  [R0402]  342.68 47.72 90 bottom
R549  4.7K/F_4  [R0402]  350.55 39.97 90 bottom
R550  *4.7K/F_4  [R0402]  349.54 39.97 90 bottom
R601  *0_5%_4  [R0402]  24.54 103.85 270 bottom
R602  *0_5%_4  [R0402]  23.53 103.85 90 bottom
R603  *0_5%_4  [R0402]  25.56 85.56 270 bottom
R604  *0_5%_4  [R0402]  24.54 85.56 90 bottom
R613  *0_5%_4  [R0402]  23.78 110.45 90 bottom
R614  *0_5%_4  [R0402]  25.81 92.04 90 bottom
R615  *0_5%_4  [R0402]  24.8 92.04 270 bottom
R618  *0_4/S  [S0402]  22.13 108.17 0 top
R619  *4.7K_4  [R0402]  65.56 47.97 180 top
R620  *4.7K_4  [R0402]  65.56 46.95 0 top
R621  *0_4/S  [S0402]  24.42 89.5 0 top
R622  *4.7K_4  [R0402]  65.56 49.98 180 top
R623  *4.7K_4  [R0402]  66.2 48.99 0 top
R626  *4.7K_4  [R0402]  65.97 51.35 90 top
R627  *4.7K_4  [R0402]  66.58 45.94 0 top
R628  *4.7K_4  [R0402]  64.95 51.35 270 top
R629  *4.7K_4  [R0402]  65.18 45.56 90 top
R630  *4.7K_4  [R0402]  57.28 47.59 0 top
R631  *4.7K_4  [R0402]  55.25 47.59 180 top
R632  *4.7K_4  [R0402]  57.28 48.6 0 top
R633  *4.7K_4  [R0402]  55.25 48.6 180 top
R634  4.7K_4  [R0402]  55.25 49.62 180 top
R635  4.99K_1%_4  [R0402]  57.44 46.45 180 top
R908  100K_4  [R0402]  252.2 32.76 0 top
R909  100K_4  [R0402]  254.03 33.95 0 top
R910  806K/F_4  [R0402]  255.48 33.24 270 top
R911  *0_4  [R0402]  244.51 41.8 90 top
R912  *0_4  [R0402]  245.57 41.8 90 top
R1000  *0_5%_2  [R0201]  143.67 44.41 180 top
R1001  *1K_1%_2  [R0201]  144.74 44.41 180 top
R1002  1K_1%_4  [R0402]  139.48 24.35 270 bottom
R1003  *0_4/S  [S0402]  138.46 26.38 270 bottom
R1004  *0_4  [R0402]  139.48 26.38 270 bottom
R1005  *0_4  [R0402]  168.66 22.29 270 bottom
R1006  *0_4/S  [S0402]  169.68 22.29 270 bottom
R1007  1K_1%_4  [R0402]  138.46 24.35 90 bottom
R1008  *0_4/S  [S0402]  140.49 26.38 90 bottom
R1009  *0_4/S  [S0402]  168.66 24.32 270 bottom
R1010  *0_5%_4  [R0402]  169.68 24.32 270 bottom
R1012  2/F_6  [R0603]  134.14 26.38 270 bottom
R1015  24.9/F_4  [R0402]  130.79 25.87 180 bottom
R1017  240/F_2  [R0201]  147.33 44.41 0 bottom
R1018  *1K_1%_2  [R0201]  148.34 44.41 180 bottom
R1019  *0_5%_2  [R0201]  159.67 44.41 180 bottom
R1020  *0_5%_2  [R0201]  182.73 44.03 180 bottom
R1021  *0_5%_2  [R0201]  178.59 44.41 180 bottom
R1022  *0_2/S  [S0201]  158.66 44.41 180 bottom
R1023  *0_2/S  [S0201]  182.73 44.79 0 bottom
R1024  *0_2/S  [S0201]  177.45 44.41 180 bottom
R1025  240/F_2  [R0201]  146.08 27.27 270 bottom
R1026  *1K/F_4  [R0402]  145.07 27.27 90 bottom
R1027  *0_4  [R0402]  157.51 27.27 270 bottom
R1028  *0_4/S  [S0402]  174.02 26.89 270 bottom
R1029  *0_4  [R0402]  176.05 26.89 270 bottom
R1030  1K_1%_4  [R0402]  157.13 23.84 0 bottom
R1031  *0_4/S  [S0402]  155.48 25.49 270 bottom
R1034  *0_4/S  [S0402]  156.5 27.27 90 bottom
R1035  *0_4  [R0402]  175.04 26.89 90 bottom
R1036  *0_4/S  [S0402]  177.07 26.89 90 bottom
R1037  1K_1%_4  [R0402]  155.48 23.71 90 bottom
R1039  2/F_6  [R0603]  151.16 22.82 270 bottom
R1041  24.9/F_4  [R0402]  148.75 22.82 90 bottom
R1043  240/F_2  [R0201]  147.3 44.41 0 top
R1044  *1K_1%_2  [R0201]  148.34 44.41 180 top
R1045  *0_5%_2  [R0201]  158.32 44.41 180 top
R1046  *0_2/S  [S0201]  167.65 24.09 270 bottom
R1047  *0_2/S  [S0201]  166.63 24.09 270 bottom
R1048  *0_2/S  [S0201]  157.31 44.41 180 top
R1049  *0_5%_2  [R0201]  167.65 22.57 270 bottom
R1050  *0_5%_2  [R0201]  166.63 22.57 270 bottom
R2001  10K_5%_4  [R0402]  206.1 141.37 270 top
R2010  40.2_1%_4  [R0402]  218.68 132.64 90 top
R2011  40.2_1%_4  [R0402]  219.79 132.63 90 top
R2012  60.4_1%_4  [R0402]  219.36 121.88 90 top
R2020  *0_4/S  [S0402]  207.8 107.58 180 top
R2022  *100K_1%_4  [R0402]  231.05 93.4 270 bottom
R2023  100K_5%_4  [R0402]  222.03 86.07 90 top
R2024  100K_1%_4  [R0402]  222.28 94.71 270 top
R2025  100K_1%_4  [R0402]  231.05 91.37 90 bottom
R2026  100K_1%_4  [R0402]  232.06 93.4 270 bottom
R2027  100K_1%_4  [R0402]  223.3 94.71 270 top
R2028  *100K_1%_4  [R0402]  232.06 91.37 90 bottom
R2029  *100K_1%_4  [R0402]  222.41 92.39 90 top
R2030  100K_1%_4  [R0402]  223.43 92.39 270 top
R2031  10K_5%_4  [R0402]  219.72 90.74 180 top
R2032  *100K_1%_4  [R0402]  224.01 88.79 90 top
R2033  2K_1%_4  [R0402]  215.93 92.39 270 top
R2034  2K_1%_4  [R0402]  215.93 94.67 270 top
R2035  *10K_5%_4  [R0402]  219.23 94.67 90 top
R2036  *100K_1%_4  [R0402]  221.39 92.39 90 top
R2037  10K_1%_4  [R0402]  215.4 90.36 90 top
R2038  *0_4/S  [S0402]  220.12 84.93 270 top
R2039  2K_1%_4  [R0402]  216.95 92.39 270 top
R2040  2K_1%_4  [R0402]  216.95 94.67 270 top
R2042  *10K_5%_4  [R0402]  217.96 92.39 270 top
R2043  10K_5%_4  [R0402]  220.25 94.71 270 top
R2044  10K_5%_4  [R0402]  221.27 94.63 270 top
R2046  *0_5%_4  [R0402]  214.54 88.43 180 top
R2050  10K_5%_4  [R0402]  197.39 91.15 90 bottom
R2057  100K_5%_4  [R0402]  216.82 87.31 180 top
R2059  *0_4/S  [S0402]  219.21 87.34 180 top
R2060  100K_5%_4  [R0402]  216.82 86.29 180 top
R2062  10K_5%_4  [R0402]  212.7 143.65 270 bottom
R2063  10K_5%_4  [R0402]  209.75 140.4 270 bottom
R2064  10K_5%_4  [R0402]  214.01 133.21 0 bottom
R2065  2.49K_1%_4  [R0402]  200.44 129.25 0 bottom
R2066  10K_5%_4  [R0402]  243.61 115.02 0 bottom
R2067  10K_5%_4  [R0402]  245.51 115.02 0 bottom
R2068  10K_5%_4  [R0402]  244.88 111.79 180 bottom
R2069  10K_5%_4  [R0402]  235.23 108.11 270 bottom
R2070  *10K_1%_4  [R0402]  196.76 102.33 0 bottom
R2071  *10K_1%_4  [R0402]  195.61 103.67 90 bottom
R2072  10K_1%_4  [R0402]  197.14 104.48 90 bottom
R2073  2K_1%_4  [R0402]  215.93 94.67 270 bottom
R2074  2K_1%_4  [R0402]  215.93 92.39 270 bottom
R2075  *100K_1%_4  [R0402]  206.53 94.71 90 bottom
R2076  *100K_1%_4  [R0402]  205.39 94.67 270 bottom
R2077  1K_5%_4  [R0402]  207.55 94.71 270 bottom
R2078  10K_5%_4  [R0402]  224.34 90.01 0 bottom
R2079  10K_1%_4  [R0402]  196.26 97.63 180 bottom
R2080  10K_5%_4  [R0402]  196.75 95.59 0 bottom
R2081  100K_1%_4  [R0402]  219.23 94.67 270 bottom
R2082  *10K_1%_4  [R0402]  196.76 100.67 0 bottom
R2083  10K_5%_4  [R0402]  224.06 94.58 90 bottom
R2084  10K_5%_4  [R0402]  224.06 92.39 90 bottom
R2085  100K_1%_4  [R0402]  216.95 92.39 270 bottom
R2086  10K_5%_4  [R0402]  217.96 92.39 270 bottom
R2087  10K_5%_4  [R0402]  220.5 90.39 0 bottom
R2088  10K_5%_4  [R0402]  217.96 94.67 270 bottom
R2089  10K_5%_4  [R0402]  195.1 95.21 90 bottom
R2090  *100K_1%_4  [R0402]  222.03 92.39 90 bottom
R2091  100K_1%_4  [R0402]  221.06 94.67 270 bottom
R2092  *100K_1%_4  [R0402]  221.01 92.39 90 bottom
R2093  *10K_5%_4  [R0402]  222.16 88.48 180 bottom
R2094  100K_1%_4  [R0402]  222.03 94.67 270 bottom
R2095  10K_5%_4  [R0402]  219.23 92.39 270 bottom
R2096  *100K_1%_4  [R0402]  224.44 92.39 270 top
R2097  100K_1%_4  [R0402]  225 88.79 90 top
R2098  *100K_1%_4  [R0402]  223.04 92.39 90 bottom
R2099  100K_1%_4  [R0402]  223.04 94.67 270 bottom
R2101  10K_5%_4  [R0402]  199.93 88.32 90 bottom
R2102  100K_1%_4  [R0402]  65.21 69.26 270 bottom
R2103  100K_1%_4  [R0402]  203.87 95.05 180 bottom
R2104  100K_1%_4  [R0402]  63.99 69.26 270 bottom
R2105  100K_1%_4  [R0402]  202.09 95.05 0 bottom
R2107  10K_1%_4  [R0402]  232.32 67.91 180 top
R2108  *0_5%_4  [R0402]  232.82 66.89 0 top
R2109  100K_5%_4  [R0402]  232.7 63.21 90 top
R2110  100K_5%_4  [R0402]  233.71 63.21 90 top
R2111  *0_4/S  [S0402]  236 62.96 90 top
R2112  100K_1%_4  [R0402]  231.12 83.78 0 bottom
R2113  100K_1%_4  [R0402]  236.96 89.52 0 bottom
R2114  10K_1%_4  [R0402]  230.94 87.85 90 top
R2115  *0_5%_4  [R0402]  230.94 86.07 90 top
R2116  100K_5%_4  [R0402]  234.86 86.42 180 top
R2117  100K_5%_4  [R0402]  234.6 87.94 270 top
R2118  *0_4/S  [S0402]  235.62 87.94 90 top
R2119  10K_1%_4  [R0402]  234.35 76.54 180 top
R2120  *0_5%_4  [R0402]  234.09 75.15 90 top
R2121  100K_5%_4  [R0402]  234.73 73.12 0 top
R2122  100K_5%_4  [R0402]  234.73 72.1 0 top
R2123  *0_4/S  [S0402]  235.49 69.69 90 top
R2124  1K_5%_4  [R0402]  210.47 105.22 90 top
R2125  100K_1%_4  [R0402]  235.25 90.51 270 bottom
R2126  *0_4/S  [S0402]  218.22 94.71 90 top
R2127  0_5%_4  [R0402]  200.18 90.64 270 bottom
R2128  *10K_5%_4  [R0402]  222.16 81.88 180 top
R2129  0_5%_4  [R0402]  221.52 84.67 0 top
R2132  10K_5%_4  [R0402]  223.68 80.86 180 top
R2133  0_5%_4  [R0402]  225.08 80.1 270 top
R2135  10K_5%_4  [R0402]  271.56 52.67 315 bottom
R2136  *100K_5%_4  [R0402]  258.68 64.23 135 top
R2137  *0_5%_4  [R0402]  226.09 80.1 90 top
R2138  10K_5%_4  [R0402]  207.04 92.93 270 bottom
R2139  10K_5%_4  [R0402]  205.9 92.93 270 bottom
R2140  *0_5%_4  [R0402]  232.34 89.24 270 top
R2141  *0_5%_4  [R0402]  232.98 72.2 0 top
R2142  *0_4/S  [S0402]  220 81.65 90 bottom
R2143  *0_4  [R0402]  218.98 81.65 90 bottom
R2145  10K_5%_4  [R0402]  209.46 50.51 90 top
R2146  10K_5%_4  [R0402]  229.52 86.96 180 top
R2147  *0_5%_4  [R0402]  220.25 82.64 0 top
R2148  10K_5%_4  [R0402]  220.25 80.23 0 top
R2150  100K/F_4  [R0402]  228.33 86.83 90 bottom
R2151  100K/F_4  [R0402]  236.96 87.59 0 bottom
R2152  100K/F_4  [R0402]  232.95 84.34 180 bottom
R2226  1K_1%_4  [R0402]  76.49 62.45 0 top
R2227  30K_4  [R0402]  264.11 58.46 315 top
R2228  200K_1%_4  [R0402]  256.83 65.24 135 top
R2231  0_5%_4  [R0402]  229.65 83.76 270 top
R2232  *10K_5%_4  [R0402]  228.63 83.76 90 top
R2233  *0_5%_4  [R0402]  229.75 84.19 270 bottom
R2234  *0_5%_4  [R0402]  236.96 88.56 180 bottom
R2235  *0_5%_4  [R0402]  228.33 88.56 90 bottom
R2500  120_1%_4  [R0402]  226.37 143.19 0 top
R2501  *0_4/S  [S0402]  199.63 141.67 90 top
R2502  *0_4/S  [S0402]  222.71 141.15 90 top
R2503  1K_5%_4  [R0402]  205.46 143.42 180 top
R2504  1K_5%_4  [R0402]  214.4 142.91 90 top
R2505  1.33K_1%_4  [R0402]  228.15 142.89 0 top
R2506  120_1%_4  [R0402]  193.27 142.02 180 top
R2507  549_1%_4  [R0402]  228.15 141.88 0 top
R2508  931_1%_4  [R0402]  228.15 140.86 0 top
R2509  40.2_1%_4  [R0402]  199.32 143.19 0 top
R2510  40.2_1%_4  [R0402]  199.31 144.17 0 top
R2511  40.2_1%_4  [R0402]  223.19 143.33 180 top
R2512  40.2_1%_4  [R0402]  223.19 144.31 180 top
R2513  120_1%_4  [R0402]  244.3 129.01 0 top
R2514  40.2_1%_4  [R0402]  246.16 124.38 270 top
R2515  40.2_1%_4  [R0402]  245.2 124.38 270 top
R2516  *0_4/S  [S0402]  244.99 122.95 180 top
R2517  1K_5%_4  [R0402]  245.4 115.56 0 top
R2518  1K_5%_4  [R0402]  245.65 110.71 0 top
R2519  40.2_1%_4  [R0402]  245.71 102.95 90 top
R2520  40.2_1%_4  [R0402]  244.73 102.95 90 top
R2521  *0_4/S  [S0402]  243.76 103.97 270 top
R2522  120_1%_4  [R0402]  244.5 99.42 270 top
R2523  931_1%_4  [R0402]  237.9 93.15 180 bottom
R2524  1.33K_1%_4  [R0402]  239.3 93.78 270 bottom
R2525  549_1%_4  [R0402]  237.9 94.17 180 bottom
R3000  *0_6/S  [S0603]  56.29 53.81 0 top
R3001  100K_1%_4  [R0402]  54.77 55.72 180 top
R3002  100K_1%_4  [R0402]  269.78 34.25 90 top
R3004  100K_1%_4  [R0402]  59.21 51.27 0 bottom
R3007  2K_5%_4  [R0402]  57.31 51.27 180 bottom
R3008  10K_1%_4  [R0402]  60.36 48.48 180 bottom
R3009  *0_6/S  [S0603]  44.02 51.68 180 bottom
R3010  100K_1%_4  [R0402]  51.59 50.51 270 top
R3011  *0_4/S  [S0402]  341.03 19.43 90 top
R3012  10K/F_4  [R0402]  47.25 58.99 180 top
R3013  *0_4/S  [S0402]  337.98 18.53 90 top
R3014  *0_4/S  [S0402]  55.91 50.26 0 bottom
R3016  100K_1%_4  [R0402]  54.01 44.92 0 top
R3017  100K_1%_4  [R0402]  49.05 47.84 90 top
R3019  4.7K/F_4  [R0402]  33.51 47.97 90 bottom
R3020  *600,2A_6  [R0603]  44.48 50.13 180 top
R3021  *0_5%_4  [R0402]  55.91 49.24 0 bottom
R3022  1K_1%_4  [R0402]  54.01 50.13 0 bottom
R3023  *0_4/S  [S0402]  50.07 47.84 90 top
R3024  *0_4  [R0402]  52.61 50.51 270 top
R3025  *0_4/S  [S0402]  57.44 45.43 180 top
R3026  10K/F_4  [R0402]  46.01 47.84 90 top
R3027  *0_4  [R0402]  51.72 48.48 180 top
R3029  10K/F_4  [R0402]  32.72 56.43 90 bottom
R3030  2.2K_5%_4  [R0402]  29.57 54.68 90 bottom
R3031  2.2K_5%_4  [R0402]  30.56 54.68 90 bottom
R3034  10K_1%_4  [R0402]  11.21 54.95 90 bottom
R3036  *0_4/S  [S0402]  249 35.19 180 top
R3037  100K_1%_4  [R0402]  54.95 60.54 90 bottom
R3039  100K_1%_4  [R0402]  53.68 60.54 90 bottom
R3040  1M_5%_4  [R0402]  59.47 60.29 270 top
R3041  100K_1%_4  [R0402]  67.09 64.73 180 bottom
R3042  22K_1%_4  [R0402]  84.11 62.32 90 top
R3043  100K_5%_4  [R0402]  82.96 62.32 90 top
R3044  *0_4/S  [S0402]  58.17 62.5 90 top
R3045  22K_1%_4  [R0402]  80.17 62.45 180 top
R3047  2.2K_5%_4  [R0402]  78.39 62.45 0 top
R3048  100K_5%_4  [R0402]  81.95 62.32 90 top
R3049  *0_4  [R0402]  253.52 37.3 0 top
R3050  *0_4  [R0402]  249.61 40.1 0 top
R3051  *0_4  [R0402]  256.45 37.81 0 top
R3052  *0_5%_4  [R0402]  66.58 69.71 0 bottom
R3053  *0_4/S  [S0402]  68.36 60.54 270 bottom
R3054  *0_4/S  [S0402]  67.44 62.45 270 bottom
R3055  *0_4/S  [S0402]  67.09 65.75 0 bottom
R3056  *0_4/S  [S0402]  56.17 65.75 180 top
R3057  4.99K_1%_4  [R0402]  59.8 67.78 180 top
R3058  *10K_5%_4  [R0402]  53.88 64.86 0 top
R3059  *10K_5%_4  [R0402]  58.58 58.89 180 top
R3060  100K_5%_4  [R0402]  59.8 69.81 0 top
R3061  100K_5%_4  [R0402]  59.8 68.8 0 top
R3062  *4.7K/F_4  [R0402]  68.87 58.51 270 top
R3063  *4.7K/F_4  [R0402]  67.85 57.75 270 top
R3064  *4.7K/F_4  [R0402]  65.82 58.51 270 top
R3065  *4.7K/F_4  [R0402]  64.93 56.86 0 top
R3066  *4.7K/F_4  [R0402]  60.23 66.64 180 top
R3067  *4.7K/F_4  [R0402]  62.77 57.98 270 top
R3068  *4.7K/F_4  [R0402]  61.75 57.98 270 top
R3075  *4.7K/F_4  [R0402]  63.79 58.51 270 top
R3076  *4.7K/F_4  [R0402]  60.36 58.89 180 top
R3077  *4.7K/F_4  [R0402]  66.83 58.51 270 top
R3079  *0_4/S  [S0402]  52.74 45.94 90 bottom
R3080  1M/F_4  [R0402]  52.13 51.27 270 bottom
R3081  *0_2/S  [S0201]  51.14 51.5 90 bottom
R3082  *0_4/S  [S0402]  53.65 49.6 270 top
R3083  2.2K_5%_4  [R0402]  13.49 63.01 0 bottom
R3084  2.2K_5%_4  [R0402]  11.67 63.01 180 bottom
R3085  2.2K_5%_4  [R0402]  17.2 63.01 0 bottom
R3086  2.2K_5%_4  [R0402]  15.35 63.01 180 bottom
R3091  *0_4/S  [S0402]  59.72 46.95 180 bottom
R3092  1K_1%_4  [R0402]  59.72 45.94 0 bottom
R3093  *10K_1%_4  [R0402]  20.73 63.01 0 bottom
R3094  100K_1%_4  [R0402]  18.96 63.01 0 bottom
R3200  3.3K/F_4  [R0402]  357.92 85.82 180 top
R3201  *100K/F_4  [R0402]  356.65 86.07 90 bottom
R3202  *100K/F_4  [R0402]  350.04 86.58 180 bottom
R3203  3.3K/F_4  [R0402]  357.92 86.83 180 top
R3204  *120_2  [R0201]  357.16 98.13 270 top
R3205  *120_2  [R0201]  357.16 89.88 90 top
R3206  *120_2  [R0201]  357.16 95.49 270 top
R3207  *120_2  [R0201]  357.16 93.44 90 top
R3600  *0_6/S  [S0603]  328.02 10.92 270 top
R3601  *0_4/S  [S0402]  347.5 8.38 270 top
R3602  *0_4/S  [S0402]  342.04 18.36 270 top
R3603  *0_4/S  [S0402]  344.38 4.59 180 top
R3604  100K_1%_4  [R0402]  346.31 4.36 0 top
R3605  33_4  [R0402]  344.84 16.51 90 top
R3606  *0_4/S  [S0402]  336.33 16.46 270 top
R3607  768K_1%_4  [R0402]  343.95 6.06 90 top
R3608  *0_4/S  [S0402]  346.23 16.14 180 top
R3609  *0_4/S  [S0402]  332.77 12.95 270 top
R3610  10K_1%_4  [R0402]  341.79 16.51 90 top
R3611  100_1%_2  [R0201]  342.2 4.61 180 top
R3612  33_5%_4  [R0402]  340.77 16.28 90 top
R3613  *33_4  [R0402]  347.99 11.63 270 top
R3614  33_4  [R0402]  347 11.63 270 top
R3615  *0_2/S  [S0201]  345.27 10.79 180 top
R3616  *0_2/S  [S0201]  345.98 12.82 180 top
R3617  *0_2/S  [S0201]  345.98 13.58 180 top
R3618  33_5%_4  [R0402]  335.31 16.46 90 top
R3619  100K_1%_4  [R0402]  334.3 14.35 90 top
R3620  *0_4/S  [S0402]  332.77 14.73 0 top
R3622  *0_4/S  [S0402]  332.7 4.57 180 top
R3626  *0_8/S  [S0805]  337.42 6.22 0 bottom
R3627  *0_8  [R0805]  337.34 3.04 180 top
R3628  *0_8  [R0805]  337.34 3.04 180 bottom
R3629  33_5%_4  [R0402]  342.7 19.71 0 top
R3630  33_4  [R0402]  350.78 9.14 180 top
R3631  10K_1%_4  [R0402]  348.9 9.14 180 top
R3636  *0_4/S  [S0402]  348.14 21.76 90 top
R3637  *0_4/S  [S0402]  348.88 25.9 180 top
R3638  *0_4/S  [S0402]  352.97 27.78 90 top
R3639  10K_1%_4  [R0402]  351.44 27.14 180 top
R3640  *0_4/S  [S0402]  360.46 14.57 0 top
R3641  30/F_4  [R0402]  356.24 9.41 180 top
R3642  30/F_4  [R0402]  352.46 3.39 270 top
R3643  *0_5%_6  [R0603]  196.63 155.67 0 top
R3644  *0_6/S  [S0603]  229.09 153.23 90 bottom
R3645  *0_6/S  [S0603]  196.63 157.19 0 top
R3646  2.2K_5%_4  [R0402]  195.87 154.14 180 bottom
R3647  2.2K_5%_4  [R0402]  195.87 155.16 180 bottom
R3648  *0_5%_4  [R0402]  200.06 153.76 0 top
R3649  *0_5%_4  [R0402]  221.01 156.68 270 top
R3652  *0_5%_4  [R0402]  201.33 156.68 0 top
R3655  *0_2/S  [S0201]  349.64 11.55 90 top
R3678  *0_4/S  [S0402]  203.23 157.82 0 top
R3679  *0_4/S  [S0402]  203.23 158.84 0 top
R3680  *0_5%_4  [R0402]  192.79 150.84 180 bottom
R3681  *0_5%_4  [R0402]  191.8 151.22 0 top
R3682  *0_4/S  [S0402]  340.9 20.95 0 top
R3683  *47K/F_4  [R0402]  353.42 7.91 0 top
R4000  *0_4/S  [S0402]  29.5 118.84 90 bottom
R4001  *10K/F_4  [R0402]  28.86 122.9 0 top
R4002  *10K/F_4  [R0402]  29.5 118.84 90 top
R4003  *4.7K/F_4  [R0402]  22.64 120.61 90 top
R4004  4.7K/F_4  [R0402]  22 120.36 90 bottom
R4005  *10K/F_4  [R0402]  26.83 122.01 0 top
R4006  *0_5%_4  [R0402]  23.65 120.61 90 top
R4007  *0_4/S  [S0402]  19.67 126.3 0 bottom
R4008  1K_1%_4  [R0402]  31.15 125.57 90 top
R4009  3.01K/F_4  [R0402]  22.26 127.85 270 bottom
R4010  *2.2K_4  [R0402]  30.64 131.92 180 top
R4011  20K/F_4  [R0402]  28.86 127.09 180 top
R4012  10K_1%_4  [R0402]  28.86 128.11 0 top
R4013  100K_1%_4  [R0402]  30.64 129.12 0 top
R4014  100K_1%_4  [R0402]  30.64 130.9 0 top
R4015  75/F_4  [R0402]  20.86 137.07 0 bottom
R4016  75/F_4  [R0402]  20.86 138.77 0 bottom
R4017  75/F_4  [R0402]  20.86 143.73 0 bottom
R4018  75/F_4  [R0402]  20.86 145.25 0 bottom
R4019  *0_6/S  [S0603]  15.4 112.23 90 top
R4020  *0_6/S  [S0603]  10.7 136.36 90 top
R4021  *0_4/S  [S0402]  23.27 122.01 180 top
R4022  *30K_4  [R0402]  28.86 126.07 0 top
R4023  499_1%_4  [R0402]  28.86 124.93 0 top
R4024  499_1%_4  [R0402]  28.86 123.92 0 top
R4025  *0_4/S  [S0402]  23.15 125.06 0 top
R4026  *0_4/S  [S0402]  23.27 123.03 180 top
R4100  100K_1%_4  [R0402]  328.58 71.85 0 bottom
R4101  *10K_5%_2  [R0201]  352.2 72.73 90 bottom
R4102  *4.7K/F_4  [R0402]  328.2 70.83 0 bottom
R4103  *0_4  [R0402]  352.2 71.34 90 bottom
R4104  *100K/F_4  [R0402]  352.97 78.83 180 bottom
R4106  *0_4/S  [S0402]  350.55 73.75 180 bottom
R4107  100K_1%_4  [R0402]  352.97 79.85 180 bottom
R4108  *0_6/S  [S0603]  331.76 78.32 0 bottom
R4110  10K_1%_4  [R0402]  351.31 76.42 0 bottom
R4111  100K_1%_4  [R0402]  351.57 79.47 270 bottom
R4112  10K_1%_4  [R0402]  349.41 85.18 0 bottom
R4113  *0_4  [R0402]  347.76 76.42 0 bottom
R4114  *0_4/S  [S0402]  349.54 76.42 0 bottom
R4115  *0_4/S  [S0402]  340.27 61.69 0 bottom
R4116  *0_4/S  [S0402]  350.55 72.48 180 bottom
R4117  *0_4/S  [S0402]  350.55 71.34 0 bottom
R4118  10K_5%_2  [R0201]  341.05 62.57 0 bottom
R4119  *0_4/S  [S0402]  342.68 74.97 0 top
R4120  75K/F_4  [R0402]  344.46 60.57 0 bottom
R4121  10K_1%_4  [R0402]  334.42 27.47 180 top
R4122  *10K/F_4  [R0402]  350.55 74.77 0 bottom
R4123  4.7K/F_4  [R0402]  347.12 62.32 180 bottom
R4124  *100K_1%_4  [R0402]  345.98 76.42 180 bottom
R4125  4.7K/F_4  [R0402]  355.51 69.31 270 bottom
R4127  75K/F_4  [R0402]  328.58 72.86 0 bottom
R4129  22_1%_4  [R0402]  345.35 62.32 0 bottom
R4130  22_1%_4  [R0402]  343.59 62.32 0 bottom
R4131  *0_4/S  [S0402]  336.2 73.7 270 top
R4132  *0_4/S  [S0402]  336.1 70.09 270 top
R4133  *0_4/S  [S0402]  342.02 72.25 90 top
R4134  *0_4/S  [S0402]  341.99 69.81 270 top
R4135  *0_4  [R0402]  331.86 66.26 180 top
R4137  10K/F_4  [R0402]  331.86 67.35 180 top
R4138  *10K/F_4  [R0402]  331.86 68.92 180 top
R4200  1M/F_4  [R0402]  352.63 12.54 180 bottom
R4201  47K/F_4  [R0402]  336.32 20.85 180 bottom
R4202  *30K_4  [R0402]  334.17 23.49 270 bottom
R4203  *1M/F_4  [R0402]  352.63 13.56 180 bottom
R4204  *100K_1%_4  [R0402]  305.34 12.92 90 top
R4205  100K_1%_4  [R0402]  329.21 5.81 0 bottom
R4206  *0_4/S  [S0402]  333.27 18.66 90 bottom
R4207  *0_4/S  [S0402]  333.43 5.93 90 bottom
R4208  *0_4  [R0402]  342.55 19.73 0 bottom
R4209  *100K_1%_4  [R0402]  340.04 19.3 270 bottom
R4210  *10K/F_4  [R0402]  331.78 18.16 180 bottom
R4211  *0_4/S  [S0402]  349.08 6.31 270 bottom
R4212  *20K/F_4  [R0402]  306.36 12.92 90 top
R4213  *100K/F_4  [R0402]  342.55 18.41 0 bottom
R4214  *0_4  [R0402]  334.45 5.93 90 bottom
R4215  47K/F_4  [R0402]  336.32 21.87 180 bottom
R4216  *0_8/S  [S0805]  331.5 22.95 0 bottom
R4217  *0_4/S  [S0402]  330.61 5.04 90 bottom
R4219  100K_1%_4  [R0402]  333.27 20.43 90 bottom
R4221  *0_4  [R0402]  350.07 6.19 90 bottom
R4222  *0_4/S  [S0402]  352.63 11.53 180 bottom
R4223  *30K_4  [R0402]  334.23 18.42 90 bottom
R4224  *0_4/S  [S0402]  331.63 5.04 90 bottom
R4225  47K/F_4  [R0402]  347.35 5.93 90 bottom
R4226  *100K_1%_4  [R0402]  344.84 18.63 90 bottom
R4227  100K_1%_4  [R0402]  338.56 21 180 bottom
R5000  *0_8/S  [S0805]  44.99 47.46 270 bottom
R5001  *0_4/S  [S0402]  37.57 47.21 270 bottom
R5100  10K_1%_4  [R0402]  326.68 24.22 180 bottom
R5102  *0_4  [R0402]  312.96 30.06 270 bottom
R5103  *0_4  [R0402]  325.91 20.41 180 bottom
R5104  *0_4  [R0402]  319.06 49.62 0 bottom
R5106  *0_4  [R0402]  318.75 8.22 0 top
R5108  10K_1%_4  [R0402]  310.55 41.37 180 bottom
R5109  *0_4  [R0402]  325.79 22.19 270 bottom
R5111  *0_4  [R0402]  309.91 42.38 180 bottom
R6000  *0_4/S  [S0402]  278.16 26.51 180 top
R6001  *10K_5%_2  [R0201]  273.84 30.06 180 top
R6003  100K_4  [R0402]  275.88 30.82 0 bottom
R6004  *0_4/S  [S0402]  264.95 34.25 270 bottom
R6005  2M_4  [R0402]  31.53 136.11 90 bottom
R6008  *0_4/S  [S0402]  271.56 34.25 270 bottom
R6011  *0_4/S  [S0402]  278.16 27.52 180 top
R6014  33_5%_4  [R0402]  275.88 33.11 180 bottom
R6015  33_5%_4  [R0402]  275.88 31.84 180 bottom
R6016  *0_4/S  [S0402]  294.19 47.46 0 bottom
R6017  *0_4/S  [S0402]  270.29 20.03 90 top
R6018  10K_5%_2  [R0201]  275.5 29.94 180 bottom
R6019  *0_4/S  [S0402]  300.44 40.48 270 bottom
R6020  *15K_1%_4  [R0402]  272.19 20.28 90 bottom
R6021  300_5%_4  [R0402]  261.91 28.56 0 bottom
R6022  *0_4/S  [S0402]  275.44 23.94 270 bottom
R6023  300_5%_4  [R0402]  258.96 27.04 0 top
R6025  300_5%_4  [R0402]  261.07 24.86 0 bottom
R6026  43_5%_4  [R0402]  267.75 34.25 270 bottom
R6027  *0_6/S  [S0603]  258.86 25.87 90 bottom
R6028  2.2K_5%_2  [R0201]  275.75 26.25 0 top
R6029  2.2/F_6  [R0603]  276.26 28.79 0 bottom
R6030  *0_4/S  [S0402]  301.78 46.06 180 bottom
R6031  2.2K_5%_2  [R0201]  275.75 27.01 0 top
R6032  2.2/F_6  [R0603]  269.65 36.16 0 bottom
R6034  2.2/F_6  [R0603]  261.91 23.59 90 top
R6035  *0_4/S  [S0402]  301.4 40.48 270 bottom
R6036  2.2K_5%_2  [R0201]  275.5 22.7 180 bottom
R6037  2.2K_5%_2  [R0201]  275.5 21.93 180 bottom
R6038  2.2K_5%_2  [R0201]  273.21 33.87 270 top
R6039  2.2K_5%_2  [R0201]  273.97 33.87 270 top
R6040  10K_1%_4  [R0402]  275.88 29.05 180 top
R6045  *10K_5%_2  [R0201]  260.15 36.44 270 top
R6047  10K_5%_2  [R0201]  260.64 33.97 0 top
R6050  100K_1%_2  [R0201]  264.83 26.89 0 top
R6053  470K_5%_4  [R0402]  254.03 30.19 270 top
R6056  100K_1%_2  [R0201]  268.26 30.7 270 top
R6061  *0_4/S  [S0402]  271.3 20.16 90 top
R6062  100K_1%_2  [R0201]  263.61 27.52 90 top
R6066  *10K_2  [R0201]  261.65 33.97 180 top
R6068  10K_5%_2  [R0201]  275.5 30.95 180 top
R6071  20K_1%_4  [R0402]  265.67 33.62 90 top
R6072  *0_4/S  [S0402]  274.35 34.25 270 bottom
R6073  *0_4/S  [S0402]  275.88 30.06 180 top
R6075  *1K_1%_4  [R0402]  270.03 19.88 270 bottom
R6077  10K_5%_2  [R0201]  273.46 33.87 90 bottom
R6078  100K_1%_2  [R0201]  259.75 28.28 270 top
R6079  100K_1%_2  [R0201]  255.12 27.75 90 top
R6080  47_5%_4  [R0402]  258.48 28.28 180 top
R6082  100K_4  [R0402]  275.22 24.4 0 top
R6090  4.7K_1%_2  [R0201]  193.83 19.14 180 top
R6091  4.7K_1%_2  [R0201]  192.82 22.57 0 top
R6092  *0_4  [R0402]  32.8 141.57 0 bottom
R6093  100/F_4  [R0402]  34.45 141.7 270 bottom
R6094  360_6  [R0603]  362.24 150.46 180 top
R6095  360_6  [R0603]  362.24 151.98 180 top
R6096  1M/F_4  [R0402]  32.54 136.11 270 bottom
R6097  *2.2/F_6  [R0603]  258.86 28.67 90 bottom
R6098  2.2/F_6  [R0603]  257.33 28.67 90 bottom
R6100  10K_5%_2  [R0201]  272.45 33.87 270 top
R6130  2.2K_5%_2  [R0201]  267.11 35.9 0 bottom
R6131  2.2K_5%_2  [R0201]  268.89 33.75 0 bottom
R6132  10K_5%_2  [R0201]  262.03 22.32 180 bottom
R6133  10K_5%_2  [R0201]  262.03 23.08 180 bottom
R6134  33_5%_4  [R0402]  263.94 34.25 270 bottom
R6135  33_5%_4  [R0402]  261.91 32.98 0 bottom
R6136  33_5%_4  [R0402]  261.91 31.54 0 bottom
R6137  33_5%_4  [R0402]  261.91 30.57 0 bottom
R6138  33_5%_4  [R0402]  261.91 29.55 0 bottom
R6152  33_5%_4  [R0402]  301.68 54.14 90 bottom
R6164  100K_4  [R0402]  276.64 32.22 270 top
R6165  *10K_5%_2  [R0201]  275.5 31.71 0 top
R6167  10K_5%_2  [R0201]  272.19 20.16 90 top
R6169  470K_5%_4  [R0402]  256.53 52.44 90 top
R6170  470K_5%_4  [R0402]  255.56 52.44 90 top
R6172  *10K_2  [R0201]  250.35 47.97 180 top
R6173  *10K_2  [R0201]  250.35 47.21 180 top
R6174  2.2K_5%_4  [R0402]  254.16 51.4 180 top
R6175  *0_4/S  [S0402]  252.51 47.46 180 top
R6176  2.2K_5%_2  [R0201]  256.19 48.86 180 top
R6177  *0_4  [R0402]  254.41 45.18 270 top
R6178  *0_4/S  [S0402]  255.43 45.18 270 top
R6179  *0_4  [R0402]  252.13 43.14 180 top
R6181  10K_1%_4  [R0402]  269.4 12.16 0 top
R6182  10K_1%_4  [R0402]  269.4 13.93 0 top
R6183  *10K_1%_4  [R0402]  263.81 12.16 0 top
R6184  *10K_1%_4  [R0402]  263.81 14.14 0 top
R6185  0_4  [R0402]  266.48 15.46 0 top
R6186  0_4  [R0402]  263.81 11.14 180 top
R6187  *0_4/S  [S0402]  265.97 34.25 90 bottom
R6188  33_5%_4  [R0402]  306.56 50.1 180 top
R6189  33_5%_4  [R0402]  298.61 46.95 180 top
R6190  33_5%_4  [R0402]  306.56 48.99 180 top
R6201  4.7K/F_4  [R0402]  301.78 47.08 180 bottom
R6202  2.55K/F_4  [R0402]  308.59 50.1 180 top
R6203  *0_4/S  [S0402]  308.52 45.61 90 bottom
R6204  *0_4/S  [S0402]  301.53 59.53 270 bottom
R6205  4.7K/F_4  [R0402]  299.24 46.95 0 bottom
R6210  *3.3K/F_4  [R0402]  316.26 51.53 270 bottom
R6212  33_4  [R0402]  297.85 46.57 270 bottom
R6214  *0_4/S  [S0402]  301.25 57.19 90 bottom
R6215  *200K/F_4  [R0402]  301.63 55.82 0 bottom
R6218  33_4  [R0402]  317.28 51.53 90 bottom
R6221  3.3K/F_4  [R0402]  300.51 52.62 270 bottom
R6222  3.3K/F_4  [R0402]  297.34 59.65 0 bottom
R6223  100K_4  [R0402]  261.65 34.81 180 top
R6224  10K_5%_2  [R0201]  260.64 31.33 270 top
R6225  10K_5%_2  [R0201]  261.91 31.21 0 top
R6228  *4.7K/F_4  [R0402]  277.78 24.35 180 bottom
R6229  *2.55K/F_4  [R0402]  278.54 27.27 0 bottom
R6230  10K_1%_4  [R0402]  271.18 20.28 270 bottom
R6231  *20K_1%_2  [R0201]  258.99 29.68 0 top
R6234  *1K_1%_4  [R0402]  258.96 25.97 180 top
R6237  100K_1%_4  [R0402]  279.97 29.73 270 top
R6238  *100K_1%_2  [R0201]  260 29.68 0 top
R6240  300_5%_4  [R0402]  305.64 39.31 270 top
R6241  300_5%_4  [R0402]  258.78 21.58 0 top
R6300  *0_4  [R0402]  322.23 76.67 270 bottom
R6301  *0_4/S  [S0402]  19.84 98.52 0 bottom
R6302  2K/F_4  [R0402]  326.8 80.1 0 bottom
R6303  10K_1%_4  [R0402]  24.8 94.71 270 bottom
R6304  *47K/F_4  [R0402]  323.25 78.32 0 bottom
R6305  10K_1%_4  [R0402]  334.7 87.9 270 bottom
R6351  *0_4/S  [S0402]  103.92 5.73 90 top
R6353  *0_4/S  [S0402]  101.63 5.73 90 top
R6354  *0_4/S  [S0402]  100.62 5.73 90 top
R6355  *0_4/S  [S0402]  102.9 5.73 90 top
R6358  47K/F_4  [R0402]  97.72 4.99 90 top
R6359  1K_1%_4  [R0402]  98.71 3.7 180 bottom
R6401  2.2K_5%_4  [R0402]  170.09 89.72 180 bottom
R6402  150/F_4  [R0402]  121.44 113.17 0 top
R6403  *470K/J_4  [R0402]  128.18 113.12 0 top
R6404  25.5K/F_4  [R0402]  128.18 111.09 180 top
R6405  10K_1%_4  [R0402]  188.25 91.02 270 bottom
R6406  10K_1%_4  [R0402]  189.77 88.61 180 bottom
R6407  *0_4/S  [S0402]  274.99 34.13 270 top
R6412  2.2K_5%_2  [R0201]  270.16 18 180 top
R6413  2.2K_5%_2  [R0201]  270.16 17.24 180 top
R6500  *0_4  [R0402]  296.45 56.86 90 top
R6501  *150K/F_4  [R0402]  293.15 47.46 90 top
R6502  10K_1%_4  [R0402]  296.2 47.46 270 top
R6503  *0_4/S  [S0402]  297.85 57.39 0 top
R6504  *0_4/S  [S0402]  252.51 46.45 180 top
R6507  *0_4  [R0402]  292.13 47.46 90 top
R6508  4.7K/F_4  [R0402]  297.85 56.38 180 top
R6509  4.7K/F_4  [R0402]  295.36 56.73 270 top
R6510  10K_1%_4  [R0402]  292.64 45.68 0 top
R6511  51K_4  [R0402]  303.05 41.49 270 bottom
R6512  10K_1%_4  [R0402]  304.07 41.49 270 bottom
R6513  *0_5%_4  [R0402]  291.37 48.99 180 top
R6514  *0_4/S  [S0402]  292.39 53.43 270 top
R6802  10K_1%_4  [R0402]  238.92 45.43 270 top
R6803  10K_1%_4  [R0402]  238.23 55.84 90 top
R6804  10K_1%_4  [R0402]  237.9 57.62 270 top
R6805  10K_1%_4  [R0402]  237.52 59.02 180 top
R6806  10K_1%_4  [R0402]  238.54 49.04 0 top
R6807  10K_1%_4  [R0402]  238.28 52.54 180 top
R6808  10K_1%_4  [R0402]  238.54 50.05 0 top
R6809  560_5%_4  [R0402]  237.52 60.03 0 top
R6810  10K_1%_4  [R0402]  242.86 55.77 180 top
R6811  470/F_4  [R0402]  236.62 51.53 0 top
R6812  560_5%_4  [R0402]  236.51 57.62 90 top
R6813  200/F_4  [R0402]  237.27 55.84 270 top
R6814  470/F_4  [R0402]  238.28 53.71 0 top
R6815  *0_4/S  [S0402]  231.05 56.1 0 bottom
R6816  *0_4/S  [S0402]  231.05 55.08 0 bottom
R6817  200/F_4  [R0402]  236.89 53.94 270 top
R6818  470/F_4  [R0402]  236.62 50.51 0 top
R6819  200/F_4  [R0402]  236.62 49.49 0 top
R6820  200/F_4  [R0402]  236.62 48.48 0 top
R6821  200/F_4  [R0402]  230.92 53.05 180 bottom
R6822  *0_4/S  [S0402]  231.05 52.03 0 bottom
R6823  10K_1%_4  [R0402]  240.95 60.16 90 top
R6824  20K/F_4  [R0402]  243.47 45.58 270 top
R6825  *10K/F_4  [R0402]  241.46 51.02 180 top
R6826  20K/F_4  [R0402]  242.09 43.91 180 top
R6827  100K_1%_4  [R0402]  189.9 47.59 90 top
R6828  1K_1%_4  [R0402]  190.91 47.59 90 top
R7008  10K_1%_4  [R0402]  26.96 99.15 270 top
R7011  22K/F_4  [R0402]  18.96 99.91 0 top
R7013  39K/F_4  [R0402]  18.96 100.93 180 top
R7016  *0_4  [R0402]  24.8 96.86 270 top
R7019  10K_1%_4  [R0402]  26.83 97.37 0 top
R7022  *0_4/S  [S0402]  26.83 96.36 0 top
R7100  *10K_1%_4  [R0402]  359.92 120.11 90 bottom
R7101  *10K_1%_4  [R0402]  360.59 123.53 270 bottom
R7140  10K_1%_4  [R0402]  346.23 89.37 270 bottom
R7141  *470K_5%_4  [R0402]  339.12 133.82 270 bottom
R7142  1M_1%_4  [R0402]  339.25 132.04 270 bottom
R7153  10K_1%_4  [R0402]  343.44 100.55 90 top
R7154  1M_1%_4  [R0402]  340.52 129.25 180 top
R7155  *470K_5%_4  [R0402]  340.52 130.27 0 top
R7175  *0_2/S  [S0201]  359.7 132.93 270 top
R7176  *0_2/S  [S0201]  359.92 127.88 180 bottom
R7177  *0_2/S  [S0201]  359.7 116.17 270 top
R7178  *0_2/S  [S0201]  361.73 110.45 270 bottom
R7187  10K_1%_4  [R0402]  350.91 143.65 90 top
R7188  14.3K_1%_4  [R0402]  349.94 143.65 270 top
R7189  10K_1%_4  [R0402]  348.9 131.41 180 top
R7190  14.3K_1%_4  [R0402]  348.9 132.42 180 top
R7191  *470K_5%_4  [R0402]  356.14 131.92 0 top
R7192  *470K_5%_4  [R0402]  356.14 130.9 0 top
R7199  *10K_1%_4  [R0402]  345.22 89.37 270 bottom
R7200  10K_1%_4  [R0402]  290.35 12.28 90 bottom
R7201  *0_4/S  [S0402]  295.69 11.9 180 bottom
R7202  *0_4/S  [S0402]  295.69 10.63 180 bottom
R7203  10K_1%_4  [R0402]  289.97 10.63 180 bottom
R7204  *10K/F_4  [R0402]  290.35 14.06 90 bottom
R7205  *0_2/S  [S0201]  354.36 144.16 0 top
R7206  *0_2/S  [S0201]  342.42 129.25 180 top
R7300  4.7K/F_4  [R0402]  286.26 10.4 0 top
R7301  *0_4  [R0402]  285.27 20.87 90 bottom
R7302  100K_1%_4  [R0402]  282.96 20.77 270 bottom
R7303  *0_4/S  [S0402]  284.99 22.95 90 bottom
R7304  470/F_4  [R0402]  286.65 8.9 270 top
R7305  *0_4/S  [S0402]  284.23 14.49 270 top
R7306  *0_4/S  [S0402]  283.22 14.49 270 top
R7307  10K_4  [R0402]  29.88 73.88 270 bottom
R7308  *0_5%_4  [R0402]  31.02 73.8 90 bottom
R7309  33_4  [R0402]  24.52 70.63 0 bottom

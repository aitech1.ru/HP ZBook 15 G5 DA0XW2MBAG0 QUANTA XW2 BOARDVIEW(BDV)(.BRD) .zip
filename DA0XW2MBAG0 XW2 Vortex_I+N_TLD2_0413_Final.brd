# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD26: length 25.8
  IN3 w0.089: v1(204.38,141.75) 204.83,141.3 206.61,141.3 207.17,140.74 208.15,140.74 208.77,140.13 208.77,134.81 212.2,131.37 212.2,127.58 212.05,127.43 212.05,124.67 212.08,124.64 212.08,124.35 212.18,124.25 212.18,123.33 212.18,122.72 v1(211.72,122.26)
  BOTTOM w0.14: U2000.Y30 212.08,122.62 211.73,122.27 211.73,122.26 v1(211.72,122.26) ; VRAM2500.K4 v1(204.38,141.75)
FBA_CMD27: length 21.5
  BOTTOM w0.14: U2000.AA34 211.28,128.06 209.78,129.56 209.78,130.93 207.77,132.94 v1(206.29,132.94) 205.54,132.94 203.18,135.3 203.18,135.98 202.64,136.52 202.64,141.82 202.97,142.15 VRAM2500.K5
FBA_CMD28: length 22.2
  BOTTOM w0.14: U2000.Y31 211.68,123.9 211.68,128.28 210.5,129.46 v1(210.5,134.47) 210.5,136.3 207.95,138.85 207.95,140.37 207.59,140.73 207.01,140.73 206.77,140.97 205.16,140.97 VRAM2500.L3
FBA_CMD29: length 21
  BOTTOM w0.14: VRAM2500.J2 206.01,143.38 206.53,143.38 207.09,142.81 207.24,142.81 208.57,141.49 208.57,141.2 R2063.1 211.23,138.54 v1(211.23,133.35) 211.23,129.58 212.05,128.75 212.05,126.27 212.08,126.24 U2000.Y34
FBA_CMD30: length 25.5
  TOP w0.14: v1(205.18,142.55) 205.97,141.76 R2001.2
  IN3 w0.089: v1(212.51,126.3) 212.99,126.78 212.99,127.57 212.93,127.63 212.93,131.74 209.54,135.13 209.54,141.66 208.54,142.66 206.89,142.66 206.21,141.98 205.75,141.98 v1(205.18,142.55)
  BOTTOM w0.14: VRAM2500.J3 v1(205.18,142.55) ; U2000.Y33 212.46,125.48 212.46,126.25 v1(212.51,126.3)
FBA_CMD31: length 26.6
  BOTTOM w0.14: U2000.V31 213.61,123.67 213.61,123.92 213.38,124.15 213.38,127.19 212.71,127.86 212.71,128.91 211.95,129.66 v1(211.95,131.94) 211.95,140.47 208.29,144.14 205.19,144.14 VRAM2500.G3
FBA_DBI0: length 19.4
  IN4 w0.089: v1(217.54,122.24) 217.93,122.63 217.93,123.22 217.67,123.49 217.33,123.49 217.09,123.73 217.09,125.68 217.04,125.73 217.04,127.3 216.51,127.83 216.51,132.72 215.36,133.86 215.36,136.19 215.87,136.69 215.87,138.07 v1(216.34,138.54)
  BOTTOM w0.14: v1(216.34,138.54) 216.75,138.95 VRAM2501.D2 ; v1(217.54,122.24) 217.09,122.7 U2000.P30
FBA_DBI1: length 18.5
  IN4 w0.089: v1(225.98,138.52) 225.98,138.43 226.81,137.6 227.28,137.6 227.51,137.37 227.51,130.58 224.85,127.92 224.85,127.29 224.17,126.6 224.17,126.15 223.78,125.76 223.78,124.5 223.36,124.08 v1(223.36,123.85)
  BOTTOM w0.14: VRAM2501.D13 225.58,138.92 v1(225.98,138.52) ; v1(223.36,123.85) 223.43,123.85 U2000.F31
FBA_DBI2: length 26.1
  IN1 w0.089: v1(225.98,146.55) 226.48,146.05 226.48,144.02 226.11,143.65 225.63,143.65 225.45,143.83 223.93,143.83 223.14,143.04 223.14,142.18 222.59,141.62 222.59,134.81 225.01,132.39 225.01,128.03 v1(224.33,127.35)
  BOTTOM w0.14: VRAM2501.P13 v1(225.98,146.55) ; U2000.F34 223.78,126.51 224.33,127.06 v1(224.33,127.35)
FBA_DBI3: length 27.5
  IN1 w0.089: v1(216.38,146.59) 216.35,146.62 214.93,146.62 214.43,146.12 214.43,142.99 213.93,142.48 213.93,131.11 216.63,128.41 217.25,128.41 218.35,127.31 218.35,127.3 218.38,127.27 218.38,126.97 218.83,126.51 218.83,125.18 v1(218.35,124.7)
  BOTTOM w0.14: v1(218.35,124.7) 218.38,124.7 U2000.M32 ; v1(216.38,146.59) 216.42,146.59 VRAM2501.P2
FBA_DBI4: length 18.7
  IN4 w0.089: v1(208.34,123.08) 208.76,123.5 208.76,124.18 209.19,124.61 209.19,127.47 208.93,127.73 208.93,133.27 206.29,135.91 206.29,137.4 v1(205.18,138.5)
  BOTTOM w0.14: VRAM2500.P2 205.18,138.55 v1(205.18,138.5) ; v1(208.34,123.08) 208.36,123.08 U2000.AD31
FBA_DBI5: length 21.3
  IN4 w0.089: v1(203.29,122.22) 203.08,122.42 203.08,123.19 202.93,123.34 202.75,123.52 202.34,123.52 202.1,123.76 202.1,124.96 201.27,125.78 201.27,127.37 200.84,127.8 200.84,129.66 195.49,135.02 195.49,135.97 196.02,136.5 196.02,137.48 196.35,137.81 v1(196.35,138.55)
  BOTTOM w0.14: VRAM2500.P13 196.76,138.95 v1(196.35,138.55) ; v1(203.29,122.22) 203.29,122.21 U2000.AL29
FBA_DBI6: length 28.8
  IN1 w0.089: v1(201.67,124.71) 201.25,125.13 201.25,131.29 197.54,135 196.34,135 194.76,136.57 194.76,147.01 195.21,147.45 196.28,147.45 v1(196.38,147.35)
  BOTTOM w0.14: VRAM2500.D13 v1(196.38,147.35) ; U2000.AM32 v1(201.67,124.71)
FBA_DBI7: length 24.5
  IN1 w0.089: v1(207.47,126.36) 207.03,126.8 207.03,127.13 208.61,128.71 208.61,145.66 208.27,146 206.3,146 205.98,146.32 v1(205.98,146.55)
  BOTTOM w0.14: VRAM2500.D2 v1(205.98,146.55) ; U2000.AF34 207.08,125.97 207.47,126.36 v1(207.47,126.36)
FBA_DEBUG0: length 8.5
  TOP w0.127: TP2000.1 v1(217.76,130.88)
  BOTTOM w0.102: 216.04,126.63 215.72,126.31 215.72,125.53 215.94,125.31 215.94,124.96 216.14,124.76 216.14,124.76 216.28,124.62 U2000.R32
  BOTTOM w0.127: v1(217.76,130.88) 217.76,130.11 216.04,128.39 216.04,126.63
FBA_DEBUG1: length 7.5
  TOP w0.127: v1(210.01,124.7) 209.66,125.04 209.66,127 TP2001.1
  BOTTOM w0.114: v1(210.01,124.7) 209.61,124.3 U2000.AC32
FBA_EDC0: length 17.1
  IN4 w0.089: v1(216.35,137.76) 216.35,136.53 215.81,136 215.81,134.05 216.96,132.9 216.96,128.06 217.93,127.09 217.93,123.67 218.35,123.25 v1(218.35,123.1)
  BOTTOM w0.14: VRAM2501.C2 216.73,138.15 v1(216.35,137.76) ; U2000.M31 218.75,123.5 v1(218.35,123.1)
FBA_EDC1: length 17.9
  IN4 w0.089: v1(225.98,137.78) 226.49,137.27 226.49,130.33 223.7,127.54 223.7,126.32 223.46,126.07 223.16,126.07 222.84,125.75 222.84,125.06 222.94,124.96 222.94,123.54 v1(222.5,123.1)
  BOTTOM w0.14: VRAM2501.C13 225.61,138.15 v1(225.98,137.78) ; v1(222.5,123.1) 222.9,123.5 U2000.G31
FBA_EDC2: length 26.2
  IN1 w0.089: v1(225.18,147.35) 227.08,147.35 227.42,147.01 227.42,140.58 227.15,140.3 226.81,140.3 226.46,139.95 226.46,135.67 225.71,134.92 225.71,127.94 225.41,127.64 v1(225.41,126.75)
  BOTTOM w0.14: v1(225.41,126.75) 225.39,126.75 224.98,126.35 224.98,125.5 U2000.E33 ; VRAM2501.R13 v1(225.18,147.35)
FBA_EDC3: length 28
  IN1 w0.089: v1(216.36,147.36) 216.2,147.52 214.47,147.52 213.98,147.04 213.98,143.18 213.48,142.67 213.48,130.92 216.58,127.81 217.24,127.81 217.92,127.13 217.92,126.49 217.91,126.48 217.91,125.94 v1(218.35,125.5)
  BOTTOM w0.14: VRAM2501.R2 216.39,147.36 v1(216.36,147.36) ; U2000.M33 218.38,125.5 v1(218.35,125.5)
FBA_EDC4: length 17.4
  IN4 w0.089: v1(207.51,123.9) 207.51,124.1 207.91,124.51 207.91,124.88 208.11,125.08 208.64,125.08 208.77,125.22 208.77,127.3 208.48,127.59 208.48,133.08 205.84,135.73 205.84,137.08 v1(205.16,137.75)
  BOTTOM w0.14: U2000.AE31 207.53,123.9 v1(207.51,123.9) ; v1(205.16,137.75) 205.56,138.15 VRAM2500.R2
FBA_EDC5: length 18.7
  IN4 w0.089: v1(203.39,123.9) 203.39,125.61 202.98,126.02 202.98,127.87 201.73,129.12 201.73,130.05 196.69,135.1 196.69,137.26 v1(197.18,137.75)
  BOTTOM w0.14: U2000.AK30 203.39,122.99 v1(203.39,123.9) ; VRAM2500.R13 v1(197.18,137.75)
FBA_EDC6: length 30.6
  IN1 w0.089: v1(197.18,148.15) 195.87,148.15 195.69,148.33 195.17,148.33 194.93,148.09 194.93,147.78 194.33,147.19 194.33,136.35 196.13,134.55 197.3,134.55 200.53,131.33 200.53,127.42 200.42,127.32 200.42,125.99 v1(200.05,125.63)
  BOTTOM w0.14: VRAM2500.C13 v1(197.18,148.15) ; U2000.AN33 200.75,125.63 v1(200.05,125.63)
FBA_EDC7: length 27.4
  IN1 w0.089: v1(207.5,124.68) 207.5,124.85 207.93,125.28 207.93,127.27 209.04,128.38 209.04,146.55 207.96,147.63 206.5,147.63 v1(205.98,148.15)
  BOTTOM w0.14: VRAM2500.C2 v1(205.98,148.15) ; U2000.AF33 v1(207.5,124.68)
FBA_PLL_AVDD: length 53.3
  TOP w0.381: v1(222.58,111.4) 221.61,111.4 221.3,111.09 C2105.2
  TOP w0.457: C2056.2 220.27,118.47 220.68,118.89 v1(220.68,118.84)
  TOP w0.508: C2064.1 215.75,118.97 215.17,119.56 v1(215.17,119.61) ; v1(200.26,121.3) 199.88,121.3 199.04,122.14 199.04,129.3 v1(196.46,131.88) 195.65,132.69 L2001.1 194.71,132.69 194.57,132.83 C2008.2
  IN2 w0.457: v1(222.58,111.4) 221.59,111.4 221.14,111.85 221.14,115.28 220.68,115.74 v1(220.68,118.84) 220.55,118.96 215.82,118.96 v1(215.17,119.61) 214.67,119.61 213.61,118.55 210.85,118.55 210.41,118.99 207.33,118.99 206.75,119.57 206.03,119.57 205.14,120.45 200.98,120.45 200.26,121.17 v1(200.26,121.3)
  BOTTOM w0.356: v1(220.68,118.84) 220.68,119.95 U2000.K27 ; v1(222.58,111.4) 222.58,111.42 222.2,111.8 U2000.H17
  BOTTOM w0.381: U2000.U27 v1(215.17,119.61)
FBA_VREFC: length 56
  TOP w0.406: v1(195.2,142.77) 194.74,142.77 v1(194.58,142.93) 194.34,143.17 C2515.1
  IN4 w0.406: v1(195.2,142.77) 194.22,143.75 194.22,149.82 197.77,153.38 203.87,153.38 204.78,152.47 211.46,152.47 212.25,153.25 214.28,153.25 215.23,152.3 219.04,152.3 220.38,150.97 226.73,150.97 228.12,149.57 228.12,143.71 v1(226.87,142.46)
  BOTTOM w0.406: v1(195.2,142.77) 195.22,142.79 195.82,142.79 VRAM2500.J14 ; VRAM2501.J14 v1(226.87,142.46)
FBB_CMD0: length 24.4
  IN3 w0.089: v1(225.1,108.86) 225.52,108.44 226.2,108.44 226.34,108.58 228.54,108.58 235.97,101.15 237.49,101.15 238.15,100.49 238.15,100.22 238.84,99.52 239.69,99.52 240.36,98.84 242.48,98.84 242.93,99.29 v1(242.93,100.14)
  BOTTOM w0.14: U2000.D13 225.1,108.83 v1(225.1,108.86) ; VRAM2503.G12 v1(242.93,100.14)
FBB_CMD1: length 24
  IN3 w0.089: v1(243.74,101.74) 243.74,101.84 242.59,102.99 236.05,102.99 229.73,109.3 227.03,109.3 226.98,109.25 226.5,109.25 226.05,109.7 v1(224.26,109.7)
  BOTTOM w0.14: U2000.E14 224.28,109.7 v1(224.26,109.7) ; v1(243.74,101.74) 243.74,101.75 VRAM2503.H10
FBB_CMD2: length 25.3
  IN3 w0.089: v1(223.41,109.74) 223.98,109.16 224.42,109.16 224.61,109.35 226.03,109.35 226.48,108.9 229.18,108.9 235.82,102.26 242.29,102.26 243.59,100.97 v1(243.71,100.97)
  BOTTOM w0.14: U2000.F14 223.83,109.31 v1(223.41,109.74) ; v1(243.71,100.97) 243.76,100.97 VRAM2503.H11
FBB_CMD3: length 21.8
  BOTTOM w0.14: U2000.A12 230.2,107.6 v1(232.45,105.35) 234.31,103.49 245.38,103.49 245.79,103.08 245.79,102.75 246.12,102.42 246.12,101.73 VRAM2503.K11
FBB_CMD4: length 20.9
  BOTTOM w0.14: U2000.B12 227.48,107.2 228.81,107.2 v1(231.81,104.2) 232.65,104.2 234.03,102.82 245.05,102.82 VRAM2503.K10
FBB_CMD5: length 26.2
  BOTTOM w0.14: VRAM2503.L12 246.91,100.92 246.91,103.64 246.33,104.22 234.54,104.22 v1(232.04,106.72) 230.4,108.35 227.79,108.35 227.26,108.88 226.69,108.88 U2000.C14
FBB_CMD6: length 22
  BOTTOM w0.14: U2000.B14 227.33,109.3 227.73,108.9 228.8,108.9 228.8,108.9 230.81,108.9 234.77,104.94 v1(235.24,104.94) 244.87,104.94 245.31,105.38 245.31,106.52 245.33,106.54 VRAM2503.K4
FBB_CMD7: length 27.4
  IN3 w0.089: v1(245.87,105.57) 244.02,103.71 236.28,103.71 230.09,109.9 227.16,109.9 226.91,110.14 226.53,110.14 226.05,110.14 225.89,109.98 224.81,109.98 224.38,110.41 223.45,110.41 v1(223.37,110.49)
  BOTTOM w0.14: v1(223.37,110.49) 223.37,110.49 U2000.G15 ; v1(245.87,105.57) 245.73,105.72 VRAM2503.K5
FBB_CMD8: length 25.5
  IN3 w0.089: v1(223.9,110.84) 224.29,110.84 224.4,110.95 225.31,110.95 225.59,110.66 227.32,110.66 227.48,110.5 228.03,110.5 228.43,110.9 230.99,110.9 236.73,105.16 243.5,105.16 244.53,106.19 v1(244.53,106.54)
  BOTTOM w0.14: U2000.F15 223.9,110.17 v1(223.9,110.84) ; VRAM2503.J4 v1(244.53,106.54)
FBB_CMD9: length 24.2
  IN3 w0.089: v1(225.08,110.52) 225.2,110.4 227.08,110.4 227.28,110.2 228.33,110.2 228.63,110.5 230.44,110.5 236.5,104.44 243.73,104.44 v1(244.83,105.54)
  BOTTOM w0.14: U2000.E15 225.08,110.5 v1(225.08,110.52) ; VRAM2503.J5 244.83,106.04 v1(244.83,105.54)
FBB_CMD10: length 21.9
  IN3 w0.089: v1(243.73,106.54) 243.14,105.95 238.48,105.95 236.82,107.61 236.82,108.01 235.85,108.99 v1(235.85,109.95)
  BOTTOM w0.14: v1(235.85,109.95) 234.01,109.95 233.46,110.5 228.07,110.5 228.07,110.5 225.88,110.5 U2000.D15 ; VRAM2503.H4 v1(243.73,106.54)
FBB_CMD11: length 18
  BOTTOM w0.14: U2000.A14 231.43,109.3 233.91,106.82 v1(235.24,106.82) 237.22,106.82 238.38,105.66 243.65,105.66 VRAM2503.H5
FBB_CMD12: length 24.8
  IN4 w0.089: v1(226.68,109.7) 227.29,109.7 228.43,110.84 233.57,110.84 235.09,112.36 242.27,112.36 244.23,110.4 244.23,107.79 v1(243.73,107.29)
  BOTTOM w0.14: U2000.D14 225.88,109.7 v1(226.68,109.7) ; VRAM2503.G3 243.33,107.7 v1(243.73,107.29)
FBB_CMD13: length 22.2
  BOTTOM w0.14: U2000.A15 232.87,110.1 v1(233.24,109.73) 233.7,109.27 236.12,109.27 236.52,109.67 236.52,110.47 237.84,111.79 R2068.1 244.49,111.34 245.3,110.53 245.3,108.91 VRAM2503.J2
FBB_CMD14: length 22.2
  BOTTOM w0.14: U2000.B15 227.48,109.7 232.05,109.7 233.26,108.5 v1(234.35,108.5) R2069.2 236.3,108.5 237.19,109.39 237.19,110.19 237.75,110.75 243.76,110.75 244.27,110.24 244.27,109.78 244.52,109.53 244.52,108.15 VRAM2503.J3
FBB_CMD15: length 24.8
  IN4 w0.089: v1(226.68,111.38) 226.69,111.39 233.49,111.39 235.01,112.91 242.53,112.91 245.9,109.54 245.9,107.52 v1(246.13,107.29)
  BOTTOM w0.14: U2000.C17 226.28,111.78 v1(226.68,111.38) ; VRAM2503.L3 246.53,107.69 v1(246.13,107.29)
FBB_CMD16: length 27.2
  IN3 w0.089: v1(225.9,113.04) 226.21,113.36 230.66,113.36 233.9,116.59 233.9,121.54 236.83,124.48 242.23,124.48 243.57,125.82 v1(243.73,125.82)
  BOTTOM w0.14: VRAM2502.L12 v1(243.73,125.82) ; v1(225.9,113.04) 225.9,113.02 U2000.D18
FBB_CMD17: length 28.1
  IN3 w0.089: v1(243.74,125.01) 242.48,123.76 237.06,123.76 234.57,121.26 234.57,116.21 233.91,115.55 232.85,114.49 232.58,114.49 231.09,113 227.06,113 226.65,112.59 225.61,112.59 225.17,113.02 v1(225.05,113.02)
  BOTTOM w0.14: v1(225.05,113.02) 225.05,112.97 U2000.E18 ; VRAM2502.K10 v1(243.74,125.01)
FBB_CMD18: length 30.4
  IN3 w0.089: v1(224.15,113.13) 224.15,112.92 224.46,112.61 225.3,112.61 225.53,112.39 226.91,112.39 227.09,112.57 231.5,112.57 232.73,113.8 233.19,113.8 235.24,115.86 235.24,120.98 237.29,123.03 242.71,123.03 244.53,124.85 v1(244.53,125.05)
  BOTTOM w0.14: v1(224.15,113.13) 223.83,112.82 U2000.F18 ; v1(244.53,125.05) 244.49,125.05 VRAM2502.K11
FBB_CMD19: length 25.1
  BOTTOM w0.14: U2000.A20 228.25,114.67 230.68,114.67 234.41,118.4 v1(234.41,119.69) 234.41,121.66 236.57,123.82 244.12,123.82 244.28,123.66 244.97,123.66 245.34,124.02 245.34,125.02 VRAM2502.H11
FBB_CMD20: length 25.8
  BOTTOM w0.14: U2000.B20 227.46,113.92 228.13,113.92 228.51,114.3 231.26,114.3 235.08,118.12 v1(235.08,118.44) 235.08,121.38 236.85,123.15 243.9,123.15 244.03,123.02 245.08,123.02 245.73,123.67 VRAM2502.H10
FBB_CMD21: length 29.2
  BOTTOM w0.14: U2000.C18 226.67,112.99 227.22,112.99 227.51,113.28 229.51,113.28 229.85,113.62 231.53,113.62 235.76,117.84 v1(235.76,119.82) 235.76,121.1 237.13,122.47 245.25,122.47 246.13,123.35 246.13,125.82 VRAM2502.G12
FBB_CMD22: length 25.8
  BOTTOM w0.14: U2000.B18 227.22,112.6 227.61,112.99 231.85,112.99 236.43,117.56 v1(236.43,117.89) 236.43,120.82 237.41,121.8 244.78,121.8 245.31,121.27 245.31,120.23 VRAM2502.H4
FBB_CMD23: length 30.3
  IN4 w0.089: v1(222.58,112.18) 223.44,112.18 223.83,111.79 225.53,111.79 225.71,111.98 232.53,111.98 234.92,114.37 243.59,114.37 245.45,116.22 245.45,118.81 246.08,119.45 v1(246.08,120.21)
  BOTTOM w0.14: U2000.G18 222.98,112.58 v1(222.58,112.18) ; VRAM2502.H5 245.73,120.61 246.08,120.26 v1(246.08,120.21)
FBB_CMD24: length 28.1
  IN4 w0.089: v1(223.41,113.02) 223.72,112.71 224.7,112.71 224.79,112.61 225.34,112.61 225.53,112.42 226.18,112.42 226.2,112.44 229.8,112.44 230.02,112.65 232.58,112.65 234.74,114.81 243.1,114.81 244.46,116.17 244.46,119.3 v1(244.57,119.41)
  BOTTOM w0.14: v1(244.57,119.41) 244.93,119.77 VRAM2502.J4 ; U2000.G17 223.41,112.23 v1(223.41,113.02)
FBB_CMD25: length 29.2
  IN3 w0.089: v1(244.55,121.14) 244.1,121.58 237.75,121.58 236.59,120.43 236.59,115.03 233.92,112.36 233.06,112.36 232.5,111.79 224.7,111.79 v1(224.27,112.22)
  BOTTOM w0.14: v1(244.55,121.14) 244.93,120.76 VRAM2502.J5 ; v1(224.27,112.22) 224.25,112.22 U2000.F17
FBB_CMD26: length 28.3
  IN3 w0.089: v1(225.08,111.38) 225.28,111.38 225.71,110.94 226.97,110.94 227.43,111.4 233.98,111.4 237.26,114.68 237.26,120.15 237.97,120.86 243.86,120.86 v1(244.52,120.2)
  BOTTOM w0.14: v1(225.08,111.38) 225.08,111.35 U2000.D16 ; VRAM2502.K4 244.52,120.2 v1(244.52,120.2)
FBB_CMD27: length 22
  BOTTOM w0.14: U2000.A18 232.42,112.6 237.1,117.29 v1(237.1,119.16) 237.1,120.55 237.8,121.24 243.5,121.24 VRAM2502.K5
FBB_CMD28: length 22.1
  BOTTOM w0.14: U2000.D17 225.88,112.2 232.97,112.2 233.39,112.62 v1(233.62,112.62) 236.15,115.15 241.66,115.15 242.64,116.14 242.64,116.72 242.92,117 242.92,118.61 VRAM2502.L3
FBB_CMD29: length 21
  BOTTOM w0.14: VRAM2502.J2 244.52,117.81 244.52,116.47 244.37,116.31 244.37,115.65 244,115.28 R2066.1 243.46,114.48 236.47,114.48 v1(235.49,113.5) 233.93,111.95 233.62,111.95 233.47,111.8 U2000.A17
FBB_CMD30: length 24.6
  BOTTOM w0.14: VRAM2502.J3 245.36,118.59 245.36,117.18 245.46,117.07 245.46,116.12 245.12,115.78 R2067.2 245.12,114.26 244.67,113.81 236.78,113.81 v1(234.22,111.25) 228.18,111.25 228.03,111.4 227.48,111.4 U2000.B17
FBB_CMD31: length 32.3
  IN3 w0.089: v1(225.08,112.2) 225.14,112.14 232.04,112.14 232.97,113.08 233.62,113.08 235.91,115.38 235.91,120.7 237.52,122.31 244.65,122.31 245.36,121.6 245.36,120.25 246.12,119.49 v1(246.12,118.66)
  BOTTOM w0.14: U2000.E17 v1(225.08,112.2) ; v1(246.12,118.66) 246.48,119.02 VRAM2502.G3
FBB_DBI0: length 18.9
  IN4 w0.089: v1(224.26,106.37) 224.66,106.78 225.24,106.78 225.74,107.29 228.06,107.29 228.7,107.93 234.91,107.93 236.43,109.45 239.97,109.45 v1(240.48,108.94)
  BOTTOM w0.14: v1(240.48,108.94) 240.88,108.54 VRAM2503.D2 ; U2000.E11 v1(224.26,106.37)
FBB_DBI1: length 18.3
  IN4 w0.089: v1(225.02,99.72) 226.06,99.72 226.51,99.27 227.07,99.27 227.21,99.4 235.41,99.4 236.87,97.94 238.87,97.94 239.22,98.28 239.22,98.56 240.02,99.36 v1(240.52,99.36)
  BOTTOM w0.14: VRAM2503.D13 240.89,99.74 v1(240.52,99.36) ; U2000.E3 224.64,100.1 v1(225.02,99.72)
FBB_DBI2: length 23.2
  IN1 w0.089: v1(229.72,98.93) 229.73,98.94 236.68,98.94 237.78,97.84 247.14,97.84 247.57,98.28 247.57,98.46 247.81,98.7 248.07,98.7 248.48,99.11 v1(248.48,99.34)
  BOTTOM w0.14: VRAM2503.P13 248.88,99.74 v1(248.48,99.34) ; v1(229.72,98.93) 229.72,99.19 229.19,99.72 228.43,99.72 228.05,100.1 U2000.A3
FBB_DBI3: length 29.3
  IN1 w0.089: v1(249.33,108.94) 248.86,109.41 248.86,110.43 247.58,111.71 235.8,111.71 230.45,106.36 229.64,106.36 228.93,105.65 228.3,105.65 227.77,105.11 226.27,105.11 v1(225.85,105.53)
  BOTTOM w0.14: v1(225.85,105.53) U2000.C9 ; VRAM2503.P2 v1(249.33,108.94)
FBB_DBI4: length 20.2
  IN4 w0.089: v1(224.26,116.37) 224.68,115.95 226.1,115.95 226.95,115.09 231.78,115.09 234.48,117.79 240.46,117.79 241.26,118.59 241.26,118.61 v1(241.28,118.61)
  BOTTOM w0.14: U2000.F23 224.25,116.37 v1(224.26,116.37) ; VRAM2502.P2 241.28,118.57 v1(241.28,118.61)
FBB_DBI5: length 23.3
  IN4 w0.089: v1(223.4,120.53) 223.4,120.82 223.84,121.25 223.84,121.56 224.07,121.79 226.42,121.79 228.39,123.76 228.6,123.76 229.15,124.31 229.15,124.45 233.64,128.94 239.75,128.94 240.02,128.66 240.02,127.92 v1(240.53,127.42)
  BOTTOM w0.14: VRAM2502.P13 v1(240.53,127.42) ; U2000.F27 v1(223.4,120.53)
FBB_DBI6: length 26.4
  IN1 w0.089: v1(248.48,127.42) 248.25,127.42 247.5,128.16 247.5,128.69 247.24,128.96 238.82,128.96 238.25,128.38 234.88,128.38 229.71,123.21 226.86,123.21 v1(226.68,123.02)
  BOTTOM w0.14: v1(248.48,127.42) 248.88,127.01 VRAM2502.D13 ; v1(226.68,123.02) 226.68,123 U2000.C30
FBB_DBI7: length 23.3
  IN1 w0.089: v1(248.51,118.64) 247.96,119.18 246.26,119.18 244.76,120.68 237.04,120.68 235.67,119.31 230.13,119.31 v1(228.9,118.08)
  BOTTOM w0.14: VRAM2502.D2 v1(248.51,118.64) ; v1(228.9,118.08) 228.42,117.6 U2000.A24
FBB_DEBUG0: length 5.8
  TOP w0.127: TP2003.1 228.99,107.57 227.13,107.57 v1(226.68,108.03)
  BOTTOM w0.114: v1(226.68,108.03) 226.68,108 U2000.C12
FBB_DEBUG1: length 6.2
  TOP w0.114: v1(226.68,113.9) 227.78,113.9 228.56,113.12 TP2002.1
  BOTTOM w0.114: U2000.C20 v1(226.68,113.9)
FBB_EDC0: length 16.9
  IN4 w0.089: v1(237.87,109) 237.63,108.76 236.34,108.76 235.05,107.47 228.86,107.47 228.24,106.85 225.77,106.85 225.26,106.34 v1(225.09,106.34)
  BOTTOM w0.14: VRAM2503.C2 239.75,108.92 237.94,108.92 v1(237.87,109) ; U2000.D10 v1(225.09,106.34)
FBB_EDC1: length 17.1
  IN4 w0.089: v1(239.73,100.14) 238.42,98.83 236.93,98.83 235.68,100.08 226.29,100.08 v1(225.87,100.5)
  BOTTOM w0.14: U2000.D5 225.87,101.41 v1(225.87,100.5) ; VRAM2503.C13 v1(239.73,100.14)
FBB_EDC2: length 27.3
  IN1 w0.089: v1(226.67,99.68) 226.88,99.47 226.88,98.8 227.39,98.29 227.78,98.29 227.97,98.48 229.4,98.48 229.54,98.35 236.68,98.35 237.64,97.39 247.94,97.39 248.65,98.1 248.65,98.65 249.15,99.14 249.15,100 v1(249.28,100.14)
  BOTTOM w0.102: v1(226.67,99.68) 226.28,100.08 U2000.C3
  BOTTOM w0.14: v1(249.28,100.14) 249.68,99.74 VRAM2503.R13
FBB_EDC3: length 29.3
  IN1 w0.089: v1(227.48,105.53) 227.9,105.94 228.69,105.94 229.68,106.93 230.39,106.93 235.62,112.16 247.98,112.16 249.5,110.63 249.5,110.21 249.84,109.87 249.84,108.43 v1(250.13,108.14)
  BOTTOM w0.14: v1(227.48,105.53) 227.48,105.5 U2000.B9 ; VRAM2503.R2 v1(250.13,108.14)
FBB_EDC4: length 18.7
  IN4 w0.089: v1(240.48,118.61) 240.08,118.22 234.32,118.22 231.73,115.63 229.44,115.63 229.12,115.95 226.48,115.95 226.29,116.14 226.29,116.59 226.1,116.78 225.49,116.78 v1(225.08,116.37)
  BOTTOM w0.14: U2000.E23 225.08,116.4 v1(225.08,116.37) ; v1(240.48,118.61) 240.48,118.57 VRAM2502.R2
FBB_EDC5: length 22
  IN4 w0.089: v1(224.27,121.35) 225.23,121.35 225.61,120.97 226.9,120.97 227.07,121.14 227.07,121.59 227.27,121.79 227.64,121.79 227.99,122.14 227.99,122.66 229.48,124.14 230.11,124.14 230.34,124.37 230.34,124.98 233.85,128.49 237.88,128.49 238.45,127.92 239.11,127.92 239.33,127.7 239.33,127.02 v1(239.73,126.61)
  BOTTOM w0.14: U2000.E28 224.28,121.35 v1(224.27,121.35) ; VRAM2502.R13 v1(239.73,126.61)
FBB_EDC6: length 27.9
  IN1 w0.089: v1(249.38,127.42) 249.38,128.16 249.35,128.19 249.35,129.06 248.48,129.93 238.33,129.93 237.66,129.26 234.58,129.26 v1(229.91,124.59)
  BOTTOM w0.14: VRAM2502.C13 249.73,127.06 v1(249.38,127.42) ; U2000.B30 228.02,123.54 228.85,123.54 v1(229.91,124.59)
FBB_EDC7: length 25
  IN1 w0.089: v1(228.32,116.38) 228.74,115.96 229.14,115.96 229.75,115.35 231.67,115.35 232.26,115.95 249.2,115.95 249.42,116.17 249.42,116.92 250.13,117.63 v1(250.13,117.81)
  BOTTOM w0.14: VRAM2502.C2 v1(250.13,117.81) ; U2000.A23 227.9,116.8 v1(228.32,116.38)
FBB_VREFC: length 58.3
  TOP w0.508: C2535.1 244.79,128.03 v1(244.79,128.33)
  IN4 w0.406: v1(244.79,128.33) 244.79,128.81 245.24,129.26 251.05,129.26 251.66,128.64 251.66,119.75 252.56,118.86 252.56,98.57 251.11,97.12 246.09,97.12 v1(244.93,98.28)
  BOTTOM w0.406: VRAM2503.J14 244.93,98.28 v1(244.93,98.28) ; VRAM2502.J14 244.9,127.84 244.9,128.22 244.8,128.33 244.8,128.33 v1(244.79,128.33)
  BOTTOM w0.508: R2523.2 R2525.2 238.67,94.17 238.67,94.17 R2524.2 C2558.1 241.21,95.06 v1(241.21,95.09) 241.74,95.09 244.93,98.28
FBVDD_EN: length 111.6
  IN2 w0.089: v1(233.29,149.61) 232.14,148.45 232.14,142.38 234.19,140.32 246.59,140.32 249.41,137.5 249.41,132.17 252.18,129.4 252.18,122.85 253.17,121.86 253.17,116.22 254.03,115.36 254.03,94.57 251.81,92.35 249.13,92.35 248.55,91.76 248.55,91.3 246.09,88.84 241.46,88.84 240.92,89.38 231.28,89.38 230.84,88.94 229.7,88.94 229.01,88.25 227.38,88.25 227.22,88.08 225.46,88.08 225.23,87.85 225.23,87.01 224.9,86.68 v1(223.43,86.68)
  BOTTOM w0.114: U2005.4 222.17,85.82 222.42,86.07 222.87,86.07 223.43,86.63 v1(223.43,86.68)
  BOTTOM w0.254: PQ8003.2 233.08,150.63 233.08,149.82 v1(233.29,149.61) 233.71,149.19 PR8007.1
FBVDDQ_MEM: length 68.3
  BOTTOM w0.203: U2000.T33 215.45,125.12 215.45,126.69 v1(215.6,126.84) ; v1(223.58,148.15) v1(224.38,148.15)
  BOTTOM w0.229: 206.38,138.93 205.98,138.52 205.98,137.75 VRAM2500.T1 ; VRAM2500.B3 205.18,148.15 v1(205.18,147.35) ; VRAM2502.T1 239.73,117.82 v1(239.73,118.61)
  BOTTOM w0.254: v1(239.73,118.61) 239.33,119.01 VRAM2502.T3 ; U2000.B19 227.24,113.61 228.46,113.61 228.66,113.81 v1(229.04,113.81) ; VRAM2503.L11 v1(246.11,100.92)
  BOTTOM w0.305: VRAM2500.T12 v1(197.18,136.95) ; VRAM2500.P14 195.45,138.95 v1(195.36,139.04) ; VRAM2500.B3 v1(204.38,148.15) ; VRAM2500.D3 v1(205.18,147.35) ; v1(207.2,137.02) 206.71,137.02 VRAM2500.T1 ; v1(242.96,119.41) 242.56,119.02 VRAM2502.M3 ; v1(248.87,128.42) 248.87,127.88 VRAM2502.D14 ; v1(241.29,119.42) 240.93,119.06 VRAM2502.P3 ; VRAM2503.D1 240.94,109.35 v1(240.94,109.92) ; v1(207.31,140.27) 206.89,140.27 206.6,140.55 VRAM2500.M1 ; VRAM2500.P1 206.38,138.91 206.87,138.42 v1(207.2,138.42) ; v1(215.36,137.44) 215.44,137.35 215.98,137.35 VRAM2501.B1 ; VRAM2502.R10 v1(239.73,125.01) ; VRAM2503.B12 v1(238.93,100.14) ; VRAM2502.K3 v1(243.73,118.61) 243.33,118.22 VRAM2502.L2 VRAM2502.L1 243.27,117.36 243.27,116.57 v1(243.16,116.45) ; v1(243.69,119.41) 243.69,119.46 VRAM2502.L4 ; VRAM2502.N5 v1(242.11,120.23) ; VRAM2500.G11 198.36,144.55 v1(197.99,144.92) 197.58,145.33 VRAM2500.F12 ; U2000.AA30 211.27,122.7 v1(210.84,122.27) ; VRAM2503.P3 248.93,107.74 v1(249.33,108.14) ; VRAM2502.P1 240.77,117.42 240.07,116.71 v1(240.07,116.55) ; VRAM2501.E5 v1(218.78,140.15) ; VRAM2503.C10 v1(239.75,101.76) ; VRAM2501.B3 v1(217.17,137.76) ; VRAM2500.R10 v1(198.78,137.75) ; VRAM2500.T14 195.37,137.35 v1(195.36,137.36) ; VRAM2502.D12 248.58,126.57 v1(248.58,126.61) ; VRAM2500.N10 v1(198.78,139.35) VRAM2500.P11 ; v1(251.1,128.38) 250.53,127.82 VRAM2502.B14 ; VRAM2501.P3 v1(217.19,146.56) ; v1(203.56,137.77) VRAM2500.R5 ; v1(210.14,126.54) 210.3,126.39 210.3,125.23 U2000.AB33 ; v1(217.98,148.1) 217.98,148.1 217.98,148.1 217.58,148.5 VRAM2501.T3 ; v1(205.18,136.95) 205.18,136.95 VRAM2500.T3 ; v1(239.7,120.2) 240.11,120.61 VRAM2502.R5 ; VRAM2503.B1 239.31,109.36 v1(239.31,109.92) ; VRAM2503.D3 240.53,108.14 v1(240.49,108.14) ; VRAM2503.C5 v1(239.74,106.53) ; VRAM2502.M1 242.53,117.12 242.19,116.77 v1(242.19,116.44) ; VRAM2503.E5 v1(242.13,106.54) ; v1(204.38,138.5) 204.38,138.61 204.72,138.95 VRAM2500.P3 ; VRAM2501.P11 v1(224.38,147.35) VRAM2501.P12 ; VRAM2500.P12 v1(197.18,138.55) ; VRAM2503.T3 v1(250.13,107.34) ; VRAM2503.B3 v1(239.75,107.32) ; VRAM2501.D1 v1(215.38,138.95) ; VRAM2502.T1 239.33,117.39 238.72,116.78 v1(238.72,116.54) ; VRAM2502.B3 v1(250.13,119.42) ; VRAM2502.B12 v1(250.13,125.82) ; VRAM2501.D3 217.58,138.9 v1(217.19,138.51) ; VRAM2500.N5 v1(203.6,140.17) ; VRAM2501.C5 v1(218.78,137.75) ; v1(224.38,148.15) VRAM2501.T12 ; U2000.E16 v1(224.26,111.38) ; VRAM2501.B12 v1(224.39,136.96) ; VRAM2500.B12 v1(197.98,148.15)
  BOTTOM w0.381: U2000.T30 215.64,122.49 v1(215.64,122.1) ; U2000.B16 v1(227.73,110.95) ; v1(214.95,132.38) 214.95,132.66 R2064.1 ; v1(213.36,122.27) U2000.W30 ; v1(227.48,108.03) 227.48,108.05 U2000.B13 ; v1(212.91,125.72) 212.88,125.72 212.93,125.67 U2000.W33 ; v1(195.36,139.04) 194.33,139.04 193.26,140.11 C2566.1 ; R2069.1 v1(236.02,107.72) ; VRAM2501.F12 VRAM2501.G13 ; U2000.E19 225.08,113.85 v1(225.08,113.88) ; C2567.1 193.49,137.45 193.58,137.36 v1(195.36,137.36)
  BOTTOM w0.4: U2000.E13 224.44,108.69 v1(224.02,108.69) ; VRAM2502.T12 v1(238.93,126.61)
  BOTTOM w0.406: v1(248.87,128.42) 248.87,128.79 250.15,130.07 C2569.1
  vias: v1(195.31,144.34) v1(195.31,140.84) v1(195.36,148.79) v1(195.4,147.01) v1(195.35,145.22) v1(195.44,141.69) v1(196.38,144.15) v1(197.18,144.15) v1(197.18,141.75) v1(197.18,140.14) v1(197.98,147.35) v1(198.78,147.35) v1(199.59,145.76) v1(202.16,146.22) v1(202.62,147.47) v1(202.78,148.15) v1(204.36,145.77) v1(204.38,143.4) v1(205.18,141.75) v1(205.17,140.16) v1(206.01,144.93) v1(206.89,147.12) v1(206.95,145.55) v1(206.95,144.9) v1(207.31,141.31) v1(207.48,119.8) v1(208.38,119.8) v1(209.18,119.8) v1(210,119.8) v1(210.83,119.8) v1(211.29,119.22) v1(211.68,120.59) v1(211.68,119.8) v1(212.48,119.8) v1(212.84,119.22) v1(213.36,120.63) v1(213.42,119.76) v1(215.4,148.89) v1(215.42,147.07) v1(215.42,145.18) v1(215.38,141.76) v1(215.4,140.87) v1(215.83,120.58) v1(215.93,119.72) v1(216.4,144.93) v1(216.41,144.13) v1(216.69,119.72) v1(217.2,144.97) v1(217.16,141.73) v1(217.48,119.69) v1(217.99,143.34) v1(217.98,140.95) v1(218.35,119.69) v1(218.78,144.15) v1(219.58,148.15) v1(219.74,145.59) v1(221.65,117.02) v1(221.65,116.39) v1(221.65,115.75) v1(221.65,104.87) v1(221.77,114.71) v1(221.79,113.87) v1(221.75,113.03) v1(221.75,112.21) v1(221.8,110.53) v1(221.78,109.7) v1(221.8,108.88) v1(221.81,108.02) v1(221.78,107.21) v1(221.77,106.39) v1(221.77,105.53) v1(221.9,145) v1(222.71,145.68) v1(222.78,148.15) v1(223.58,140.17) v1(224.37,144.94) v1(224.38,140.95) v1(224.38,138.6) v1(225.18,141.75) v1(225.98,144.15) v1(226.93,148.71) v1(226.95,146.85) v1(226.95,145.35) v1(226.96,144.52) v1(226.93,141.63) v1(226.97,140.73) v1(226.99,138.94) v1(226.97,137.17) v1(229.63,141.01) v1(238.6,98.39) v1(239.43,139.41) v1(239.57,128.34) v1(240.49,126.62) v1(240.53,125.82) v1(240.56,100.92) v1(240.85,98.34) v1(241.33,125.01) v1(241.33,101.74) v1(241.39,128.35) v1(242.67,98.35) v1(242.74,109.91) v1(242.92,100.93) v1(242.93,107.34) v1(243.21,128.37) v1(243.63,109.92) v1(243.75,108.12) v1(243.73,100.14) v1(245.31,107.32) v1(245.34,126.61) v1(245.38,119.41) v1(245.35,100.17) v1(246.12,128.3) v1(246.12,100.15) v1(246.13,106.54) v1(246.43,98.4) v1(246.69,116.37) v1(246.93,118.65) v1(246.91,109.92) v1(246.92,99.34) v1(246.93,125.82) v1(246.94,108.95) v1(246.96,100.13) v1(247.06,128.44) v1(247.33,116.35) v1(247.73,124.21) v1(247.64,105.65) v1(248.28,121.65) v1(248.53,124.21) v1(248.45,102.56) v1(248.94,116.39) v1(248.94,104.86) v1(249.17,98.46) v1(249.33,125.01) v1(249.33,124.21) v1(249.33,120.22) v1(249.33,118.66) v1(249.32,109.73) v1(249.32,105.73) v1(249.33,100.94) v1(249.45,121.17) v1(250.13,121.01) v1(250.13,100.98) v1(250.13,101.74) v1(250.31,116.44) v1(250.25,98.45) v1(250.87,109.92) v4(232.19,135.82) v4(232.57,136.46) v4(232.57,135.19) v4(232.95,135.82) v4(233.33,136.46) v4(233.33,135.19) v4(233.71,135.82) v4(234.09,136.46) v4(234.09,135.19) v4(236.38,132.93) v4(236.76,132.3) v4(237.14,132.93) v4(237.52,132.3) v4(237.9,132.93) v4(238.28,132.3) v4(238.67,132.93) v4(239.05,132.3) v4(239.81,132.3)
FBVDDQ_SENSE: length 97.1
  TOP w0.254: v1(232.34,138.32) 232.67,138.65 PR8023.2
  IN2 w0.254: v1(223.43,97.59) 223.37,97.54 223.37,95.87 224.03,95.21 225.1,95.21 225.33,95.44 234.8,95.44 236.28,93.97 241.73,93.97 243.13,95.37 247.46,95.37 248.07,94.76 252.15,94.76 253.42,96.03 253.42,115.11 252.55,115.97 252.55,121.61 251.57,122.59 251.57,129.14 248.79,131.92 248.79,137.25 246.51,139.53 233.55,139.53 v1(232.34,138.32)
  BOTTOM w0.203: v1(223.43,97.59) 223.78,97.95 U2000.F1
FBVDDQ_VIN:
  vias: v1(237.22,153) v1(237.19,152.34) v1(237.24,153.63) v1(237.52,151.73) v1(237.88,152.29)
FLY_N: length 3.5
  TOP w0.203: 335.24,6.85 335.24,7.04 335.68,7.48 U3600.30
  TOP w0.254: C3613.1 334.99,5.49 v1(335.08,5.4) 335.19,5.5 335.19,6.8 335.24,6.85
FLY_P: length 2.7
  TOP w0.203: v1(334.78,7.08) 334.78,7.18 335.48,7.88 U3600.29
  TOP w0.254: C3613.2 334.58,6.58 334.58,6.87 v1(334.78,7.08)
FN_KEY_LED#: length 55.2
  TOP w0.114: Q9036.5 R18074.1 237.52,46.7 237.85,46.37 v1(238.28,46.37) 238.37,46.37 R6802.2
  IN1 w0.076: v1(238.28,46.37) 239.22,46.37 239.94,47.08 241.82,47.08 246.16,42.74 247.43,42.74 247.59,42.9 248.87,42.9 249.07,42.7 249.07,42.19 252.85,38.41 254.39,38.41 256.38,36.41 257.35,36.41 259.08,34.69 263.63,34.69 263.99,34.32 264.76,34.32 265.45,33.63 265.45,31.66 265.96,31.16 268.76,31.16 269.3,30.62 271.38,30.62 272.14,29.86 272.14,22.98 v1(271.61,22.44)
  BOTTOM w0.114: U6001.A10 271.17,22.89 v1(271.61,22.44)
FN_KEY_LED#_R: length 5.9
  TOP w0.114: R6820.1 237.01,48.35 238.15,47.22 R17964.1 237.73,47 237.25,47.48 R18074.2 236.4,47.48 236.13,47.21 v1(236.13,46.83) 236.51,46.44 Q9036.6
FORCEON_BL: length 307.7
  TOP w0.114: R18008.1 263.75,34.72 263.44,34.41 263.44,32.97 v1(263.15,32.68) ; U49.1 245.99,36.5 246.39,36.11 248.14,36.11 v1(248.32,36.29) 248.49,36.11 R17888.1 249.16,36.66 v1(249.16,36.67)
  IN1 w0.076: v1(267.9,22.39) 268.66,23.15 268.66,25.38 268.4,25.64 266.07,25.64 265.94,25.77 265.94,27.03 264.61,28.36 262.71,28.36 262.19,28.88 262.19,31.5 263.15,32.46 v1(263.15,32.68) 262.97,32.86 261.99,32.86 261.4,33.45 257.79,33.45 257.08,34.17 255.39,34.17 253.21,36.35 253.21,36.48 252.41,37.28 249.79,37.28 249.18,36.67 v1(249.16,36.67)
  IN2 w0.089: v1(208.93,11.01) 209.32,11.4 209.74,11.4 211.02,10.12 225.27,10.12 226.94,8.44 236.61,8.44 236.9,8.15 240.06,8.15 241.08,7.13 242.51,7.13 244.07,5.57 246.25,5.57 246.82,6.13 246.92,6.24 249.15,6.24 249.83,5.56 250.46,5.56 251.74,6.84 261.77,6.84 262.34,6.27 266.65,6.27 267.47,7.09 267.47,8.65 267.14,8.98 267.14,12.38 266.22,13.3 266.22,16.22 266.5,16.5 266.5,20.08 267.04,20.61 267.04,22.13 267.29,22.39 v1(267.9,22.39)
  IN4 w0.076: v1(72.04,47.59) 74.64,47.59 76.26,49.2 89.11,49.2 91.48,46.83 91.48,44.53 97.82,38.19 97.82,21.9 100.13,19.59 100.13,18.15 109.08,9.2 112.22,9.2 114.88,6.54 176.22,6.54 187.17,17.49 203.19,17.49 205.92,14.76 205.92,12.56 207.17,11.32 207.84,11.32 208.15,11.01 v1(208.93,11.01)
  BOTTOM w0.114: v1(72.04,47.59) 71.41,46.95 67.98,46.95 67.19,46.17 61.37,46.17 60.59,46.95 R3091.2
FOST1: length 74.7
  TOP w0.114: R7320.2 353.59,144.04 353.85,143.78 354.9,143.78 v1(355.07,143.96)
  IN4 w0.076: v1(342.42,90.64) 341.66,90.64 340.9,91.4 340.9,96.46 342.68,98.24 342.68,101.82 343.82,102.96 349.54,102.96 350.81,104.23 350.81,105.63 353.1,107.93 353.1,118.28 352.47,118.91 352.47,120.35 349.41,123.41 346.87,123.41 346.49,123.79 346.49,125.57 354.49,133.57 354.49,143.37 v1(355.07,143.96)
  BOTTOM w0.114: U8500.L7 342.43,90.65 v1(342.42,90.64)
FOST1_R: length 4.8
  TOP w0.114: R7320.1 R7324.1 351.87,142.94 351.97,142.84 352.13,142.68 352.56,142.68 352.6,142.64 353.4,142.64 v1(353.68,142.36) 352.96,141.64 U7112.C4
FOST2: length 52.7
  TOP w0.114: R7323.2 v1(341.54,130.27)
  IN1 w0.076: v1(341.54,130.27) 345.4,126.41 345.4,122.57 345.83,122.14 347.45,122.14 348.62,120.97 348.98,120.97 350.48,119.47 350.48,117.32 350.06,116.91 350.06,115.5 350.32,115.24 350.32,113.8 352.43,111.69 352.43,110.14 352.24,109.95 352.24,105.88 351.29,104.93 351.29,103.86 349.37,101.94 349.37,100.21 349.54,100.04 349.54,97.5 348.57,96.53 348.57,94.48 347.66,93.56 345.04,93.56 344.53,93.06 342.72,93.06 v1(341.7,92.04)
  BOTTOM w0.114: U8500.L8 341.93,92.27 v1(341.7,92.04)
FOST2_R: length 5.3
  TOP w0.114: U7113.C4 345.63,130.62 345.27,130.27 v1(344.96,130.27) 343.8,130.27 343.39,130.67 343.39,131.15 343.25,131.29 R7327.1 342.94,131.28 R7323.1
FPR_LOCK#: length 171.2
  IN2 w0.089: v1(253.7,73.93) 253.7,74.21 252.64,75.27 252.64,75.53 253.4,76.3 254.01,76.3 254.95,77.24 254.95,79.05 254.75,79.25 254.75,81.11 255.81,82.17 255.81,83.1 255.99,83.28 256.51,83.28 256.73,83.06 256.73,81.44 258.22,79.95 259.39,79.95 259.62,79.72 259.62,79.21 259.95,78.88 259.95,77.72 261.75,75.92 262.72,75.92 264.77,73.87 264.98,73.87 265.28,73.57 265.76,73.57 267.72,71.61 268.28,71.61 271.45,68.44 271.45,68.22 273.53,66.14 274.89,66.14 275.38,66.63 276.68,66.63 277.29,66.03 277.29,63.54 280.13,60.69 280.13,59.22 280.13,58.64 281,57.76 281,57.66 281.24,57.3 281.25,57.28 281.69,56.63 282.24,56.08 282.56,55.87 282.66,55.8 282.66,55.79 282.89,55.64 283.09,55.56 283.29,55.48 283.3,55.46 283.43,55.33 283.59,55.18 283.87,55.18 283.92,55.13 286.88,55.13 286.98,55.02 290.45,51.55 291.09,51.55 292.28,50.36 292.79,50.36 292.89,50.26 303.48,50.26 313.47,40.27 313.47,30.47 315.45,28.48 319.24,28.48 323.25,24.47 323.25,17.61 319.82,14.19 314.08,14.19 312.12,16.14 303.53,16.14 302.11,14.73 302.11,13.83 297.57,9.29 290.68,9.29 288.88,11.09 288.88,12.21 289.08,12.41 289.46,12.41 v1(289.47,12.41)
  BOTTOM w0.102: U9002.AV18 253.94,74.17 v1(253.7,73.93)
  BOTTOM w0.114: v1(289.47,12.41) v1(289.47,11.77) 289.47,11.52 290.35,10.63 R7203.2 290.61,10.63 290.8,10.82 ESD7200.4 292.19,10.82 292.47,10.55 292.47,9.76 292.2,9.49 CON7200.3
FPR_OFF#: length 162.4
  IN2 w0.089: v1(289.47,13.04) 288.7,12.28 288.7,11.01 290.61,9.11 297.85,9.11 302.29,13.55 302.29,14.57 303.68,15.97 312.05,15.97 314.02,13.99 319.88,13.99 324.26,18.38 324.26,23.84 319.44,28.66 315.53,28.66 313.65,30.54 313.65,40.43 303.62,50.46 292.94,50.46 292.85,50.55 292.39,50.55 291.21,51.73 290.53,51.73 286.96,55.3 283.99,55.3 283.94,55.35 283.66,55.35 283.59,55.42 283.43,55.59 283.39,55.63 283.13,55.73 282.98,55.8 282.76,55.94 282.36,56.21 281.82,56.74 281.41,57.37 281.39,57.39 281.19,57.69 281.19,57.83 280.31,58.71 280.31,59.15 280.31,60.76 277.46,63.61 277.46,66.1 276.76,66.81 275.13,66.81 274.88,66.56 274.25,66.56 273.68,67.13 273.31,67.13 272.8,67.13 271.63,68.3 271.63,68.52 268.35,71.79 267.79,71.79 265.83,73.75 265.35,73.75 265.06,74.04 264.85,74.04 262.79,76.09 261.83,76.09 260.13,77.79 260.13,78.96 259.8,79.28 259.8,80 259.49,80.3 v3(258.77,80.3)
  BOTTOM w0.102: v3(258.77,80.3) 258.53,80.07 258.53,78.32 257.6,77.38 257.6,77.2 257.29,76.89 257.29,76.66 256.9,76.27 U9002.BD20
  BOTTOM w0.114: CON7200.2 292.7,10.64 292.39,10.96 292.39,12.54 292.2,12.72 ESD7200.6 290.79,12.72 290.74,12.67 R7200.1 R7204.2 290.09,13.67 v1(289.47,13.04)
G5719_EN: length 4.8
  TOP w0.114: PR9507.2 204.63,84.32 204.64,84.31 PC9513.2 204.12,84.34 203.33,84.34 v1(202.94,83.95) 202.63,83.64 PU9502.1
G5719_LX:
  vias: v1(199.73,83.28)
G5719_PG: length 3.8
  TOP w0.114: PU9502.5 201.68,78.95 202.31,78.32 v1(202.6,78.32) 202.87,78.32 PR9506.2
G5719_VFB: length 3.9
  TOP w0.114: PR9509.2 204.76,82.37 203.99,81.59 PR9510.2 203.39,81.58 202.9,81.09 202.9,80.65 202.63,80.39 PU9502.6
G5719_VFB_R: length 6.5
  TOP w0.114: PR9511.1 204.43,87.08 v1(204.84,86.67) 205.23,86.29 205.23,82.04 PR9510.1
G5719_VIN:
  vias: v1(199.3,79.21)
G_SDO: length 4.3
  TOP w0.114: R9512.1 190.8,20.67 v1(191.04,20.44) 190.8,20.2 R9507.2 190.8,19.21 190.41,18.81 189.47,18.81 189.28,18.99 U9500.3
GC6_EVT#: length 64.3
  TOP w0.114: D2003.1 224.42,90.48 225.18,89.73 227.9,89.73 228.38,89.25 228.38,88.73 228.48,88.63 228.99,88.63 229.52,88.1 229.52,87.35 R2146.2 v1(229.91,85.99) 229.91,85.38 v1(229.93,85.36) ; R2136.1 258.53,64.62 258.53,66 v1(258.65,66.13)
  IN2 w0.089: v1(229.93,85.36) 230.08,85.21 230.08,84.14 230.31,83.91 236.23,83.91 237.57,82.56 242.26,82.56 243.3,81.52 243.85,81.52 245.07,80.3 245.07,77.22 245.95,76.33 245.95,74.71 247.69,72.97 247.69,71.91 247.62,71.84 247.62,70.99 247.86,70.75 247.86,70.28 247.69,70.11 247.69,68.51 247.34,68.16 247.34,64.77 249.51,62.6 254.44,62.6 255.89,64.05 255.89,66.54 255.58,66.85 255.58,67.32 255.79,67.53 256.39,67.53 257.59,66.33 258.45,66.33 v1(258.65,66.13)
  BOTTOM w0.102: v1(258.65,66.13) 258.65,66.24 258.62,66.28 U9002.AN37
GC6_FB_EN: length 70
  IN3 w0.089: v1(225.03,82.89) 225.15,83.02 228.45,83.02 228.78,83.35 233.13,83.35 234.17,84.39 241.03,84.39 241.47,83.95 241.47,83.47 244.71,80.23 245.93,80.23 246.49,79.67 247.89,79.67 249.92,77.64 250.15,77.64 250.82,76.96 250.82,76.1 251.78,75.15 251.78,73.81 252.83,72.76 253.98,72.76 254.64,72.1 254.64,71.62 254.46,71.44 254.46,70.73 254.63,70.56 254.63,70 256.46,68.17 257.11,68.17 257.42,67.86 257.59,67.86 259.29,66.16 260.15,66.16 261.5,64.81 261.75,64.81 262.19,64.38 262.19,64.25 263.11,63.32 263.16,63.32 264.73,61.76 264.73,60.06 268.46,56.33 268.61,56.33 270.14,54.8 v1(270.31,54.8)
  BOTTOM w0.114: v1(270.31,54.8) 270.54,54.57 270.54,54.07 270.44,53.96 R9342.2 R2135.2 ; v1(225.03,82.89) 225.43,83.29 225.43,86.23 224.19,87.47 Q2010.3
GC6_FB_EN_L: length 14.6
  BOTTOM w0.102: 262.26,60.77 261.74,61.29 261.74,62.07 261.47,62.33 U9002.AL47
  BOTTOM w0.114: 262.26,60.77 262.49,60.54 262.49,59.45 262.8,59.15 262.8,58.4 264.33,56.87 264.33,56.62 v1(264.73,56.22) 265.21,55.74 265.83,55.74 266.53,55.04 266.53,54.8 267.66,53.66 269.04,53.66 R9206.1 R9342.1
GC6FBEN: length 21.9
  TOP w0.114: v1(221.62,89.19) 221.44,89.37 220.89,89.37 220.66,89.59 220.66,91.4 220,92.06 219.01,92.06 218.8,92.27 218.8,98.62 218.12,99.31 218.12,99.93 v1(217.53,100.52)
  BOTTOM w0.102: v1(217.53,100.52) 218.36,100.52 U2000.M3
  BOTTOM w0.114: U2005.1 v1(220.87,88.59) 221.02,88.59 v1(221.62,89.19) 220.85,89.97 220.54,89.97 R2087.2 220.11,90.49 220.5,90.88 Q2013.2
GFX_SCL: length 13.2
  TOP w0.114: Q2019.4 216.86,90.73 217.36,91.23 217.36,92.37 R2039.2 217.38,93.21 217.38,95.34 216.91,95.81 216.91,95.81 216.46,96.27 216.46,98.08 215.92,98.62 215.92,99.82 216.26,100.17 216.26,100.68 216.08,100.86 216.06,100.87 215.83,101.11 v1(215.83,101.29)
  BOTTOM w0.102: U2000.T4 215.43,100.94 215.81,101.32 215.81,101.31 v1(215.83,101.29)
GFX_SDA: length 16
  TOP w0.114: v1(215.83,100.5) 215.4,100.07 215.4,99.88 215.41,99.88 215.41,96.44 v1(215.88,95.97) 216.05,95.97 R2040.2 216.38,94.49 216.38,91.48 215.86,90.96 215.86,89.12 215.97,89 217.23,89 217.66,89.43 Q2019.1
  BOTTOM w0.114: U2000.T3 v1(215.83,100.5)
GLAN_CLK_REQ2#: length 304.6
  TOP w0.114: v3(257.46,68.34) 257.36,68.44 256.62,68.44
  IN1 w0.076: v1(237.29,74.67) 237.29,75 237.49,75.19 237.49,75.8 238.75,77.07 239.48,77.07 240.01,76.53 240.18,76.53 240.66,76.05 244.65,76.05 245.19,76.6 247.31,76.6 v1(247.45,76.46)
  IN3 w0.089: v1(237.29,74.67) 235.87,74.67 235.52,74.31 234.98,74.31 234.8,74.49 233.33,74.49 232.32,73.47 229.83,73.47 229.19,72.84 229.19,72 228.75,71.56 227.25,71.56 226.44,72.37 220.99,72.37 219.36,74 219.36,75.66 217.34,77.67 210.92,77.67 210.13,78.47 174.15,78.47 167.17,71.49 117.73,71.49 113.66,67.43 100.16,67.43 97.67,64.93 93.5,64.93 91.36,62.8 83.92,62.8 82.94,61.81 82.94,61.41 80.92,59.39 75.86,59.39 72.17,63.08 66.71,63.08 65.95,63.84 59.21,63.84 56.22,66.84 50.07,66.84 45.7,71.21 43.91,71.21 43.38,71.74 43.19,71.74 41.23,73.7 41.23,74.18 40.77,74.64 40.77,78.63 34.8,84.6 34.8,88.6 29.75,93.65 29.75,97.04 29.42,97.37 29.42,104.03 29.02,104.43 29.02,112.43 29.19,112.6 29.19,116.65 28.3,117.53 23.7,117.53 22.8,118.43 v1(22.8,118.43)
  IN4 w0.076: v1(247.45,76.46) 247.77,76.77 249.37,76.77 249.59,76.99 249.59,77.41 249.82,77.64 250.2,77.64 250.48,77.35 250.48,76.97 252.11,75.34 252.11,74.27 252.89,73.5 252.89,71.86 256.41,68.34 v3(257.46,68.34)
  BOTTOM w0.114: v1(22.8,118.43) 23.02,118.65 23.02,119.6 23.74,120.32 U4000.48 ; U9002.AR32 257.46,69.21 257.46,68.34 v3(257.46,68.34)
GPD7: length 5.5
  TOP w0.114: R9367.2 268.22,69.46 266.88,69.46 R9366.1 266.22,69.31 264.02,69.31 v1(263.91,69.19)
  BOTTOM w0.102: U9002.BE41 264.23,69.51 v1(263.91,69.19)
GPIO14_IFPA_HPD: length 6.6
  TOP w0.114: TP2014.1 218.35,97.53 217.09,98.78 217.09,100.71 217.48,101.1 217.48,101.3 v1(217.5,101.32)
  BOTTOM w0.127: U2000.N4 217.53,101.3 217.52,101.3 v1(217.5,101.32)
GPIO15_IFPB_HPD: length 4.5
  BOTTOM w0.102: 217.84,97.19 217.84,97.75 217.46,98.13 217.46,98.86 217.08,99.24 U2000.P2
  BOTTOM w0.114: TP2015.1 217.84,96.15 217.84,97.19
GPIO17_IFPD_HPD: length 46.6
  TOP w0.114: Q2016.3 232.7,66.38 R2108.1 233.21,67.4 R2107.2 232.7,68.04 v1(233.34,68.68)
  IN2 w0.089: v1(233.34,68.68) 232.9,69.11 232.9,70.48 232.87,70.51 232.87,70.64 231.06,72.46 231.06,75.06 230.29,75.83 229.63,75.83 229,76.46 229,79.03 227.45,80.58 227.45,81.34 225.53,83.25 225.53,84.22 223.74,86.01 222.44,86.01 222.08,86.37 222.08,87.94 221.03,88.99 221.03,89.86 220.56,90.33 220.41,90.33 220.41,90.33 219.54,90.33 218.78,91.09 218.78,95.01 218.54,95.25 218.54,100.46 218.78,100.7 218.78,102.38 219.18,102.78 v1(219.18,103.01)
  BOTTOM w0.102: U2000.M6 218.78,102.6 v1(219.18,103.01)
GPIO17_IFPD_HPD_Q: length 4.6
  TOP w0.114: R2110.1 R2109.1 232.7,64.09 Q2016.2 232.2,66.09 232.43,66.33 R2108.2
GPIO18_IFPE_HPD: length 31.2
  TOP w0.114: v1(223.43,85.59) 224.29,85.59 225.71,84.16 v1(227.11,84.16) 227.36,84.16 227.81,84.61 229.86,84.61 230.07,84.4 230.07,84.24 230.28,84.03 230.74,84.03 231.07,84.37 231.07,84.8 230.52,85.35 230.52,86.04 R2115.1 R2114.2 231.44,87.46 Q2017.3
  IN2 w0.089: v1(216.99,96.51) 216.99,95.81 218.6,94.2 218.6,91.02 219.47,90.15 220.49,90.15 220.85,89.79 220.85,88.91 221.86,87.91 221.86,85.78 222.44,85.2 223.04,85.2 v1(223.43,85.59)
  BOTTOM w0.102: 216.74,97.19 216.74,97.78 216.28,98.24 U2000.R1
  BOTTOM w0.114: v1(216.99,96.51) 216.74,96.75 216.74,97.19
GPIO18_IFPE_HPD_Q: length 5.4
  TOP w0.114: R2115.2 v1(231.94,85.68) 233,85.68 233.22,85.9 Q2017.2 233.92,86.48 233.97,86.42 R2116.1 234.6,86.55 R2117.1
GPIO24_IFPF_HPD: length 41.4
  TOP w0.114: v1(232.95,73.19) 232.95,73.71 233.24,73.99 233.24,75 233.77,75.54 R2120.1 234.74,76.18 R2119.2 235.11,76.54 235.62,76.04 Q2018.3
  IN2 w0.089: v1(232.95,73.19) 232.57,73.19 231.52,74.25 231.52,74.85 230.36,76.01 229.7,76.01 229.18,76.53 229.18,79.1 227.63,80.65 227.63,81.41 225.71,83.33 225.71,84.29 223.81,86.19 222.51,86.19 222.26,86.45 222.26,88.01 221.21,89.06 221.21,89.93 221.1,90.04 220.63,90.51 220.56,90.51 220.55,90.51 220.25,90.51 219.67,91.1 219.67,94.4 218.72,95.35 218.72,96.7 219.27,97.25 v1(220.48,97.25)
  BOTTOM w0.102: U2000.L2 219.58,99.1 219.92,98.76 219.92,98.18 220.48,97.62 v1(220.48,97.25)
GPIO24_IFPF_HPD_Q: length 3.3
  TOP w0.114: R2122.1 R2121.1 235.12,73.12 Q2018.2 234.48,74.76 R2120.2
GPIO26_GFX: length 78.8
  TOP w0.114: v1(211.49,48.96) 210.75,48.96 210.46,49.25 Q2021.1 210.35,50.12 R2145.2
  IN2 w0.089: v1(211.49,48.96) 212.27,49.75 212.6,49.75 213.52,50.66 214.84,50.66 215.75,49.75 224,49.75 226.89,52.63 226.89,53.57 228.74,55.42 228.74,66.56 227.69,67.6 225.97,67.6 225.61,67.96 225.61,68.57 225.13,69.05 225.13,75.98 218.35,82.77 218.35,84.32 217.25,85.41 217.25,85.99 215.16,88.09 215.16,89.61 216.46,90.91 216.46,91.7 217.2,92.45 217.2,94.22 216.08,95.34 216.08,96.81 216.67,97.4 v1(216.67,101.31)
  BOTTOM w0.102: U2000.R5 216.28,101.7 v1(216.67,101.31)
GPIO27_IFPC_HPD: length 15.1
  TOP w0.114: Q2008.3 214.14,87.72 214.15,87.73 R2046.1 215.4,89.68 R2037.2 214.76,90.6 v1(214.76,90.74)
  BOTTOM w0.114: U2000.U3 214.18,99.7 214.18,96.8 215.42,95.56 215.42,92.64 215.12,92.34 214.87,92.34 214.71,92.18 214.71,90.79 v1(214.76,90.74)
GPIO27_IFPC_HPD_Q: length 4.7
  TOP w0.114: R2046.2 214.92,87.97 214.79,87.84 214.79,87.08 Q2008.2 216.31,87.31 R2057.1 R2060.1
GPP_B21: length 5.7
  BOTTOM w0.102: U9002.BD30 260.37,73.05 260.66,73.34 260.66,73.55 260.86,73.74 260.96,73.74 261.21,74 261.29,74 261.91,74.61 261.91,75.31 262.74,76.14 263.14,76.14 263.22,76.22 R9323.2
GPP_B23: length 10.5
  BOTTOM w0.102: 264.83,74.17 264.59,74.17 263.86,73.45 263.82,73.45 262.61,72.24 262.41,72.24 262.24,72.07 261.84,72.07 261.75,71.97 U9002.BD33
  BOTTOM w0.114: R10048.2 269.93,76.14 269.44,75.65 269.17,75.65 268.81,75.28 268.01,75.28 R9119.1 267.81,75.08 267.45,75.08 266.78,74.41 266,74.41 265.75,74.17 264.83,74.17
GPP_C11: length 1.4
  TOP w0.114: 254.84,72 254.99,72 v1(255.35,71.64)
  BOTTOM w0.114: 254.69,71.87 255.12,71.87 v1(255.35,71.64)
GPP_D11: length 2.6
  TOP w0.114: v1(254.22,77.32) 254.31,77.23 254.31,76.62 254.03,76.34 TP9026.1
  BOTTOM w0.114: v1(254.22,77.32) 254.51,77.32 U9002.BB16
GPP_D12: length 1.3
  TOP w0.114: v1(251.74,73.29) 251.72,73.26 TP9027.1
  BOTTOM w0.114: v1(251.74,73.29) 252.32,73.29 U9002.AN18
GPP_D17: length 124
  IN2 w0.089: v1(328.81,27.35) 328.8,27.35 327.72,27.35 326.73,28.35 324.08,28.35 323.25,29.17 323.25,30.19 321.34,32.09 320.45,32.09 319.18,33.36 319.18,34.51 318.68,35.02 316.64,35.02 315.32,36.34 315.32,41.73 311.59,45.46 311.59,47.05 307.47,51.17 299.86,51.17 298.06,52.97 293.8,52.97 293.61,53.17 291.98,53.17 290.49,54.66 v1(290.23,54.66) 289.61,54.66 288.07,56.19 284.36,56.19 284.31,56.24 284.11,56.24 284.01,56.35 283.96,56.36 283.94,56.36 283.93,56.37 283.89,56.38 283.89,56.38 283.4,56.59 283.33,56.63 283.25,56.68 283.24,56.69 282.92,56.91 282.52,57.31 282.14,57.87 282.14,57.92 281.98,58.32 281.96,58.37 281.96,58.4 281.5,58.86 281.5,61.03 278.93,63.59 278.46,64.07 278.46,66.37 277.13,67.7 275.45,67.7 274.97,68.18 273,68.18 272.52,68.66 272.52,68.89 268.67,72.73 268.11,72.73 266.2,74.64 265.86,74.64 265.57,74.93 265.21,74.93 262.21,77.94 262.21,78.32 261.61,78.92 261.61,80.01 260.45,81.16 259.42,81.16 259.04,81.55 258.22,81.55 257.13,82.64 257.13,83.23 256.84,83.52 256.84,83.97 256.58,84.23 255.83,84.23 255.45,83.86 255.45,82.32 253.91,80.78 253.91,77.69 253.77,77.56 v1(253.77,76.86)
  BOTTOM w0.114: v1(290.23,54.66) 290.87,55.3 290.87,56.3 291.7,57.13 291.7,57.6 291.7,57.87 291.7,58.44 291.7,58.67 292.13,59.09 292.13,59.79 R9617.2 ; v1(328.81,27.35) 328.89,27.35 R9624.2 ; v1(253.77,76.86) 253.59,76.86 U9002.AW15
GPP_D18: length 68.1
  IN4 w0.076: v1(290.1,53.68) 289.54,53.13 281.64,53.13 280.93,53.84 279.78,53.84 279.44,53.51 278.38,53.51 278.26,53.63 277.94,53.63 276.55,55.02 274.4,55.02 271.79,57.63 268.89,57.63 268.46,57.2 267.96,57.2 267.42,57.75 265.83,57.75 264.84,58.74 264.84,61.32 263.42,62.74 262,62.74 259.62,65.11 259.62,65.76 260.12,66.26 260.12,66.81 258.23,68.7 256.34,68.7 253.14,71.9 253.14,74 253.65,74.51 v1(253.65,75.71)
  BOTTOM w0.102: v1(253.65,75.71) 253.44,75.92 U9002.AV16
  BOTTOM w0.114: R9623.2 288.31,50.67 v1(288.6,50.97) 289.02,51.38 289.02,51.9 290.1,52.98 v1(290.1,53.68) 291.1,54.68 291.1,56.21 291.93,57.04 291.93,57.7 291.93,57.97 291.93,58.35 291.93,58.57 292.35,59 292.35,59.24 293.53,60.42 294.59,60.42 R9616.2
GPP_D19: length 81.2
  IN2 w0.089: v3(256.19,79.1) 258.87,76.42 260.69,76.42 261.55,75.56 262.56,75.56 264.61,73.51 264.84,73.51 265.18,73.17 265.66,73.17 267.57,71.26 268.13,71.26 271.09,68.3 271.09,68.07 273.39,65.78 275.03,65.78 275.53,66.28 276.54,66.28 276.93,65.88 276.93,63.34 279.64,60.63 279.64,58.63 279.77,58.49 280.56,57.7 280.62,57.64 280.62,57.58 280.93,57.11 281.41,56.4 282.02,55.8 282.22,55.66 282.66,55.36 282.69,55.34 282.72,55.32 283.02,55.2 283.02,55.2 283.09,55.17 283.23,55.03 283.42,54.84 283.44,54.82 283.72,54.82 283.77,54.77 286.6,54.77 290.34,51.03 290.85,51.03 291.98,49.9 292.74,49.9 292.92,49.72 298.38,49.72 299.12,48.99 299.12,47.54 299.57,47.08 304.45,47.08 306.33,45.2 306.33,39.6 v1(307.4,38.53)
  BOTTOM w0.102: v3(256.19,79.1) 256.06,78.97 256.06,78.55 255.46,77.94 255.26,77.94 U9002.BD16
  BOTTOM w0.114: R9615.2 306.99,36.51 v1(307.12,36.64) 306.92,36.84 306.92,37.55 306.99,37.62 306.99,38.12 v1(307.4,38.53) R9622.2
GPP_D20: length 58.9
  IN1 w0.076: v3(261.27,87.62) 262.03,87.62 273.61,76.04 273.89,76.04 275.69,74.23 276.68,74.23 279.17,71.74 280.91,71.74 281.77,70.88 282.43,70.88 282.68,71.13 282.96,71.13 283.2,70.89 283.2,69.12 284.72,67.6 286.76,67.6 291.63,62.73 292.89,62.73 v1(294.06,61.56)
  BOTTOM w0.102: 260.09,86.44 259.89,86.44 259.16,85.7 259.14,85.7 257.94,84.5 257.94,83 257.4,82.45 257.4,82.43 256.89,81.92 256.89,80.63 255.63,79.37 255.63,78.95 U9002.BF15
  BOTTOM w0.114: R9621.2 292.49,62.28 292.61,62.4 R9614.2 292.96,62.2 293.25,61.91 293.52,61.91 293.54,61.9 293.72,61.9 v1(294.06,61.56) ; v3(261.27,87.62) 261.27,87.52 260.19,86.44 260.09,86.44

# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VIN on TOP (solid shape): 312.58,65.5 312.58,64.1 312.18,63.7 312.14,63.7 311.99,63.64 311.93,63.49 311.91,63.34 311.93,63.19 311.96,63.08 312.06,62.98 312.07,62.95 312.07,62.57 312.14,62.51 312.19,62.44 312.26,62.39 312.45,62.19 312.45,61.56 312.33,61.43 311.31,61.43 310.93,61.81 310.93,62.41 310.94,62.45 310.98,62.49 311,62.53 311.09,62.66 311.12,62.81 311.08,63 310.93,63.16 310.93,63.18 310.93,63.84 310.8,63.97 310.8,65.22 311.18,65.6 312.47,65.6
+VIN on TOP (solid shape): outline of 137 points within 97.7,63.21 102.27,83.36
+VIN on TOP (solid shape): outline of 460 points within 244.81,3.03 303.37,23.64
+VIN on TOP (solid shape): outline of 734 points within 205.14,29.3 221.77,43.7
+VIN on TOP (solid shape): outline of 1421 points within 111.56,112.36 174.28,152.49
+VIN on BOTTOM (solid shape): 194.18,53.94 194.18,53.23 193.8,52.84 193.8,52.71 193.2,52.11 193.2,51.36 192.87,51.03 192.67,51.03 192.65,51.02 189.66,51.02 189.55,51.12 189.55,51.5 189.63,51.73 189.55,51.96 189.55,53.54 189.82,53.8 193.36,53.8 193.65,54.1 194.03,54.1
+VIN on BOTTOM (solid shape): 237.14,155.31 237.14,154.22 236.73,153.81 232.1,153.81 231.97,153.94 231.97,155.35 232.14,155.52 233.7,155.23 235.25,155.62 236.84,155.62
+VIN on BOTTOM (solid shape): 210.47,43.83 210.47,43.27 210.96,42.78 210.96,41.33 210.98,41.31 210.98,40.48 210.85,40.35 207.68,40.35 207.47,40.55 207.47,41.06 207.46,41.07 207.46,41.13 207.4,41.13 207.37,41.16 205.77,41.16 205.39,40.78 205.39,38.7 205.09,38.39 202.29,38.39 202.14,38.24 200.54,38.24 200.08,38.7 199.68,38.7 199.6,38.78 199.6,38.88 199.73,39 200.79,39 201.2,39.41 201.2,40.15 201.5,40.45 202.22,40.45 203.36,41.59 203.36,43.52 203.84,44.01 210.29,44.01
+VIN on BOTTOM (solid shape): 120.3,116.42 120.3,114.23 120.22,113.98 120.3,113.74 120.3,113.38 120.91,112.77 124.51,112.77 124.77,113.03 125.66,113.03 125.77,112.92 125.77,112.54 125.69,112.46 124.58,112.46 124.51,112.52 122.91,112.52 122.47,112.08 118.62,112.08 118.27,111.72 118.27,111.42 118.17,111.32 116.77,111.32 116.31,111.77 115.73,111.77 115.32,112.18 114.66,112.18 114.54,112.31 114.54,115.74 115.48,116.68 120.05,116.68
+VIN on BOTTOM (solid shape): 136.48,144.46 136.48,141.75 134.45,139.71 134.43,139.71 133.7,139.62 133,139.39 132.99,139.38 132.47,139.38 130.46,137.38 130.46,134.91 127.9,132.35 126.7,132.35 125.98,131.62 125.98,130.89 125.84,130.75 125.61,130.75 125.38,130.52 125.38,130.27 124.75,129.63 120.56,129.63 119.67,128.74 119.67,126.53 119.49,126.35 119.49,126.02 119.67,125.85 119.67,125.2 120.02,124.84 123.63,124.84 123.88,125.09 124.77,125.09 124.88,124.98 124.88,124.6 124.8,124.52 123.69,124.52 123.63,124.59 122.02,124.59 122.02,124.58 121.55,124.11 116.43,124.11 116.43,124.11 115.92,124.11 115.73,124.3 115.73,125.31 115.86,125.44 116.62,125.44 117,125.82 117,132.55 117.51,133.06 121.72,133.06 121.72,133.14 124.23,135.64 124.23,138.91 125.28,139.97 126.98,139.97 128.86,141.85 133.66,141.85 134.4,142.58 134.4,144.52 134.65,144.77 136.18,144.77
+VIN on BOTTOM (solid shape): outline of 332 points within 206.34,14.82 256.7,33.39
+VIN on BOTTOM (solid shape): outline of 2329 points within 137.26,145.66 180.75,161.38
+VIN on IN4 (solid shape): outline of 16905 points within 74.45,7.84 237.14,161.49
+VIN_1.05V on TOP (solid shape): 306.36,69.31 308.26,69.31 308.52,69.05 312.33,69.05 312.58,68.8 312.58,66.13 312.35,65.9 311.18,65.9 311.06,66.03 311.06,67.02 310.8,67.27 307.25,67.27 307.12,67.4 307.12,67.91 307.01,68.02 306.87,68.02 306.59,68.02 306.56,68.02 305.1,68.02 304.9,67.82 304.9,64.96 304.89,64.93 304.88,64.91 304.85,64.9 304.57,64.9 304.5,64.79 304.44,64.79 304.44,64.35 304.44,64.33 304.43,64.3 304.41,64.28 304.39,64.25 304.36,64.24 304.33,64.23 304.3,64.23 304.27,64.24 304.24,64.25 304.21,64.28 304.2,64.3 304.19,64.33 304.19,64.35 304.19,64.79 304.13,64.79 304.05,64.87 304.05,64.9 303.61,64.9 303.58,64.91 303.57,64.93 303.56,64.96 303.56,67.98 304.69,67.98 304.69,68.59 304.44,68.59 304.44,67.98 303.56,67.98 303.56,69.13 303.58,69.16 303.59,69.21 303.6,69.26 303.62,69.36 303.82,69.56 306.1,69.56
+VIN_1.8VPCU on TOP (solid shape): outline of 120 points within 291.76,6.22 294.5,15.89
+VIN_3VPCU on BOTTOM (solid shape): 211.61,43.65 215.68,43.65 215.92,43.89 216.45,43.89 216.82,43.52 218.5,43.52 218.52,43.5 218.52,43.32 218.5,43.3 217.61,43.3 216.72,42.41 216.49,42.41 216.41,42.33 215.81,42.33 215.47,42 214.83,42 214.82,42.01 214.66,42.04 214.51,42.01 214.5,42 213.77,42 213.01,41.24 211.36,41.24 211.25,41.34 211.25,42.87 210.73,43.4 210.73,43.78 210.85,43.91 211.36,43.91
+VIN_5V_USBSRC on BOTTOM (solid shape): 207.68,40.1 208.44,40.1 208.57,39.97 208.57,39.71 208.06,39.21 208.06,37.94 207.3,37.17 207.3,36.41 207.8,35.9 210.22,35.9 210.47,36.16 214.03,36.16 214.15,36.03 214.15,35.68 214.33,35.5 214.84,35.5 214.89,35.45 214.89,35.35 214.81,35.27 214.23,35.27 214.15,35.19 214.15,35.14 213.9,34.89 211.36,34.89 210.6,34.13 209.31,34.13 209.1,33.92 209.1,33.49 208.98,33.37 207.54,33.37 207.13,33.78 206.58,33.78 205.65,34.72 205.65,38.98 205.87,39.21 205.87,40.58 206.13,40.84 206.94,40.84
+VIN_BLIGHT on TOP (solid shape): 68.74,54.19 68.74,53.43 68.75,53.42 68.75,53.38 68.95,53.19 68.98,53.19 69.12,53.05 69.76,53.05 70.01,52.8 70.01,52.29 70.26,52.03 70.77,52.03 71.03,51.78 71.03,46.7 70.77,46.45 68.74,46.45 68.1,47.08 68.1,48.86 67.72,49.24 67.72,50.38 67.09,51.02 67.09,51.65 66.58,52.16 65.82,52.16 65.44,52.54 65.44,54.19 65.69,54.45 68.49,54.45
+VIN_BLIGHT on BOTTOM (solid shape): 67.15,54.02 68.67,54.02 68.78,53.92 68.78,49.32 68.53,49.08 67.46,49.08 67.22,49.32 67.22,50.64 66.96,50.89 64.8,50.89 64.31,51.39 64.31,53.2 65.31,53.2 65.31,54.35 65.06,54.35 65.06,53.2 64.81,53.2 64.81,54.35 64.56,54.35 64.56,53.2 64.31,53.2 64.31,54.37 64.49,54.55 66.62,54.55
AGND on TOP (solid shape): 367.44,11.01 367.55,10.9 367.56,10.88 367.57,10.86 367.38,4 367.33,3.92 367.23,3.91 367.16,3.95 367.08,3.97 367.06,4 367.06,4.37 366.41,5.02 366.4,5.04 366.39,5.06 366.44,6.93 366.44,6.95 366.51,9.38 366.55,10.88 366.68,11.01 367.44,11.01
AGND on TOP (solid shape): 365.45,14.92 365.48,14.91 365.49,14.89 365.64,14.69 365.81,14.51 367.44,13.12 367.57,12.95 367.62,12.74 367.61,12.58 367.44,12.41 366.7,12.41 366.59,12.51 365.15,13.74 364.72,14.22 364.42,14.8 364.42,14.83 364.43,14.86 364.49,14.92
AGND on TOP (solid shape): 338.69,3.7 338.69,1.95 339.11,1.52 366.3,1.52 366.33,2.71 366.34,2.75 366.38,2.76 366.96,2.76 367.04,2.77 367.11,2.78 367.16,2.8 367.21,2.81 367.3,2.8 367.35,2.72 367.3,0.99 367.15,0.65 366.81,0.51 337.72,0.51 337.68,0.52 337.67,0.56 337.67,3.59 337.85,3.77 338.61,3.77
AGND on BOTTOM (solid shape): 340.11,6.5 340.11,5.03 340.04,4.95 338.5,4.95 338.48,4.95 338.46,4.96 338.23,5.06 337.96,4.99 337.93,5 337.7,5.23 337.7,6.88 337.78,6.96 339.66,6.96
AGND on BOTTOM (solid shape): 367.55,10.9 367.56,10.88 367.57,10.86 367.38,4 367.33,3.92 367.23,3.91 367.1,3.96 366.96,3.98 366.47,3.98 366.4,4.01 366.37,4.08 366.44,6.93 366.45,6.93 366.5,9.03 366.55,10.89 366.68,11.01 367.44,11.01
AGND on BOTTOM (solid shape): 365.45,14.92 365.48,14.91 365.49,14.89 365.64,14.69 365.81,14.51 367.44,13.12 367.57,12.95 367.62,12.74 367.61,12.58 367.44,12.41 366.7,12.41 366.59,12.51 365.15,13.74 364.72,14.22 364.42,14.8 364.42,14.83 364.43,14.86 364.49,14.92
AGND on BOTTOM (solid shape): 340.52,3.77 340.52,1.9 340.9,1.52 366.3,1.52 366.33,2.71 366.34,2.75 366.38,2.76 366.96,2.76 367.04,2.77 367.11,2.78 367.16,2.8 367.21,2.81 367.3,2.8 367.35,2.72 367.3,0.99 367.15,0.65 366.81,0.51 337.72,0.51 337.68,0.52 337.67,0.56 337.67,3.59 337.98,3.9 340.39,3.9
AGND on GND (solid shape): outline of 1218 points within 337.52,0.51 367.62,27.52
AGND on IN1 (solid shape): 367.55,10.9 367.56,10.88 367.57,10.86 367.38,3.96 367.33,3.87 367.23,3.87 367.1,3.92 366.96,3.94 366.47,3.94 366.4,3.97 366.36,4.04 366.44,6.93 366.44,6.93 366.55,10.89 366.68,11.01 367.44,11.01
AGND on IN1 (solid shape): 365.45,14.92 365.48,14.91 365.49,14.89 365.64,14.69 365.81,14.51 367.44,13.12 367.57,12.95 367.62,12.74 367.61,12.58 367.44,12.41 366.7,12.41 366.59,12.51 365.15,13.74 364.72,14.22 364.42,14.8 364.42,14.83 364.43,14.86 364.49,14.92
AGND on VCC (solid shape): outline of 1218 points within 337.52,0.51 367.62,27.52
AGND on IN2 (solid shape): 367.55,10.9 367.56,10.88 367.57,10.86 367.38,3.97 367.33,3.89 367.23,3.89 367.1,3.94 366.96,3.95 366.47,3.95 366.39,3.99 366.37,4.06 366.4,5.28 366.44,6.93 366.44,6.93 366.55,10.89 366.68,11.01 367.44,11.01
AGND on IN2 (solid shape): 365.45,14.92 365.48,14.91 365.49,14.89 365.64,14.69 365.81,14.51 367.44,13.12 367.57,12.95 367.62,12.74 367.61,12.58 367.44,12.41 366.7,12.41 366.59,12.51 365.15,13.74 364.72,14.22 364.42,14.8 364.42,14.83 364.43,14.86 364.49,14.92
AGND on IN3 (solid shape): 367.55,10.9 367.56,10.88 367.57,10.86 367.38,3.97 367.33,3.89 367.23,3.89 367.1,3.94 366.96,3.95 366.47,3.95 366.39,3.99 366.37,4.06 366.4,5.28 366.44,6.93 366.44,6.93 366.55,10.89 366.68,11.01 367.44,11.01
AGND on IN3 (solid shape): 365.45,14.92 365.48,14.91 365.49,14.89 365.64,14.69 365.81,14.51 367.44,13.12 367.57,12.95 367.62,12.74 367.61,12.58 367.44,12.41 366.7,12.41 366.59,12.51 365.15,13.74 364.72,14.22 364.42,14.8 364.42,14.83 364.43,14.86 364.49,14.92
AGND on GND1 (solid shape): outline of 1219 points within 337.52,0.51 367.62,27.52
AGND on IN4 (solid shape): 367.55,10.9 367.56,10.88 367.57,10.86 367.38,3.96 367.33,3.87 367.23,3.87 367.1,3.92 366.96,3.94 366.47,3.94 366.4,3.97 366.36,4.04 366.44,6.93 366.44,6.93 366.55,10.89 366.68,11.01 367.44,11.01
AGND on IN4 (solid shape): 365.45,14.92 365.48,14.91 365.49,14.89 365.64,14.69 365.81,14.51 367.44,13.12 367.57,12.95 367.62,12.74 367.61,12.58 367.45,12.42 366.69,12.42 366.59,12.51 365.15,13.74 364.72,14.22 364.42,14.8 364.42,14.83 364.43,14.86 364.49,14.92
AGND on GND2 (solid shape): outline of 1218 points within 337.52,0.51 367.62,27.52
GND on TOP (solid shape): 129.7,151.22 129.7,146.65 129.57,146.52 125,146.52 124.87,146.65 124.87,151.22 125,151.35 129.57,151.35
GND on TOP (solid shape): 135.67,85.94 135.67,84.16 135.59,84.09 126.35,84.09 126.3,84.14 126.3,86.02 126.35,86.07 135.54,86.07
GND on TOP (solid shape): 221.65,35.78 221.65,34 221.39,33.75 220.12,33.75 220,33.87 220,35.78 220.25,36.03 221.39,36.03
GND on TOP (solid shape): 274.22,63.78 274.22,63.66 271.68,61.12 271.55,61.12 270.28,62.39 270.28,62.51 272.82,65.05 272.95,65.05
GND on TOP (solid shape): 306.66,9.31 306.66,5.42 306.38,5.15 304.58,5.15 304.17,5.55 304.17,9.08 304.6,9.51 306.46,9.51
GND on TOP (solid shape): 348.37,137.76 348.37,134.51 348.22,134.36 346.92,134.36 346.79,134.48 346.79,137.86 346.95,138.01 348.11,138.01
GND on TOP (solid shape): 352,134.3 352,133.03 351.82,132.86 350.88,132.86 350.83,132.91 350.83,134.28 350.93,134.38 351.92,134.38
GND on TOP (solid shape): 355.63,128.36 355.63,127.22 355.25,126.84 352.08,126.84 351.95,126.96 351.95,128.15 352.66,128.87 355.12,128.87
GND on TOP (solid shape): 357.39,131.51 357.39,130.6 357.27,130.48 356.41,130.48 356.23,130.65 356.23,132.15 356.32,132.24 356.66,132.24
GND on TOP (solid shape): 104.4,49.85 104.4,46.09 104.25,45.94 103.13,45.94 102.88,46.19 102.88,50 103,50.13 104.12,50.13
GND on TOP (solid shape): 354.87,90.39 354.87,86.58 354.74,86.45 353.47,86.45 353.35,86.58 353.35,90.39 353.6,90.64 354.62,90.64
GND on TOP (solid shape): 17.69,100.8 17.69,98.9 17.18,98.39 14.51,98.39 14.26,98.64 14.26,100.8 14.38,100.93 17.56,100.93
GND on TOP (solid shape): 201.33,153.72 201.33,151.86 201.24,151.77 200.07,151.77 199.94,151.89 199.94,152.21 200.1,152.38 200.1,153.85 200.31,154.06 200.99,154.06
GND on TOP (solid shape): 208.95,54.54 208.95,52.39 208.77,52.21 206.86,52.21 206.3,52.78 206.3,54.68 206.41,54.8 208.69,54.8
GND on TOP (solid shape): 293.15,23.23 293.15,21.3 292.87,21.02 291.04,21.02 290.74,21.33 290.74,23.2 290.99,23.46 292.92,23.46
GND on TOP (solid shape): 351.44,85.05 351.44,83.91 351.06,83.53 348.29,83.53 347.71,84.11 347.71,85.56 347.89,85.74 350.76,85.74
GND on TOP (solid shape): 355.1,137.56 355.1,136.23 353.75,134.89 352.41,134.89 352.38,134.91 352.38,136.34 352.48,136.44 352.48,138.22 352.76,138.5 354.16,138.5
GND on TOP (solid shape): 360.97,60.03 360.97,57.49 360.2,56.73 358.68,56.73 358.05,56.1 356.78,56.1 355.63,57.24 355.63,61.18 355.89,61.43 359.57,61.43
GND on TOP (solid shape): 16.36,92.09 16.36,88.91 16.14,88.69 14.81,88.69 14.51,88.99 13.7,88.99 13.52,89.17 13.52,92.04 13.8,92.32 16.14,92.32
GND on TOP (solid shape): 284.77,65.11 284.77,63.82 285.1,63.49 285.1,63.21 284.99,63.11 283.99,63.11 283.81,63.29 283.81,65.37 284.51,65.37
GND on TOP (solid shape): 22.64,131.92 22.64,131.41 22.13,130.9 22.13,129.25 21.88,129 17.81,129 17.43,129.38 17.43,130.01 18.07,130.65 18.07,132.17 18.19,132.3 22.26,132.3
GND on TOP (solid shape): 106.84,36.29 106.84,32.12 106.43,31.71 105.62,31.71 105.32,32.02 105.32,35.27 105.57,35.52 105.57,36.41 105.7,36.54 106.59,36.54
GND on TOP (solid shape): 135.67,85.82 135.67,84.24 135.54,84.11 109.18,84.11 109,83.94 109,58.31 108.26,57.57 107.09,57.57 106.99,57.67 106.99,85.89 107.09,85.99 135.49,85.99
GND on TOP (solid shape): 212.63,38.95 212.63,38.06 211.74,37.17 209.33,37.17 209.07,37.43 209.07,39.59 209.71,40.22 211.36,40.22
GND on TOP (solid shape): 228.98,139.97 229.71,139.97 230.02,139.66 230.02,137.75 229.65,137.38 228.51,137.38 228.27,137.61 228.27,140.05 228.44,140.21 228.74,140.21
GND on TOP (solid shape): 247.94,96.99 248.44,96.99 248.57,96.86 248.57,91.15 246.03,88.61 240.06,88.61 238.28,90.39 238.28,92.8 241.59,96.1 245.4,96.1 246.79,97.5 247.43,97.5
GND on TOP (solid shape): 251.51,97.23 251.51,96.69 251.51,96.69 251.51,96.13 251.14,95.77 249.99,95.77 249.85,95.9 249.85,97.41 249.96,97.52 251.22,97.52
GND on TOP (solid shape): 273.89,6.16 273.89,3.65 273.72,3.47 271.38,3.47 271.08,3.77 271.08,6.69 271.35,6.97 273.08,6.97
GND on TOP (solid shape): 343.59,97.47 343.59,96.46 343.47,96.33 341.94,96.33 341.79,96.48 341.79,96.74 342.04,96.99 342.04,98.44 342.12,98.52 342.55,98.52
GND on TOP (solid shape): 230.03,92.77 230.03,92.13 229.52,91.63 229.52,90.1 229.39,89.97 225.36,89.97 224.95,90.39 224.95,91.02 225.58,91.66 225.58,92.9 225.71,93.02 229.78,93.02
GND on TOP (solid shape): 47.02,52.16 48.55,52.16 48.8,52.41 49.64,52.41 49.99,52.06 49.99,50.99 49.89,50.89 47.28,50.89 46.13,52.03 46.13,52.29 46.26,52.41 46.77,52.41
GND on TOP (solid shape): 104.93,84.5 104.93,74.82 104.63,74.51 102.8,74.51 102.65,74.67 102.65,79.06 102.34,79.36 102.34,82.26 101.61,83 101.61,84.93 101.91,85.23 104.2,85.23
GND on TOP (solid shape): 149.03,88.46 149.03,86.73 149.77,85.99 166.35,85.99 166.66,85.69 166.66,84.44 166.33,84.11 144.3,84.11 143.72,84.7 143.72,86.55 145.93,88.76 148.72,88.76
GND on TOP (solid shape): 210.02,27.01 210.73,27.01 210.85,26.89 210.85,26.13 210.73,26 208.44,26 207.92,26.51 207.92,27.64 208.19,27.9 209.14,27.9
GND on TOP (solid shape): 251.87,84.67 251.87,84.08 251.85,84 251.83,83.92 251.44,83.53 250.7,83.53 250.4,83.23 250.03,83.23 249.87,83.38 249.87,83.63 251.04,84.81 251.74,84.81
GND on TOP (solid shape): 291.71,61.65 292.17,61.65 292.48,61.34 292.48,60.89 292.51,60.85 292.51,59.91 292.26,59.65 290.42,59.65 289.73,60.34 289.73,60.43 289.49,60.67 289.49,61.53 289.61,61.65 291.71,61.65
GND on TOP (solid shape): 330.92,12.79 331.5,12.79 332.9,11.39 332.9,11.09 332.85,11.04 332.4,11.04 332.39,11.04 329.06,11.04 328.91,11.2 328.91,12.74 329.06,12.89 330.82,12.89
GND on TOP (solid shape): 356.18,141.78 356.18,141.39 355.98,141.19 354.24,141.19 354.22,141.18 354.19,141.18 353.69,140.68 352.33,140.68 352.2,140.81 352.2,141.06 352.33,141.19 353.6,141.19 354.24,141.82 356.14,141.82
GND on TOP (solid shape): 40.55,51.2 40.55,48.38 40.85,48.07 43.67,48.07 44.13,47.61 44.13,47.31 44.02,47.21 43.72,47.21 43.59,47.33 38.44,47.33 38.26,47.51 38.26,50.87 38.72,51.32 40.42,51.32
GND on TOP (solid shape): 202.85,96.46 202.85,94.61 202.24,94.01 202.24,93.97 202.09,93.82 201.07,93.82 200.82,94.07 200.82,94.75 201.38,95.31 201.38,95.53 201.73,95.87 201.86,95.87 202.16,96.18 202.16,96.45 202.37,96.66 202.65,96.66
GND on TOP (solid shape): 290.1,23.99 290.1,21.07 289.97,20.94 286.52,20.94 286.32,20.74 285.76,20.74 285.66,20.84 285.66,21.55 286.29,22.19 286.29,23.87 286.42,23.99 288.45,23.99 289.08,24.63 289.47,24.63
GND on TOP (solid shape): 339.4,26.8 339.43,26.81 339.47,26.8 339.5,26.76 339.5,26 340.14,25.36 340.14,23.84 339.99,23.69 337.86,23.69 337.78,23.77 337.78,26.55 337.88,26.65 339.25,26.65
GND on TOP (solid shape): 17.76,98.16 17.76,96.33 18.24,95.85 19.13,95.85 19.23,95.75 19.23,95.21 19.13,95.11 14.66,95.11 14.54,95.24 14.54,97.63 14.79,97.88 16.87,97.88 17.23,98.24 17.69,98.24
GND on TOP (solid shape): 153.07,122.9 153.07,119.98 153.32,119.72 153.32,118.2 153.19,118.07 151.67,118.07 151.54,118.2 151.54,119.98 151.16,120.36 151.16,120.74 151.21,120.78 151.28,120.78 151.28,120.86 151.29,120.87 151.29,122.9 151.42,123.03 152.94,123.03
GND on TOP (solid shape): 333.05,18.89 333.05,18.4 332.65,18 331.96,18 331.61,17.65 331.61,15.82 331.38,15.58 330.49,15.58 330.11,15.97 330.11,18.63 330.36,18.89 330.74,18.89 330.75,18.88 331.51,18.88 331.64,19.01 332.93,19.01
GND on TOP (solid shape): 103.38,68.67 103.49,68.69 103.75,68.69 103.99,68.45 103.99,67.74 102.73,66.48 101.88,66.48 101.7,66.66 101.7,67.99 101.77,68.07 102.18,68.07 102.8,68.69 103.28,68.69
GND on TOP (solid shape): 334.6,4.66 334.6,4.13 334.78,3.95 336.15,3.95 336.33,4.13 336.33,4.64 336.48,4.79 336.96,4.79 337.09,4.66 337.09,2.38 336.96,2.25 334.14,2.25 333.99,2.4 333.99,4.69 334.09,4.79 334.47,4.79
GND on TOP (solid shape): 359.4,133.67 359.4,132.98 359.3,132.88 358.1,132.88 357.94,133.03 357.54,133.03 357.44,133.14 357.44,133.61 357.99,133.61 358.12,133.74 358.2,133.9 359.17,133.9
GND on TOP (solid shape): 121.33,112.42 121.33,111.88 121.48,111.72 122.26,111.72 122.49,111.49 122.49,110.65 123.23,109.91 124.87,109.91 125.38,109.4 125.38,108.42 124.75,107.79 118.52,107.79 115.73,110.58 115.73,111.55 115.91,111.72 119.91,111.72 120.67,112.48 121.27,112.48
GND on TOP (solid shape): 149.64,122.9 149.64,120.74 149.77,120.61 149.77,117.82 149.89,117.69 150.12,117.69 150.37,117.44 150.37,116.42 150.91,115.89 150.91,111.09 150.78,110.96 148.24,110.96 147.99,111.22 147.99,116.68 147.61,117.06 147.61,122.01 147.99,122.39 147.99,122.9 148.11,123.03 149.51,123.03
GND on TOP (solid shape): 204.86,37.58 204.86,33.9 204.78,33.82 204.27,33.82 203.97,34.13 201.96,34.13 201.45,34.63 201.45,34.89 199.8,36.54 198.66,36.54 198.44,36.76 197.56,36.76 197.52,36.79 197.52,37.17 197.64,37.3 198.1,37.3 198.44,37.64 198.44,39.37 199.68,40.6 201.84,40.6
GND on TOP (solid shape): 224.19,157.65 224.19,157.19 224.31,157.06 225.08,157.06 225.33,156.81 228.12,156.81 228.25,156.68 228.25,155.92 227.99,155.66 222.98,155.66 222.72,155.92 222.72,157.09 222.85,157.22 223.45,157.22 223.65,157.42 223.65,157.62 223.73,157.7 224.14,157.7
GND on TOP (solid shape): 176.26,134.84 176.26,131.89 176.03,131.66 172.99,131.66 172.97,131.68 172.96,131.69 172.79,131.87 172.55,131.9 172.53,131.9 172.5,131.91 172.21,132.21 172.21,134.8 172.5,135.09 176,135.09
GND on TOP (solid shape): 74.36,57.9 74.36,52.92 73.69,52.26 73.69,51.53 73.82,51.4 74.07,51.4 74.23,51.25 74.23,50.89 74.1,50.76 71.66,50.76 71.41,51.02 71.41,51.91 71.03,52.29 70.39,52.29 70.26,52.41 70.26,52.92 69.88,53.3 68.99,53.3 68.87,53.43 68.87,56.48 71.03,58.64 73.62,58.64
GND on TOP (solid shape): 19.87,107 19.87,105.98 19.69,105.81 15.02,105.81 14.71,106.11 14.71,106.79 14.72,106.81 14.82,106.95 14.85,107.09 14.88,107.16 14.95,107.19 16.11,107.19 16.31,107.38 19.49,107.38
GND on TOP (solid shape): 95.79,58.18 95.79,53.23 96.3,52.72 96.3,45.82 96.04,45.57 95.55,45.57 94.82,46.3 94.82,47.84 94.14,48.53 94.14,50.97 94.15,50.98 94.15,51.64 94.14,51.65 94.14,52.06 93.83,52.36 91.47,52.36 89.21,54.62 89.21,58.03 90.99,59.81 94.16,59.81
GND on TOP (solid shape): 278.14,51.95 278.14,51.89 278.2,51.89 278.9,51.2 278.9,50.36 278.42,49.87 277.82,49.87 277.7,50 277.7,50.44 277.9,50.64 277.9,51.32 277.7,51.52 277.7,51.6 277.39,51.9 276.31,51.9 276.26,51.96 276.26,52.15 276.27,52.18 276.31,52.2 277.9,52.2
GND on TOP (solid shape): 229.01,150.5 229.01,147.98 229.84,147.15 229.84,143.47 229.85,143.46 229.85,141.63 229.69,141.48 229.53,141.48 228.99,142.02 228.99,142.09 228.8,142.29 228.5,142.29 228.24,142.55 228.24,144.17 228.24,144.18 228.24,145.84 228.25,145.86 228.25,146.93 228.23,146.95 228.23,149.05 228.23,149.05 228.23,149.14 227.59,149.79 227.59,150.79 227.81,151.01 228.5,151.01
GND on TOP (solid shape): 295.33,15.89 295.37,15.87 295.38,15.84 295.38,14.87 296.15,14.11 296.15,13.48 296.83,12.79 296.83,11.9 297.3,11.43 297.3,8.78 297.13,8.61 296.3,8.61 295.84,8.15 294.94,8.15 294.75,8.35 294.75,13.73 295,13.98 295,15.84 295.02,15.87 295.05,15.89
GND on TOP (solid shape): 267.56,45.68 267.6,45.67 267.61,45.63 267.61,41.69 267.63,41.65 267.62,41.62 266.73,40.73 263.05,40.73 262.92,40.86 260.99,40.86 260.81,41.04 260.81,41.59 260.97,41.75 266.73,41.75 266.86,41.87 266.86,45.56 266.99,45.68
GND on TOP (solid shape): 288.34,39.74 288.34,37.85 287.11,36.62 287.11,34.69 287.1,34.65 287.06,34.63 281.21,34.63 280.85,35 280.54,35 280.47,35 280.41,35 280.39,35 279.69,35.7 279.69,39.33 280.07,39.71 281.59,39.71 281.97,39.33 281.97,35.86 282.43,35.4 286.54,35.4 286.93,35.78 286.93,39.59 287.18,39.84 288.24,39.84
GND on TOP (solid shape): 192.87,87.24 192.87,85.46 193.07,85.26 193.9,85.26 194.06,85.42 194.9,85.42 195.01,85.53 196.21,85.53 196.33,85.42 197.06,85.42 197.81,86.16 198.28,86.16 198.66,85.78 198.66,85.15 198.15,84.64 197.14,84.64 197.01,84.51 193.83,84.51 193.8,84.55 193.35,84.55 192.82,84.01 192.26,84.01 192.18,84.09 192.18,85.79 191.98,85.99 191.98,87.31 192.03,87.37 192.74,87.37
GND on TOP (solid shape): 160.56,122.77 160.56,120.23 160.43,120.11 160.38,120.11 160.35,120.12 160.28,120.17 160.2,120.18 159.92,120.18 159.79,120.14 159.72,120.03 159.71,120.02 159.67,119.98 159.67,118.58 159.54,118.45 159.04,118.45 158.91,118.58 158.91,119.98 159.16,120.23 159.16,122.9 159.29,123.03 160.31,123.03
GND on TOP (solid shape): 190.15,23.28 190.15,19.73 190.02,19.6 189.24,19.6 189.11,19.73 189.11,19.91 190,19.91 190,20.15 189.59,20.15 189.59,19.91 189.11,19.91 189.11,20.57 189.13,20.59 189.63,20.59 189.63,21 189.44,21 189.44,20.59 189.13,20.59 189.13,21 189.11,21.02 189.11,21.63 189.1,21.64 189.1,21.77 189.11,21.78 189.11,22.32 188.45,22.98 188.45,23.87 188.58,23.99 189.44,23.99
GND on TOP (solid shape): 27.46,126.46 27.46,121.88 27.34,121.76 27.08,121.76 26.96,121.88 26.96,122.26 26.7,122.52 26.06,122.52 25.96,122.61 24.32,122.61 24.02,122.91 24.02,123.18 23.95,123.33 23.8,123.39 23.49,123.39 23.42,123.43 23.4,123.49 23.4,126.2 24.04,126.84 27.08,126.84
GND on TOP (solid shape): 359.82,125.19 359.82,124.55 359.19,123.92 358.55,123.92 358.43,124.04 358.43,124.72 358.46,124.79 358.53,124.82 358.81,124.93 358.92,125.21 358.95,125.28 359.02,125.31 359.7,125.31
GND on TOP (solid shape): 167.35,122.84 167.36,122.82 167.37,122.8 167.38,122.7 167.41,122.61 167.42,122.6 167.42,122.52 167.55,122.39 167.93,122.39 167.97,122.34 167.97,121.98 168.03,121.93 168.48,121.93 168.54,121.87 168.54,121.62 168.47,121.55 168.22,121.55 168.18,121.51 168.18,120.87 168.31,120.74 168.58,120.74 168.69,120.63 168.69,120.36 167.93,119.6 167.93,116.42 167.67,116.17 166.91,116.17 166.78,116.3 166.78,120.11 167.04,120.36 167.04,122.77 167.16,122.9 167.29,122.9
GND on TOP (solid shape): 37.09,67.35 37.09,67.17 37.5,66.77 37.5,64.61 37.75,64.35 38.39,64.35 38.89,63.84 41.94,63.84 42.45,64.35 42.96,64.35 43.09,64.48 43.09,66.64 43.34,66.89 43.94,66.89 43.97,66.88 43.99,66.84 43.99,64.11 43.59,63.72 43.59,63.08 43.34,62.83 42.32,62.83 42.07,63.08 38.64,63.08 38.26,62.7 37.37,62.7 36.7,63.38 36.7,65.76 36.69,65.76 36.69,66.6 36.53,66.77 36.02,66.77 35.92,66.87 35.92,67.3 36.05,67.43 37.01,67.43
GND on TOP (solid shape): 169.7,122.87 169.7,122.61 169.83,122.49 169.88,122.49 169.9,122.48 170.1,122.42 170.31,122.49 170.67,122.49 170.67,122.48 170.85,122.31 170.85,121.73 170.96,121.62 171.27,121.62 171.36,121.53 171.36,120.45 170.97,120.07 170.97,113.25 170.11,112.38 170.11,110.17 169.88,109.95 167.77,109.95 167.67,110.05 167.67,115.15 168.05,115.53 168.82,115.53 168.94,115.66 168.94,119.47 169.32,119.85 169.32,122.87 169.45,122.99 169.58,122.99
GND on TOP (solid shape): 164.5,122.9 164.5,122.01 164.1,121.61 164.08,121.61 163.96,121.55 163.9,121.43 163.9,121.41 163.86,121.38 163.86,120.87 164.12,120.61 164.12,120.49 163.86,120.23 163.86,112.92 163.99,112.79 163.99,109.95 163.86,109.82 160.81,109.82 160.69,109.95 160.69,117.69 161.58,118.58 161.58,120 162.21,120.64 162.21,121.54 162.24,121.57 162.25,121.57 162.25,122.18 162.24,122.18 162.21,122.21 162.21,122.31 162.24,122.34 162.25,122.34 162.25,122.94 162.34,123.03 164.37,123.03
GND on TOP (solid shape): 180.68,44.57 180.68,42.64 180.42,42.38 179.38,42.38 179.17,42.58 179.16,42.6 179.15,42.62 179.15,44.01 179.17,44.04 179.2,44.06 179.5,44.06 179.64,44.06 179.78,44.12 179.84,44.26 179.85,44.37 179.86,44.41 179.86,44.69 179.87,44.73 179.91,44.74 180.5,44.74
GND on TOP (solid shape): 143.78,155.67 143.82,155.66 143.83,155.62 143.83,154.88 143.82,154.85 143.78,154.83 143.01,154.83 142.78,154.61 142.78,154.04 142.78,154.04 142.78,153.74 142.92,153.6 142.92,153.34 142.81,153.23 142.5,153.23 142.4,153.33 142.4,153.63 142.53,153.76 142.53,154.61 142.3,154.83 142.03,154.83 141.99,154.85 141.98,154.88 141.98,155.62 141.99,155.66 142.03,155.67
GND on TOP (solid shape): 193.9,82.59 193.9,81.7 193.61,81.41 193.61,81.42 193.53,81.35 193.4,81.28 193.34,81.13 193.34,80.81 193.38,80.69 193.47,80.61 193.5,80.6 193.5,80.42 193.45,80.34 193.42,80.26 193.16,80 192.41,80 192.06,79.64 192.06,79.16 192.01,79.11 191.5,79.11 191.47,79.14 191.47,79.69 191.52,79.75 192.13,80.35 192.13,82.67 192.23,82.78 193.71,82.78
GND on TOP (solid shape): 151.78,155.67 151.82,155.66 151.84,155.62 151.84,154.88 151.82,154.85 151.78,154.83 151.01,154.83 150.82,154.64 150.78,154.59 150.78,153.85 150.88,153.75 150.88,153.28 150.76,153.15 150.43,153.15 150.32,153.25 150.32,153.66 150.53,153.86 150.53,153.9 150.53,153.9 150.53,154.61 150.53,154.61 150.31,154.83 150.03,154.83 150,154.85 149.98,154.88 149.98,155.62 150,155.66 150.03,155.67
GND on TOP (solid shape): 159.66,155.67 159.69,155.66 159.71,155.62 159.71,154.88 159.69,154.85 159.66,154.83 158.88,154.83 158.69,154.64 158.66,154.59 158.66,153.85 158.78,153.72 158.78,153.23 158.6,153.05 158.38,153.05 158.2,153.23 158.2,153.66 158.4,153.86 158.4,153.9 158.41,153.9 158.41,154.61 158.4,154.61 158.18,154.83 157.91,154.83 157.87,154.85 157.85,154.88 157.85,155.62 157.87,155.66 157.91,155.67
GND on TOP (solid shape): 167.79,155.67 167.82,155.66 167.84,155.62 167.84,154.88 167.82,154.85 167.79,154.83 167.01,154.83 166.82,154.64 166.78,154.59 166.78,153.85 166.91,153.72 166.91,153.13 166.83,153.05 166.5,153.05 166.35,153.2 166.35,153.68 166.53,153.86 166.53,153.9 166.53,153.9 166.53,154.61 166.53,154.61 166.31,154.83 166.03,154.83 166,154.85 165.98,154.88 165.98,155.62 166,155.66 166.03,155.67
GND on TOP (solid shape): 189.26,60.03 189.26,59.4 188.63,58.76 188.63,56.22 188.12,55.72 187.23,55.72 187.1,55.84 187.1,59.27 187.36,59.53 187.77,59.53 187.79,59.52 187.8,59.51 187.87,59.44 187.97,59.42 188.11,59.41 188.25,59.42 188.4,59.48 188.46,59.63 188.48,59.77 188.47,59.85 188.47,59.87 188.49,59.89 188.75,60.16 189.14,60.16
GND on TOP (solid shape): 184.83,85.54 184.97,85.51 185.11,85.54 186.7,85.54 186.98,85.26 186.98,16.93 187.12,16.79 194.76,16.79 195.25,16.29 195.25,13.56 195.04,13.35 187.95,13.35 186.88,12.91 186.44,11.84 186.44,2.76 106.97,2.76 106.97,35.22 109,35.22 109,4.79 184.94,4.79 184.94,83.56 184.36,84.14 177.96,84.14 177.68,84.42 177.68,85.33 177.88,85.54
GND on TOP (solid shape): 342.5,116.17 342.54,116.15 342.55,116.12 342.55,115.79 342.28,115.52 342,115.52 341.88,115.41 341.73,115.41 341.7,115.42 341.69,115.43 341.62,115.48 341.53,115.5 341.23,115.5 341.15,115.48 341.08,115.43 341.07,115.42 341.03,115.41 340.65,115.03 340.14,115.03 339.88,114.77 339.88,111.22 339.38,110.71 338.87,110.71 338.61,110.96 338.61,115.79 338.87,116.04 339.91,116.04 339.95,116.02 339.96,116.02 340.03,115.97 340.11,115.95 340.42,115.95 340.5,115.97 340.57,116.02 340.58,116.02 340.62,116.04 341.03,116.04 341.15,116.17
GND on TOP (solid shape): 97.82,71.85 97.82,64.35 97.57,64.1 97.57,63.34 97.44,63.21 97.19,63.21 97.06,63.34 97.06,65.11 95.03,67.15 95.03,69.56 95.28,69.81 95.28,70.83 95.68,71.23 95.7,71.24 95.77,71.27 95.83,71.32 95.9,71.35 95.97,71.32 96.47,71.32 96.52,71.81 96.51,71.92 96.6,71.97 97.7,71.97
GND on TOP (solid shape): 158.53,122.9 158.53,120.49 158.27,120.23 158.03,120.23 157.82,120.02 157.82,118.41 157.51,118.1 157.51,112.1 158.27,111.34 158.27,110.96 158.15,110.83 155.41,110.83 155.2,110.62 155.2,109.97 155.06,109.84 154.59,109.84 154.44,109.99 154.44,114.14 154.85,114.54 154.85,117.44 155.23,117.82 155.23,119.85 155.1,119.98 154.34,119.98 154.21,120.11 154.21,122.14 154.46,122.39 155.1,122.39 155.13,122.42 155.15,122.42 155.4,122.53 155.51,122.78 155.51,122.8 155.61,122.9 155.73,122.9 155.86,122.77 155.86,121.68 155.71,121.52 155.71,120.81 155.77,120.74 157.26,120.74 157.33,120.82 157.5,120.82 157.5,120.99 157.51,120.99 157.51,122.9 157.64,123.03 158.4,123.03
GND on TOP (solid shape): 115.98,59.5 115.98,55.94 115.86,55.81 115.78,55.81 115.74,55.83 115.73,55.86 115.73,57.55 115.63,57.55 115.6,57.56 115.58,57.6 115.58,57.65 115.13,57.65 115.13,57.6 115.11,57.56 115.08,57.55 114.98,57.55 114.98,55.86 114.97,55.83 114.93,55.81 114.78,55.81 114.74,55.83 114.73,55.86 114.73,57.55 114.63,57.55 114.6,57.56 114.58,57.6 114.58,57.65 114.13,57.65 114.13,57.6 114.11,57.56 114.07,57.55 113.98,57.55 113.98,55.86 113.97,55.83 113.93,55.81 113.82,55.81 113.57,56.07 113.57,59.53 114.23,60.19 115.3,60.19
GND on TOP (solid shape): 247.2,65.8 247.2,65.6 247.01,65.41 247.01,64.86 248.32,63.55 248.32,62.96 248.95,62.32 251.29,62.32 251.75,61.86 251.75,60.99 251.65,60.9 251.59,60.78 251.59,60.76 251.37,60.54 249.81,60.54 249.69,60.6 249.56,60.62 249.31,60.87 249.31,61.15 248.83,61.64 248.49,61.64 248.16,61.3 247.56,61.3 247.13,61.73 247.13,63.02 247.14,63.02 247.16,63.15 247.14,63.27 247.13,63.28 247.13,63.38 246.43,64.08 246.42,64.11 246.32,64.39 246.04,64.49 246.02,64.5 246,64.51 245.78,64.73 245.78,65.5 246.54,66.26 246.74,66.26
GND on TOP (solid shape): 244.05,23.31 244.05,18.96 243.69,18.61 242.8,18.61 242.61,18.41 242.61,17.99 242.45,17.83 238.25,17.83 238,18.08 238,21.88 241.58,21.88 241.59,21.82 241.6,21.76 241.62,21.7 241.65,21.64 241.68,21.58 241.72,21.54 241.77,21.49 241.82,21.45 241.88,21.42 241.94,21.4 242,21.38 242.06,21.38 242.13,21.38 242.19,21.38 242.25,21.4 242.31,21.42 242.37,21.45 242.42,21.49 242.47,21.54 242.51,21.58 242.54,21.64 242.57,21.7 242.59,21.76 242.6,21.82 242.6,21.88 242.6,21.95 242.59,22.01 242.57,22.07 242.54,22.13 242.51,22.18 242.47,22.23 242.42,22.28 242.37,22.31 242.31,22.34 242.25,22.37 242.19,22.38 242.13,22.39 242.06,22.39 242,22.38 241.94,22.37 241.88,22.34 241.82,22.31 241.77,22.28 241.72,22.23 241.68,22.18 241.65,22.13 241.62,22.07 241.6,22.01 241.59,21.95 241.58,21.88 238,21.88 238,22.74 238.97,23.71 243.64,23.71
GND on TOP (solid shape): 355.22,78.32 355.31,78.26 355.63,77.94 355.63,75.58 355.62,75.55 355.61,75.54 355.58,75.53 353.41,75.53 353.36,75.58 351.9,75.58 351.44,76.04 348.9,76.04 348.77,76.16 348.77,77.41 351.3,77.41 351.3,77.35 351.32,77.3 351.34,77.25 351.36,77.2 351.39,77.16 351.43,77.12 351.48,77.09 351.53,77.07 351.58,77.05 351.63,77.04 351.68,77.04 351.74,77.05 351.79,77.06 351.84,77.08 351.88,77.11 351.93,77.14 351.96,77.18 351.99,77.23 352.01,77.28 352.03,77.33 352.04,77.38 352.04,77.44 352.03,77.49 352.01,77.54 351.99,77.59 351.96,77.63 351.93,77.67 351.88,77.71 351.84,77.74 351.79,77.76 351.74,77.77 351.68,77.78 351.63,77.78 351.58,77.77 351.53,77.75 351.48,77.72 351.43,77.69 351.39,77.65 351.36,77.61 351.34,77.57 351.32,77.51 351.3,77.46 351.3,77.41 348.77,77.41 348.77,78.07 349.03,78.32
GND on TOP (solid shape): 333.52,28.25 333.57,28.16 333.63,28.09 334.22,27.5 334.23,27.47 334.22,27.43 333.59,26.8 333.59,26.33 333.59,26.25 333.62,26.15 333.61,26.12 333.48,26 332.9,26 332.77,26.02 332.66,26 332.65,26 328.84,26 328.65,26.18 328.63,26.22 328.65,26.26 328.74,26.35 328.74,26.88 328.77,26.95 328.83,26.98 329.18,27.29 328.93,27.69 328.87,27.76 328.89,27.85 329.64,28.6 330.08,29.05 332.72,29.05
GND on TOP (solid shape): 159.47,59 159.47,56.16 159.46,56.14 159.43,56.13 159.28,56.13 159.24,56.15 159.23,56.18 159.23,57.55 159.13,57.55 159.1,57.56 159.08,57.59 159.08,57.65 158.63,57.65 158.63,57.59 158.61,57.56 158.58,57.55 158.48,57.55 158.48,56.18 158.47,56.15 158.43,56.13 158.28,56.13 158.24,56.15 158.23,56.18 158.23,57.55 158.13,57.55 158.1,57.56 158.08,57.6 158.08,57.65 157.63,57.65 157.63,57.6 157.61,57.56 157.58,57.55 157.48,57.55 157.48,56.18 157.47,56.15 157.43,56.13 157.26,56.13 157.23,56.16 157.23,57.55 157.18,57.55 157.14,57.56 157.13,57.6 157.13,58.65 157.95,59.47 159.01,59.47
GND on TOP (solid shape): 101.12,31.84 101.12,30.19 102.01,29.3 104.05,29.3 104.43,28.92 104.43,26.76 104.3,26.63 100.62,26.63 100.56,26.69 100.52,26.76 100.48,26.82 100.46,26.88 100.48,26.95 100.58,27.22 100.46,27.47 100.43,27.55 100.46,27.62 100.58,27.88 100.48,28.14 100.45,28.21 100.48,28.28 100.56,28.65 100.28,28.9 100.25,28.91 100.24,28.95 100.24,31.84 100.49,32.09 100.87,32.09
GND on TOP (solid shape): 195.2,151.85 195.2,151.44 193.71,149.95 193.71,148.36 193.39,148.04 193.39,143.8 193.14,143.55 193.14,139.36 193.33,139.18 193.33,132.35 193.13,132.15 193.13,131.93 193.13,131.91 193.11,131.9 193.08,131.84 193.06,131.76 193.05,131.66 193.05,131.61 193.05,131.58 192.53,131.06 192.5,130.58 192.97,130.48 193.08,130.48 193.13,130.39 193.13,129.97 193,129.84 190.72,129.84 190.33,130.24 189.74,130.24 189.62,130.37 189.62,132.98 189.71,133.07 190.79,133.07 191.36,133.07 191.8,133.52 191.8,133.95 192.16,134.3 192.16,139.21 192.09,139.27 192.09,139.3 192.07,139.3 191.68,139.69 191.68,147.98 192.88,149.18 192.88,150.36 193.14,150.62 193.34,150.62 194.29,151.56 194.29,151.77 194.54,152.02 195.03,152.02
GND on TOP (solid shape): 140.11,59.55 140.11,57.6 140.1,57.56 140.06,57.55 139.98,57.55 139.98,56.25 139.86,56.13 139.78,56.13 139.74,56.15 139.73,56.18 139.73,57.55 139.63,57.55 139.6,57.56 139.58,57.59 139.58,57.65 139.13,57.65 139.13,57.59 139.11,57.56 139.08,57.55 138.98,57.55 138.98,56.18 138.97,56.14 138.93,56.13 138.78,56.13 138.74,56.15 138.73,56.18 138.73,57.55 138.63,57.55 138.6,57.56 138.58,57.6 138.58,57.65 138.13,57.65 138.13,57.6 138.11,57.56 138.08,57.55 137.98,57.55 137.98,56.18 137.97,56.15 137.93,56.13 137.78,56.13 137.74,56.15 137.73,56.18 137.73,57.55 137.72,57.55 137.7,57.58 137.7,57.61 137.71,57.63 137.92,57.84 138.38,58.3 138.38,59.29 138.82,59.73 139.94,59.73
GND on TOP (solid shape): outline of 83 points within 252.64,76.93 254.91,79.97
GND on TOP (solid shape): outline of 102 points within 265.22,33.72 271.56,36.16
GND on TOP (solid shape): outline of 103 points within 340.9,116.33 352.08,120.11
GND on TOP (solid shape): outline of 109 points within 187.25,74.89 191.42,84.48
GND on TOP (solid shape): outline of 141 points within 356.62,134.23 365.08,137.25
GND on TOP (solid shape): 349.8,105.72 349.8,105.22 350.3,104.71 350.3,104.1 350.17,103.98 349.73,103.98 349.64,104.02 349.63,104.11 349.65,104.2 349.65,104.29 349.43,104.7 348.98,104.57 348.9,104.53 348.82,104.57 348.38,104.7 348.16,104.29 348.15,104.2 348.17,104.11 348.16,104.02 348.07,103.98 347.7,103.98 347.61,104.02 347.6,104.11 347.62,104.2 347.61,104.29 347.34,104.72 346.9,104.47 346.89,104.45 346.84,104.41 346.81,104.42 346.79,104.45 346.32,104.56 346.14,104.11 346.13,104.02 346.04,103.98 345.73,103.98 345.6,104.1 345.6,104.61 345.98,104.99 345.98,105.5 346.23,105.75 349.76,105.75
GND on TOP (solid shape): outline of 145 points within 205.77,82.48 210,95.19
GND on TOP (solid shape): outline of 142 points within 117.76,119.01 132.37,134.05
GND on TOP (solid shape): 215.33,95.35 215.33,93.14 215.42,93.04 215.42,92.3 215.38,92.22 215.29,92.2 214.82,91.96 215.08,91.5 215.15,91.43 215.13,91.33 215.04,91.24 214.9,91.24 214.9,91.21 214.87,91.13 214.8,91.1 214.77,91.11 214.4,90.78 214.68,90.38 214.71,90.37 214.75,90.37 214.9,90.22 214.9,89.85 214.9,89.83 214.89,89.82 214.89,89.52 214.31,88.93 214.16,88.79 214,88.79 213.85,88.73 213.79,88.58 213.79,88.28 213.83,88.15 213.94,88.07 213.97,88.02 213.97,87.8 213.97,87.79 213.97,87.3 213.95,87.27 213.92,87.25 213.77,87.25 213.77,86.62 213.98,86.62 214.02,86.6 214.03,86.56 214.03,86.26 214,86.23 214.31,85.91 218.62,85.91 218.68,85.97 218.68,86.6 218.8,86.73 219.08,86.73 219.23,86.58 219.23,80.74 218.29,79.8 215.09,79.8 214.84,80.05 214.84,82.41 215.09,82.67 216.04,82.67 216.47,83.09 216.47,83.99 216.11,84.34 214.87,84.34 214.69,84.16 213.95,84.16 213.8,84.32 213.8,85.13 213.52,85.41 212.81,85.41 212.5,85.71 212.5,88.05 213.14,88.69 213.14,90.77 213.77,91.4 213.77,95.44 213.9,95.56 215.11,95.56
GND on TOP (solid shape): 198.44,9.55 198.44,9.55 198.68,9.3 200.53,7.46 202.72,7.46 204.5,5.68 204.5,3.17 206.15,1.52 208.35,1.52 210.73,3.9 212.12,3.9 212.9,3.12 212.9,1.51 213.3,1.11 225.41,1.11 225.91,1.61 225.91,3.32 226.24,3.65 232.7,3.65 233.82,2.52 263.18,2.52 264.34,2.29 265.32,1.64 265.44,1.52 268.17,1.52 268.29,1.64 269.27,2.29 270.43,2.52 295.18,2.52 296.34,2.29 297.32,1.64 297.44,1.52 336.93,1.52 337.09,1.36 337.09,0.76 336.84,0.51 297.43,0.51 297.05,0.58 296.73,0.8 296.6,0.92 295.95,1.36 295.18,1.51 270.43,1.51 269.66,1.35 269.01,0.92 268.89,0.8 268.56,0.58 268.18,0.51 265.43,0.51 265.05,0.58 264.73,0.8 264.6,0.92 263.95,1.36 263.18,1.51 235.88,1.51 235.3,1.42 234.77,1.17 234.03,0.67 233.76,0.55 233.48,0.51 197.21,0.51 196.86,0.65 196.72,1 196.72,10.34 196.88,10.5 197.48,10.5
GND on TOP (solid shape): outline of 136 points within 116.73,56.13 126.49,58.97
GND on TOP (solid shape): 157.51,97.59 157.51,94.04 157.77,93.78 157.77,91.26 157.58,91.07 156.23,91.07 155.86,91.44 155.86,92.45 155.91,92.54 156.02,92.54 156.49,92.62 156.48,93.1 156.46,93.13 156.45,93.17 156.51,93.75 155.92,93.8 155.88,93.84 155.86,93.89 155.86,94.36 155.91,94.45 156.02,94.44 156.49,94.53 156.48,95.01 156.45,95.08 156.48,95.15 156.49,95.63 156.02,95.71 155.91,95.71 155.86,95.8 155.86,96.26 155.91,96.35 156.02,96.35 156.49,96.43 156.48,96.91 156.45,96.98 156.48,97.05 156.49,97.53 156.02,97.62 155.91,97.61 155.86,97.7 155.86,97.98 156.09,98.2 156.11,98.21 156.13,98.21 156.24,98.2 156.34,98.23 156.35,98.23 156.88,98.23
GND on TOP (solid shape): outline of 130 points within 170.71,56.13 178.47,59.65
GND on TOP (solid shape): 162.59,97.09 162.59,94.17 162.85,93.91 162.85,91.16 162.62,90.93 160.99,90.93 160.82,91.1 160.82,91.49 160.81,91.5 160.81,91.87 160.87,91.97 160.98,91.95 161.6,92.22 160.98,92.49 160.87,92.47 160.81,92.57 160.81,93.14 160.87,93.24 160.98,93.22 161.49,93.23 161.51,93.74 161.48,93.81 161.51,93.88 161.49,94.39 160.98,94.4 160.87,94.38 160.81,94.47 160.81,95.05 160.87,95.14 160.98,95.12 161.49,95.13 161.51,95.64 161.48,95.71 161.51,95.78 161.49,96.29 160.98,96.3 160.87,96.28 160.81,96.38 160.81,96.95 160.87,97.05 160.98,97.03 161.45,97 161.57,97.45 161.58,97.55 161.66,97.59 162.08,97.59
GND on TOP (solid shape): outline of 201 points within 230.99,132.12 248.42,154.89
GND on TOP (solid shape): outline of 99 points within 340.77,109.56 347,115.41
GND on TOP (solid shape): outline of 170 points within 160.23,56.13 170.63,60.34
GND on TOP (solid shape): outline of 177 points within 126.89,56.13 137.43,59.6
GND on TOP (solid shape): outline of 313 points within 179.71,140.17 190.35,153.53
GND on TOP (solid shape): outline of 351 points within 137.07,142.17 179.23,156.17
GND on TOP (solid shape): outline of 479 points within 191.29,62.16 227.31,77.57
GND on TOP (solid shape): outline of 872 points within 0.51,0.51 186.44,117.58
GND on TOP (solid shape): outline of 1197 points within 206.2,103.43 220.82,119.27
GND on TOP (solid shape): outline of 1359 points within 327.62,16.22 369.97,155.2
GND on TOP (solid shape): outline of 303 points within 0.51,66.05 313.23,161.49
GND on TOP (solid shape): outline of 1418 points within 156.62,39.46 178.48,48.86
GND on TOP (solid shape): outline of 1962 points within 111.87,39.97 140.62,49.11
GND on BOTTOM (solid shape): 24.68,117.07 24.68,115.27 24.63,115.22 23.24,115.22 23.11,115.34 23.11,116.99 23.24,117.12 24.63,117.12
GND on BOTTOM (solid shape): 24.95,53.25 24.95,51.2 24.8,51.04 24.34,51.04 24.26,51.12 24.26,53.18 24.44,53.35 24.85,53.35
GND on BOTTOM (solid shape): 211.89,110.81 211.89,110.43 210.93,109.46 210.57,109.46 210.45,109.59 210.45,109.77 211.61,110.94 211.77,110.94
GND on BOTTOM (solid shape): 222.66,55.46 222.66,51.14 222.03,50.51 221.39,50.51 221.01,50.89 221.01,55.72 221.14,55.84 222.28,55.84
GND on BOTTOM (solid shape): 241.33,143.57 241.33,142.55 241.08,142.3 234.6,142.3 234.47,142.43 234.47,143.7 234.6,143.82 241.08,143.82
GND on BOTTOM (solid shape): 337.09,3.9 337.09,2.38 336.96,2.25 334.8,2.25 334.55,2.5 334.55,3.77 334.8,4.03 336.96,4.03
GND on BOTTOM (solid shape): 348.01,33.87 348.01,30.44 347.81,30.24 346.69,30.24 346.62,30.32 346.62,33.87 346.74,34 347.89,34
GND on BOTTOM (solid shape): 360.59,60.92 360.59,56.48 360.46,56.35 356.14,56.35 356.01,56.48 356.01,60.92 356.14,61.05 360.46,61.05
GND on BOTTOM (solid shape): 200.62,45.18 200.62,43.42 200.25,43.06 198.37,43.06 198.28,43.14 198.28,44.41 199.3,45.43 200.36,45.43
GND on BOTTOM (solid shape): 295.69,23.33 295.69,21.55 295.23,21.1 291.22,21.1 290.99,21.33 290.99,23.03 291.42,23.46 295.56,23.46
GND on BOTTOM (solid shape): 343.19,56.61 343.19,52.8 341.41,51.02 338.36,51.02 336.58,52.8 336.58,56.35 338.11,57.88 341.92,57.88
GND on BOTTOM (solid shape): 128.3,118.84 128.3,116.04 128.56,115.79 128.56,115.28 128.43,115.15 125.89,115.15 124.87,116.17 124.87,118.71 125.13,118.96 128.18,118.96
GND on BOTTOM (solid shape): 170.72,158.46 170.72,156.43 169.96,155.67 166.02,155.67 165.39,156.3 165.39,158.59 165.77,158.97 170.21,158.97
GND on BOTTOM (solid shape): 178.42,146.12 178.42,144.59 178.29,144.46 177.93,144.46 177.81,144.59 177.81,146.14 177.91,146.24 178.29,146.24
GND on BOTTOM (solid shape): 209.97,108.73 209.97,108.63 208.75,107.41 208.65,107.41 208.37,107.69 208.37,107.87 209.4,108.9 209.41,108.91 209.79,108.91
GND on BOTTOM (solid shape): 219.81,49.68 219.81,48.17 219.23,47.59 217.46,47.59 217.33,47.72 217.33,49.62 217.58,49.87 219.62,49.87
GND on BOTTOM (solid shape): 222.51,14.33 222.51,13.06 222.37,12.92 219.26,12.92 218.87,13.31 218.87,14.44 219.02,14.59 222.25,14.59
GND on BOTTOM (solid shape): 346.62,19.27 346.62,17.39 346.49,17.27 345.57,17.27 345.35,17.49 345.35,19.37 344.66,20.06 344.66,20.36 344.71,20.41 345.47,20.41
GND on BOTTOM (solid shape): 126.19,125.9 126.19,125.41 126.04,125.26 124.44,125.26 124.34,125.36 124.34,125.9 124.52,126.07 125.2,126.07 125.2,126.07 126.02,126.07
GND on BOTTOM (solid shape): 157.13,135.03 157.13,132.23 156.88,131.98 155.42,131.98 154.78,131.35 153.45,131.35 153.32,131.47 153.32,135.03 153.58,135.28 156.88,135.28
GND on BOTTOM (solid shape): 195.49,26.1 195.49,23.46 195.1,23.08 190.05,23.08 189.88,23.24 189.88,26.24 190.07,26.43 195.15,26.43
GND on BOTTOM (solid shape): 187,66.89 186.75,66.64 185.1,66.64 184.97,66.77 184.97,84.04 109.02,84.04 109.02,57.52 106.99,57.52 106.99,86.07 187,86.07
GND on BOTTOM (solid shape): 228.38,41.06 228.38,38.37 228.96,37.78 230,37.78 230.08,37.71 230.08,35.14 229.88,34.94 227.62,34.94 227.34,35.22 227.34,41.14 227.49,41.29 228.15,41.29
GND on BOTTOM (solid shape): 334.47,60.92 334.47,60.34 334.68,60.14 334.68,59.52 334.43,59.27 332.14,59.27 331.76,59.65 331.76,61.05 331.88,61.18 334.22,61.18
GND on BOTTOM (solid shape): 350.04,58.51 350.04,58.26 350.55,57.75 353.6,57.75 353.73,57.62 353.73,57.37 353.6,57.24 349.28,57.24 349.16,57.37 349.16,58.51 349.28,58.64 349.92,58.64
GND on BOTTOM (solid shape): 358.69,92.48 358.69,91.57 358.52,91.4 357.21,91.4 356.92,91.69 355.11,91.69 354.88,91.92 354.88,92.45 355.1,92.67 358.49,92.67
GND on BOTTOM (solid shape): 228.07,153.02 228.07,151.6 227.67,151.2 221.42,151.2 221.19,151.42 221.19,152.99 221.37,153.17 227.93,153.17
GND on BOTTOM (solid shape): 40.67,51.25 40.67,49.75 40.8,49.62 43.09,49.62 43.53,49.18 43.53,47.78 43.09,47.33 37.94,47.33 37.94,47.34 37.34,47.34 37.24,47.44 37.24,50.79 37.78,51.32 40.6,51.32
GND on BOTTOM (solid shape): 191.65,140.45 191.65,135.5 191.43,135.28 191.42,135.28 191.23,135.09 191.04,135.09 190.33,135.8 190.33,140.35 190.66,140.68 191.42,140.68
GND on BOTTOM (solid shape): 205.65,159.09 205.65,156.84 205.81,156.68 205.81,156.67 207.04,155.43 207.04,153.25 206.14,152.35 204.38,152.35 204.01,152.72 204.01,159.11 204.12,159.22 205.52,159.22
GND on BOTTOM (solid shape): 229.78,52.26 229.78,50.13 229.39,49.75 228.48,49.75 228.36,49.86 228.36,50.79 228.23,50.92 227.84,50.92 227.62,51.14 227.62,52.54 227.87,52.8 229.24,52.8
GND on BOTTOM (solid shape): 192.36,82.69 192.36,82.69 193.21,82.69 193.36,82.53 193.36,80.57 193.38,80.56 193.38,80.45 193.22,80.3 192.64,80.3 192.19,79.85 189.46,79.85 189.26,80.05 189.26,82.62 189.63,82.98 192.07,82.98
GND on BOTTOM (solid shape): 108.92,37.86 108.92,30.7 108.88,30.66 108.88,15.06 108.57,14.75 107.58,14.75 106.99,15.33 106.99,26.18 106.97,26.2 106.97,30.09 106.28,30.77 106.28,38.01 106.86,38.59 108.19,38.59
GND on BOTTOM (solid shape): 126.96,114.09 126.96,113.73 126.83,113.6 126.16,113.6 126.06,113.5 126.05,113.5 125.75,113.2 125.28,113.2 125.18,113.3 125.67,114.16 126.88,114.16
GND on BOTTOM (solid shape): 186.98,63.84 186.98,48.35 187.21,48.12 188.14,48.12 188.14,48.11 189.83,48.11 190.46,47.49 190.46,45.46 190.76,45.15 190.76,43.5 190.66,43.4 185.48,43.4 185.07,43.8 185.07,63.97 185.33,64.23 186.6,64.23
GND on BOTTOM (solid shape): 205.47,37.48 205.47,34.41 205.09,34.03 202.17,34.03 201.56,34.63 201.56,34.97 201.99,35.4 201.99,36.74 201.02,37.71 199.75,37.71 199.68,37.78 199.68,37.91 199.73,37.96 204.98,37.96
GND on BOTTOM (solid shape): 362.49,89.37 362.49,87.21 362.24,86.96 356.78,86.96 356.52,87.21 356.52,88.04 357.19,88.71 358.44,88.71 358.5,88.78 358.6,88.83 358.66,88.93 359.35,89.63 362.24,89.63
GND on BOTTOM (solid shape): 213.88,115.82 213.88,115.59 212.84,114.56 212.77,114.52 212.71,114.48 212.65,114.41 212.61,114.33 212.61,114.32 210.83,112.54 210.55,112.54 210.45,112.64 210.45,112.9 213.48,115.93 213.76,115.93
GND on BOTTOM (solid shape): 217.43,118.15 217.43,118.02 216.17,116.76 216.06,116.76 215,115.7 214.99,115.69 214.88,115.62 214.8,115.51 214.59,115.51 214.49,115.62 214.49,115.74 217.02,118.28 217.3,118.28
GND on BOTTOM (solid shape): 186.47,158.08 186.47,155.74 186.06,155.34 186.06,154.52 186.85,153.74 186.85,152.74 186.47,152.36 186.43,152.36 185.67,151.6 185.67,150.61 185.44,150.39 185.19,150.39 185.19,150.39 185.19,151.86 184.95,152.1 184.95,154.4 184.94,154.4 184.56,154.78 184.56,158.08 184.82,158.33 186.21,158.33
GND on BOTTOM (solid shape): 230.92,51.27 230.92,39.66 230.77,39.51 230.23,39.51 230.03,39.71 230.03,40.86 229.89,41 229.88,41.01 229.81,41.12 229.7,41.19 229.69,41.2 229.27,41.62 229.27,49.37 230.03,50.13 230.03,51.27 230.16,51.4 230.79,51.4
GND on BOTTOM (solid shape): 247.97,137.65 247.97,133.26 246.65,131.94 241.05,131.94 240.82,132.18 240.82,132.19 239.54,133.47 239.09,133.47 238.62,133.95 238.62,135.34 237.69,136.27 237.69,138.17 237.95,138.44 238.93,138.44 238.94,138.45 242.32,138.45 243,139.12 246.5,139.12
GND on BOTTOM (solid shape): 192.32,144.22 192.81,144.22 192.86,144.17 192.86,143.69 192.8,143.63 192.39,143.63 192.13,143.37 192.13,141.82 192.28,141.66 192.95,141.66 193.08,141.54 193.08,140.93 192.86,140.71 191.73,140.71 191.5,140.93 191.5,144.07 191.8,144.36 192.18,144.36
GND on BOTTOM (solid shape): 214.94,31.84 216.24,31.84 216.34,31.74 216.34,31.26 216.33,31.24 216.33,29.9 215.75,29.33 213.47,29.33 213.29,29.5 213.29,29.83 213.47,30.01 214.28,30.01 214.41,30.14 214.41,30.9 214.31,31 213.85,31 213.42,31.43 213.42,31.84 213.52,31.94 214.84,31.94
GND on BOTTOM (solid shape): 337.19,6.77 337.19,5.6 336.91,5.32 335.59,5.32 335.41,5.5 335.41,6.34 335.58,6.51 335.61,6.5 335.89,6.52 336.07,6.73 336.07,6.74 336.23,6.9 337.06,6.9
GND on BOTTOM (solid shape): 74.73,56.79 74.73,51.68 72.92,49.87 71.83,49.87 71.03,49.08 69.33,49.08 69.03,49.38 69.03,54.01 68.76,54.29 67.61,54.29 67.48,54.42 67.48,56.06 66.53,57.01 66.53,57.87 66.95,58.3 73.23,58.3
GND on BOTTOM (solid shape): 220.91,112.64 220.91,111.86 220.48,111.42 220.48,107.89 220.06,107.48 219.35,107.48 218.4,108.43 218.4,108.78 218.53,108.91 218.7,108.91 218.86,108.76 219.03,108.76 219.47,108.33 219.82,108.33 220.03,108.53 220.03,108.94 219.44,109.52 219.44,109.75 220.15,110.46 220.15,110.87 219.47,111.55 219.47,112.85 219.53,112.91 220.65,112.91
GND on BOTTOM (solid shape): 308.9,37.02 308.9,23.84 311.18,21.55 311.18,19.39 310.93,19.14 309.4,19.14 309.15,19.39 309.15,21.43 307.25,23.33 307.25,27 308.04,27.8 308.04,32.9 308.22,33.08 308.22,34.28 307.57,34.93 307.57,37.01 307.66,37.11 307.71,37.23 307.75,37.28 308.64,37.28
GND on BOTTOM (solid shape): 180.07,133.69 180.1,133.69 180.12,133.67 180.84,132.77 181.79,132.11 181.79,131.16 180.39,129.76 179.1,129.76 178.85,130.01 178.85,133.57 178.98,133.69
GND on BOTTOM (solid shape): 346.38,43.89 347.59,43.89 347.61,43.91 350.4,43.91 350.58,43.73 350.58,43.37 350.46,43.26 345.68,43.26 345.56,43.14 345.25,43.14 345.23,43.16 345.22,43.17 345.16,43.26 345.08,43.33 345.07,43.35 345.06,43.37 345.06,43.57 345.4,43.91 346.36,43.91
GND on BOTTOM (solid shape): 153.72,27.25 154.28,27.25 154.42,27.12 154.42,26.72 153.96,26.26 153.96,24.73 153.58,24.35 146.72,24.35 144.89,22.52 142.27,22.52 142.15,22.65 142.15,26.2 141.71,26.64 141.71,27.07 141.87,27.23 144.35,27.23 144.54,27.04 144.54,26.64 144.69,26.49 146.5,26.49 146.59,26.58 146.59,26.99 146.87,27.27 153.7,27.27

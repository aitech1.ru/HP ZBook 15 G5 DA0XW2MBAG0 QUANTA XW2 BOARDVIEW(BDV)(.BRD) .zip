# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Nets (continued)
+VCC_CORE: C9102.1 C9103.1 C9104.1 C9107.1 C9108.2 C9109.2 C9110.2 C9111.2 C9112.2 C9113.2 C9114.2 C9115.2 C9116.2 C9117.1 C9118.1 C9119.1 C9120.1 C9121.1 C9122.1 C9123.1 C9124.2 C9125.2 C9126.2 C9127.2 C9128.2 C9129.2 C9130.2 C9131.2 C9132.2 C9133.1 C9134.1 C9135.1 C9136.1 C9137.1 C9138.1 C9139.1 C9140.1 C9141.2 C9142.2 C9143.2 C9144.2 C9145.2 C9146.2 C9147.1 C9148.1 C9149.1 C9150.1 C9151.1 C9152.1 C9153.1 C9154.1 C9155.1 C9156.1 C9157.1 C9158.1 C9159.1 C9160.1 C9161.1 C9162.1 C9163.1 C9262.1 C9263.1 C9264.1 C9265.1 C9266.1 C9267.1 C9268.1 C9269.1 C9270.1 C9271.1 C9272.1 C9273.1 C9274.1 C9275.1 C9276.1 C9277.1 C9278.1 C9279.1 C9280.1 C9281.1 C9282.1 C9283.1 C9284.1 C9285.2 C9286.2 C9287.2 C9288.2 C9289.2 C9290.2 C9291.2 C9292.2 C9293.2 C9294.2 C9295.2 C9296.2 C9297.2 C9298.2 C9299.2 C9300.2 PC20023.1 PC20024.1 PC20025.1 PC20026.1 PL20000.2 PL20001.2 PL20002.2 PL20003.2 PR19032.2 PR20005.2 PR20019.2 PR20035.2 PR20050.2 PR26002.1 R9047.2 U9001.AA13(VCC#AA13) U9001.AA31(VCC#AA31) U9001.AA32(VCC#AA32) U9001.AA33(VCC#AA33) U9001.AA34(VCC#AA34) U9001.AA35(VCC#AA35) U9001.AA36(VCC#AA36) U9001.AA37(VCC#AA37) U9001.AA38(VCC#AA38) U9001.AB29(VCC#AB29) U9001.AB30(VCC#AB30) U9001.AB31(VCC#AB31) U9001.AB32(VCC#AB32) U9001.AB35(VCC#AB35) U9001.AB36(VCC#AB36) U9001.AB37(VCC#AB37) U9001.AB38(VCC#AB38) U9001.AC13(VCC#AC13) U9001.AC14(VCC#AC14) U9001.AC29(VCC#AC29) U9001.AC30(VCC#AC30) U9001.AC31(VCC#AC31) U9001.AC32(VCC#AC32) U9001.AC33(VCC#AC33) U9001.AC34(VCC#AC34) U9001.AC35(VCC#AC35) U9001.AC36(VCC#AC36) U9001.AD13(VCC#AD13) U9001.AD14(VCC#AD14) U9001.AD31(VCC#AD31) U9001.AD32(VCC#AD32) U9001.AD33(VCC#AD33) U9001.AD34(VCC#AD34) U9001.AD35(VCC#AD35) U9001.AD36(VCC#AD36) U9001.AD37(VCC#AD37) U9001.AD38(VCC#AD38) U9001.AE13(VCC#AE13) U9001.AE14(VCC#AE14) U9001.AE30(VCC#AE30) U9001.AE31(VCC#AE31) U9001.AE32(VCC#AE32) U9001.AE35(VCC#AE35) U9001.AE36(VCC#AE36) U9001.AE37(VCC#AE37) U9001.AE38(VCC#AE38) U9001.AF29(VCC#AF29) U9001.AF30(VCC#AF30) U9001.AF31(VCC#AF31) U9001.AF32(VCC#AF32) U9001.AF33(VCC#AF33) U9001.AF34(VCC#AF34) U9001.AF35(VCC#AF35) U9001.AF36(VCC#AF36) U9001.AF37(VCC#AF37) U9001.AF38(VCC#AF38) U9001.AG14(VCC#AG14) U9001.AG31(VCC#AG31) U9001.AG32(VCC#AG32) U9001.AG33(VCC#AG33) U9001.AG34(VCC#AG34) U9001.AG35(VCC#AG35) U9001.AG36(VCC#AG36) U9001.AH13(VCC#AH13) U9001.AH14(VCC#AH14) U9001.AH29(VCC#AH29) U9001.AH30(VCC#AH30) U9001.AH31(VCC#AH31) U9001.AH32(VCC#AH32) U9001.AJ14(VCC#AJ14) U9001.AJ29(VCC#AJ29) U9001.AJ30(VCC#AJ30) U9001.AJ31(VCC#AJ31) U9001.AJ32(VCC#AJ32) U9001.AJ33(VCC#AJ33) U9001.AJ34(VCC#AJ34) U9001.AJ35(VCC#AJ35) U9001.AJ36(VCC#AJ36) U9001.AK31(VCC#AK31) U9001.AK32(VCC#AK32) U9001.AK33(VCC#AK33) U9001.AK34(VCC#AK34) U9001.AK35(VCC#AK35) U9001.AK36(VCC#AK36) U9001.AK37(VCC#AK37) U9001.AK38(VCC#AK38) U9001.AL13(VCC#AL13) U9001.AL29(VCC#AL29) U9001.AL30(VCC#AL30) U9001.AL31(VCC#AL31) U9001.AL32(VCC#AL32) U9001.AL35(VCC#AL35) U9001.AL36(VCC#AL36) U9001.AL37(VCC#AL37) U9001.AL38(VCC#AL38) U9001.AM13(VCC#AM13) U9001.AM14(VCC#AM14) U9001.AM29(VCC#AM29) U9001.AM30(VCC#AM30) U9001.AM31(VCC#AM31) U9001.AM32(VCC#AM32) U9001.AM33(VCC#AM33) U9001.AM34(VCC#AM34) U9001.AM35(VCC#AM35) U9001.AM36(VCC#AM36) U9001.AN13(VCC#AN13) U9001.AN14(VCC#AN14) U9001.AN31(VCC#AN31) U9001.AN32(VCC#AN32) U9001.AN33(VCC#AN33) U9001.AN34(VCC#AN34) U9001.AN35(VCC#AN35) U9001.AN36(VCC#AN36) U9001.AN37(VCC#AN37) U9001.AN38(VCC#AN38) U9001.AP13(VCC#AP13) U9001.AP30(VCC#AP30) U9001.AP31(VCC#AP31) U9001.AP32(VCC#AP32) U9001.AP35(VCC#AP35) U9001.AP36(VCC#AP36) U9001.AP37(VCC#AP37) U9001.AP38(VCC#AP38) U9001.K13(VCC#K13) U9001.K14(VCC#K14) U9001.L13(VCC#L13) U9001.L14(VCC#L14) U9001.N13(VCC#N13) U9001.N14(VCC#N14) U9001.N30(VCC#N30) U9001.N31(VCC#N31) U9001.N32(VCC#N32) U9001.N35(VCC#N35) U9001.N36(VCC#N36) U9001.N37(VCC#N37) U9001.N38(VCC#N38) U9001.P13(VCC#P13) U9001.P14(VCC#P14) U9001.P29(VCC#P29) U9001.P30(VCC#P30) U9001.P31(VCC#P31) U9001.P32(VCC#P32) U9001.P33(VCC#P33) U9001.P34(VCC#P34) U9001.P35(VCC#P35) U9001.P36(VCC#P36) U9001.R13(VCC#R13) U9001.R31(VCC#R31) U9001.R32(VCC#R32) U9001.R33(VCC#R33) U9001.R34(VCC#R34) U9001.R35(VCC#R35) U9001.R36(VCC#R36) U9001.R37(VCC#R37) U9001.R38(VCC#R38) U9001.T29(VCC#T29) U9001.T30(VCC#T30) U9001.T31(VCC#T31) U9001.T32(VCC#T32) U9001.T35(VCC#T35) U9001.T36(VCC#T36) U9001.T37(VCC#T37) U9001.T38(VCC#T38) U9001.U29(VCC#U29) U9001.U30(VCC#U30) U9001.U31(VCC#U31) U9001.U32(VCC#U32) U9001.U33(VCC#U33) U9001.U34(VCC#U34) U9001.U35(VCC#U35) U9001.U36(VCC#U36) U9001.V13(VCC#V13) U9001.V14(VCC#V14) U9001.V31(VCC#V31) U9001.V32(VCC#V32) U9001.V33(VCC#V33) U9001.V34(VCC#V34) U9001.V35(VCC#V35) U9001.V36(VCC#V36) U9001.V37(VCC#V37) U9001.V38(VCC#V38) U9001.W13(VCC#W13) U9001.W14(VCC#W14) U9001.W29(VCC#W29) U9001.W30(VCC#W30) U9001.W31(VCC#W31) U9001.W32(VCC#W32) U9001.W35(VCC#W35) U9001.W36(VCC#W36) U9001.W37(VCC#W37) U9001.W38(VCC#W38) U9001.Y29(VCC#Y29) U9001.Y30(VCC#Y30) U9001.Y31(VCC#Y31) U9001.Y32(VCC#Y32) U9001.Y33(VCC#Y33) U9001.Y34(VCC#Y34) U9001.Y35(VCC#Y35) U9001.Y36(VCC#Y36)
+VCC_GT: C9036.1 C9037.1 C9038.1 C9039.1 C9040.1 C9041.1 C9042.1 C9043.1 C9044.1 C9045.1 C9046.1 C9047.1 C9048.1 C9049.1 C9050.1 C9051.1 C9052.1 C9053.1 C9054.1 C9055.1 C9056.1 C9057.1 C9058.1 C9059.1 C9060.1 C9061.1 C9062.1 C9063.1 C9064.1 C9065.1 C9066.1 C9067.1 C9257.1 PC21019.1 PC21020.1 PL2100.2 PL2101.2 PR19040.2 U9001.AT14(VCCGT1) U9001.AT31(VCCGT2) U9001.AT32(VCCGT3) U9001.AT33(VCCGT4) U9001.AT34(VCCGT5) U9001.AT35(VCCGT6) U9001.AT36(VCCGT7) U9001.AT37(VCCGT8) U9001.AT38(VCCGT9) U9001.AU14(VCCGT10) U9001.AU29(VCCGT11) U9001.AU30(VCCGT12) U9001.AU31(VCCGT13) U9001.AU32(VCCGT14) U9001.AU35(VCCGT15) U9001.AU36(VCCGT16) U9001.AU37(VCCGT17) U9001.AU38(VCCGT18) U9001.AV29(VCCGT19) U9001.AV30(VCCGT20) U9001.AV31(VCCGT21) U9001.AV32(VCCGT22) U9001.AV33(VCCGT23) U9001.AV34(VCCGT24) U9001.AV35(VCCGT25) U9001.AV36(VCCGT26) U9001.AW14(VCCGT27) U9001.AW31(VCCGT28) U9001.AW32(VCCGT29) U9001.AW33(VCCGT30) U9001.AW34(VCCGT31) U9001.AW35(VCCGT32) U9001.AW36(VCCGT33) U9001.AW37(VCCGT34) U9001.AW38(VCCGT35) U9001.AY29(VCCGT36) U9001.AY30(VCCGT37) U9001.AY31(VCCGT38) U9001.AY32(VCCGT39) U9001.AY35(VCCGT40) U9001.AY36(VCCGT41) U9001.AY37(VCCGT42) U9001.AY38(VCCGT43) U9001.BA13(VCCGT44) U9001.BA14(VCCGT45) U9001.BA29(VCCGT46) U9001.BA30(VCCGT47) U9001.BA31(VCCGT48) U9001.BA32(VCCGT49) U9001.BA33(VCCGT50) U9001.BA34(VCCGT51) U9001.BA35(VCCGT52) U9001.BA36(VCCGT53) U9001.BB13(VCCGT54) U9001.BB14(VCCGT55) U9001.BB31(VCCGT56) U9001.BB32(VCCGT57) U9001.BB33(VCCGT58) U9001.BB34(VCCGT59) U9001.BB35(VCCGT60) U9001.BB36(VCCGT61) U9001.BB37(VCCGT62) U9001.BB38(VCCGT63) U9001.BC29(VCCGT64) U9001.BC30(VCCGT65) U9001.BC31(VCCGT66) U9001.BC32(VCCGT67) U9001.BC35(VCCGT68) U9001.BC36(VCCGT69) U9001.BC37(VCCGT70) U9001.BC38(VCCGT71) U9001.BD13(VCCGT72) U9001.BD14(VCCGT73) U9001.BD29(VCCGT74) U9001.BD30(VCCGT75) U9001.BD31(VCCGT76) U9001.BD32(VCCGT77) U9001.BD33(VCCGT78) U9001.BD34(VCCGT79) U9001.BD35(VCCGT80) U9001.BD36(VCCGT81) U9001.BE31(VCCGT82) U9001.BE32(VCCGT83) U9001.BE33(VCCGT84) U9001.BE34(VCCGT85) U9001.BE35(VCCGT86) U9001.BE36(VCCGT87) U9001.BE37(VCCGT88) U9001.BE38(VCCGT89) U9001.BF13(VCCGT90) U9001.BF14(VCCGT91) U9001.BF29(VCCGT92) U9001.BF30(VCCGT93) U9001.BF31(VCCGT94) U9001.BF32(VCCGT95) U9001.BF35(VCCGT96) U9001.BF36(VCCGT97) U9001.BF37(VCCGT98) U9001.BF38(VCCGT99) U9001.BG29(VCCGT100) U9001.BG30(VCCGT101) U9001.BG31(VCCGT102) U9001.BG32(VCCGT103) U9001.BG33(VCCGT104) U9001.BG34(VCCGT105) U9001.BG35(VCCGT106) U9001.BG36(VCCGT107) U9001.BH33(VCCGT108) U9001.BH34(VCCGT109) U9001.BH35(VCCGT110) U9001.BH36(VCCGT111) U9001.BH37(VCCGT112) U9001.BH38(VCCGT113) U9001.BJ16(VCCGT114) U9001.BJ17(VCCGT115) U9001.BJ19(VCCGT116) U9001.BJ20(VCCGT117) U9001.BJ21(VCCGT118) U9001.BJ23(VCCGT119) U9001.BJ24(VCCGT120) U9001.BJ26(VCCGT121) U9001.BJ27(VCCGT122) U9001.BJ37(VCCGT123) U9001.BJ38(VCCGT124) U9001.BK16(VCCGT125) U9001.BK17(VCCGT126) U9001.BK19(VCCGT127) U9001.BK20(VCCGT128) U9001.BK21(VCCGT129) U9001.BK23(VCCGT130) U9001.BK24(VCCGT131) U9001.BK26(VCCGT132) U9001.BK27(VCCGT133) U9001.BL15(VCCGT134) U9001.BL16(VCCGT135) U9001.BL17(VCCGT136) U9001.BL23(VCCGT137) U9001.BL24(VCCGT138) U9001.BL25(VCCGT139) U9001.BL26(VCCGT140) U9001.BL27(VCCGT141) U9001.BL28(VCCGT142) U9001.BL36(VCCGT143) U9001.BL37(VCCGT144) U9001.BM15(VCCGT145) U9001.BM16(VCCGT146) U9001.BM17(VCCGT147) U9001.BM36(VCCGT148) U9001.BM37(VCCGT149) U9001.BN15(VCCGT150) U9001.BN16(VCCGT151) U9001.BN17(VCCGT152) U9001.BN36(VCCGT153) U9001.BN37(VCCGT154) U9001.BN38(VCCGT155) U9001.BP15(VCCGT156) U9001.BP16(VCCGT157) U9001.BP17(VCCGT158) U9001.BP37(VCCGT159) U9001.BP38(VCCGT160) U9001.BR15(VCCGT161) U9001.BR16(VCCGT162) U9001.BR17(VCCGT163) U9001.BR37(VCCGT164) U9001.BT15(VCCGT165) U9001.BT16(VCCGT166) U9001.BT17(VCCGT167)
+VCC_IO: C9094.1 C9095.1 C9096.1 C9100.2 C12021.2 C12022.2 EC9013.1 EC9030.1 PJP17000.1 R407.1 R6302.1 R9037.1 R9038.1 U9001.AG12(VCCIO1) U9001.G15(VCCIO2) U9001.G17(VCCIO3) U9001.G19(VCCIO4) U9001.G21(VCCIO5) U9001.H15(VCCIO6) U9001.H16(VCCIO7) U9001.H17(VCCIO8) U9001.H19(VCCIO9) U9001.H20(VCCIO10) U9001.H21(VCCIO11) U9001.H26(VCCIO12) U9001.H27(VCCIO13) U9001.J15(VCCIO14) U9001.J16(VCCIO15) U9001.J17(VCCIO16) U9001.J19(VCCIO17) U9001.J20(VCCIO18) U9001.J21(VCCIO19) U9001.J26(VCCIO20) U9001.J27(VCCIO21)
+VCC_IO_S: PC17008.2 PC17009.1 PC17010.1 PC17011.1 PJP17000.2 PL17001.2 PR17014.2
+VCC_SA: C9068.1 C9069.1 C9070.1 C9076.1 C9077.1 C9078.1 C9079.1 C9080.1 C9086.1 C9087.1 C9255.2 PC21031.1 PC21032.1 PC21033.1 PC21034.1 PL2102.2 PR19047.2 PR26007.1 U9001.J30(VCCSA1) U9001.K29(VCCSA2) U9001.K30(VCCSA3) U9001.K31(VCCSA4) U9001.K32(VCCSA5) U9001.K33(VCCSA6) U9001.K34(VCCSA7) U9001.K35(VCCSA8) U9001.L31(VCCSA9) U9001.L32(VCCSA10) U9001.L35(VCCSA11) U9001.L36(VCCSA12) U9001.L37(VCCSA13) U9001.L38(VCCSA14) U9001.M29(VCCSA15) U9001.M30(VCCSA16) U9001.M31(VCCSA17) U9001.M32(VCCSA18) U9001.M33(VCCSA19) U9001.M34(VCCSA20) U9001.M35(VCCSA21) U9001.M36(VCCSA22)
+VCCA_BCLK: C9231.2 R9265.1 U9002.V19(VCCA_BCLK_1P05)
+VCCA_XTAL: C9246.2 C9306.2 R9262.1 U9002.P2(VCCA_XTAL_1P051) U9002.P3(VCCA_XTAL_1P052)
+VCCAMPHYPLL: C9226.1 C9227.1 R9261.1 U9002.C49(VCCAMPHYPLL_1P051) U9002.D49(VCCAMPHYPLL_1P052) U9002.E49(VCCAMPHYPLL_1P053)
+VCCAPLL: C9230.2 R9263.1 U9002.C1(VCCAPLL_1P054) U9002.C2(VCCAPLL_1P055)
+VCCDPHY_1P24: R17903.1 R17904.1
+VCCDPHY_1P24_P1: C12026.2 C12027.2 R17903.2 U9002.AJ22(VCCDPHY_1P241) U9002.AJ23(VCCDPHY_1P242) U9002.AK22(VCCPRIM_1P241) U9002.AK23(VCCPRIM_1P242)
+VCCDPHY_1P24_P3: C9232.2 R17904.2 U9002.BG5(VCCDPHY_1P243)
+VCCDSW_1.05V: C9222.1 U9002.BG45(VCCDSW_1P051) U9002.BG46(VCCDSW_1P052)
+VCCDUSB: R9257.1 U9002.W22(VCCDUSB_1P051) U9002.W23(VCCDUSB_1P052)
+VCCPLL: C9101.2 C9303.1 R9045.1 U9001.H28(VCCPLL1) U9001.J28(VCCPLL2)
+VCCPLL_OC: C9099.2 C9256.2 C9302.1 R9043.1 R9044.1 U9001.BH13(VCCPLL_OC1) U9001.BJ13(VCCPLL_OC2) U9001.G11(VCCPLL_OC3)
+VCCPRIM_MPHY: C9223.2 R9259.1 U9002.W31(VCCPRIM_MPHY_1P05)
+VCCST: PC19001.1 PC23009.1 PC23010.1 PQ23004.1(S) PR19001.1 PR19002.1 PR19003.1 PR19004.1 PR23016.1 R6187.1 R9000.2 R9018.1 R9019.2 R9034.1 R9045.2 R9046.2 R9302.2 R9303.1 R9304.1 R9305.1 R9309.2 R9311.1 R9317.2 R9318.2
+VCCST_ON: PQ23008.2(G) PR23011.2 PU23001.4(Y)
+VCCSTG: C9098.2 PC23007.1 PC23008.1 PQ23003.1(S) PR23010.1 R9320.1 U9001.G30(VCCSTG1) U9001.H29(VCCSTG2)
+VCCSTG_ON: PQ23005.2(G) PQ23007.2(G) PR23008.2 PU23000.4(Y)
+VCCSTPLL: C9097.2 R9046.1 U9001.H30(VCCST)
+VDD_HDA: C3608.2 R3602.1 R3610.1 U3600.3(HDA_VDDIO)
+VDD_I2S: C3601.2 C3602.2 R3609.1 U3600.19(DVDDIO3) U3600.55(DVDDIO2)
+VDD_IO: C3605.2 R3606.1 U3600.13(DVDDIO)
+VIN: EC9004.1 EC9005.1 EC9008.1 EC9009.1 EC9010.1 EC9012.1 EC9014.1 EC9025.1 EC9026.1 EC9027.1 EC9028.1 EC9031.1 F3000.2 PC11000.2 PC11006.1 PC11008.1 PC11009.1 PC11010.2 PC13003.1 PC13004.1 PC13005.1 PC13020.1 PC13034.1 PC14001.1 PC14002.2 PC14003.1 PC14004.1 PC14005.2 PC15001.2 PC15002.1 PC15003.1 PC15004.1 PC15005.2 PC16003.1 PC17004.1 PC18005.1 PC20001.1 PC20002.1 PC20003.1 PC20004.1 PC20005.1 PC20006.1 PC20007.1 PC20008.1 PC20013.1 PC20014.1 PC20015.1 PC20016.1 PC20017.1 PC20027.1 PC20028.1 PC20029.1 PC20030.1 PC20031.1 PC20037.1 PC20038.1 PC20039.1 PC20040.1 PC20041.1 PC21000.1 PC21001.1 PC21003.1 PC21004.2 PC21005.1 PC21006.1 PC21007.1 PC21008.1 PC21012.1 PC21013.1 PC21015.1 PC21016.2 PC21017.1 PC21018.1 PC21024.1 PC21025.1 PC21026.2 PC21027.1 PC21028.1 PC25010.1 PC25011.1 PC25012.1 PC25013.1 PD11000.1 PD11006.1 PL13002.2 PL13004.2 PL16000.2 PL17000.2 PL18000.2 PQ11000.1(S1) PQ11000.2(S2) PQ11000.3(S3) PQ11001.5(D) PQ11005.1(E1) PQ20000.3(D1#1) PQ20000.4(D1#2) PQ20000.9(D1#3) PQ20001.3(D1#1) PQ20001.4(D1#2) PQ20001.9(D1#3) PQ20002.3(D1#1) PQ20002.4(D1#2) PQ20002.9(D1#3) PQ20003.3(D1#1) PQ20003.4(D1#2) PQ20003.9(D1#3) PR9805.2 PR9806.1 PR11000.2 PR11002.2 PR19008.1 PU13000.1(VIN) PU14000.1(VIN) PU15000.1(VIN) PU21000.1(VIN#1) PU21000.14(VIN#2) PU21001.1(VIN#1) PU21001.14(VIN#2) PU21002.1(VIN#1) PU21002.6(VIN#2)
+VIN_1.05V: PC18001.2 PC18002.2 PC18003.1 PC18004.1 PL18000.1 PR18000.1 PU18000.7(IN#1) PU18000.8(IN#2) PU18000.9(IN#3) PU18000.22(IN#4)
+VIN_1.8VPCU: PC16001.1 PC16002.2 PC16004.2 PC16005.1 PL16000.1 PU16000.1(VIN)
+VIN_3VPCU: PC13016.1 PC13017.1 PC13018.1 PC13019.1 PL13002.1 PU13001.1(VIN)
+VIN_5V_USBSRC: PC13030.1 PC13031.1 PC13032.2 PC13033.2 PL13004.1 PR13016.1 PU13002.7(IN#1) PU13002.22(IN#2)
+VIN_BLIGHT: C3000.1 C3004.1 C3006.1 C3007.1 C3008.2 CON3000.1 CON3000.2 CON3000.3 EC5103.2 EC5104.1 F3000.1
AGND: C3606.1 C3607.1 C3612.1 C3631.1 C3633.1 C3635.2 C3636.2 C3637.1 C3639.1 C3640.1 C3641.2 C3642.1 C3643.2 C3644.2 CON3601.5 EC3601.1 EC3602.1 PAD5.1(GND) PAD9.1(GND) Q3600.1(S) Q3603.1(S) R3626.1 R3627.2 R3628.2 R3640.2 U3600.35(HGNDA) U3600.36(SGNDA) U3600.39(VREF_DAC) U3601.3(GND_3) U3601.9(GND_9) U3601.10(GND_10) U3601.13(GND_13) U3601.19(GND_19) U3601.21(AGND_21) U3601.22(AGND_22) U3601.23(AGND_23) U3601.24(AGND_24) U3601.25(AGND_25) U3601.26(AGND_26) U3601.27(AGND_27) U3601.28(AGND_28) U3601.29(AGND_29) U3601.30(AGND_30) VC3600.2 VC3601.2 VC3602.2 VC3603.2
AGND_1.05V: PC18000.1 PC18015.2 PR18005.2 PR18010.1 PR18013.1 PR18014.2 PU18000.4(AGND)
DV33_18: C7320.1 U7301.18(DV33_18)

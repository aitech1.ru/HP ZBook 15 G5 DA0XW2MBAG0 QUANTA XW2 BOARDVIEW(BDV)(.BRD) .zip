# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ACZ_SYNC: length 8.9
  BOTTOM w0.102: 255.63,81.1 255.61,81.1 255.23,80.71 U9002.BG13
  BOTTOM w0.114: R9088.2 256.06,87.71 256.06,87.31 v1(256.47,86.91) 256.04,86.48 255.84,86.48 255.38,86.02 255.38,85.59 255.93,85.03 255.93,81.4 255.63,81.1
ACZ_SYNC_AUDIO: length 156.1
  TOP w0.114: v1(346.23,58.38) 346.66,57.96 346.66,52.98 344.82,51.14 344.82,48.2 345.69,47.33 345.69,45.44 346.53,44.59 346.53,42.09 347.14,41.49 347.14,39.9 346.91,39.67 346.91,28.11 346.39,27.59 346.39,17.46 345.35,16.42 345.35,15.66 344.05,14.37 344.05,12.89 343.84,12.68 U3600.59
  IN1 w0.076: v1(346.23,58.38) 345.87,58.02 342.88,58.02 342.44,57.57 342.21,57.57 342.2,57.57 338.58,57.57 338.01,56.99 334.8,56.99 334.55,57.24 332.95,57.24 332.49,57.7 328.61,57.7 327.23,59.07 321.34,59.07 320.61,58.33 307.4,58.33 307.17,58.1 304.71,58.1 303.75,57.15 301.7,57.15 300.83,58.02 300.11,58.02 300.01,57.91 295.44,57.91 294.36,58.99 292.73,58.99 292.04,59.68 291.08,59.68 289.59,61.17 289.59,61.32 285.81,65.1 283.31,65.1 280.93,67.48 280.19,67.48 275.73,71.93 274.75,71.93 272.86,73.83 271.25,73.83 270.29,74.79 270.29,75.7 269.93,76.06 269.72,76.06 261.78,84.01 261.78,84.06 261.13,84.71 259.86,85.98 259.25,85.98 259.16,85.89 258.81,85.89 258.5,86.2 258.5,86.29 257.33,87.45 257.33,88.41 v1(257.41,88.48)
  BOTTOM w0.114: R9088.1 256.83,87.86 257.33,88.36 257.33,88.41 v1(257.41,88.48)
ADP_A_ID: length 2.9
  TOP w0.114: R6240.2 v1(305.64,40.6) 305.59,40.65 PR12024.1 PR12027.2
ADP_A_ID_R: length 63.8
  TOP w0.114: v1(299.5,27.7) 299.5,28.34 300.46,29.3 301.02,29.3 301.66,29.94 301.66,30.7 304.83,33.87 304.83,35.35 305.64,36.16 R6240.1 ; C6039.2 257.98,24.99 v1(257.84,24.86)
  IN4 w0.076: v1(299.5,27.7) 299.19,27.4 291,27.4 290.69,27.09 289.31,27.09 288.63,26.41 286.16,26.41 285.82,26.07 284.26,26.07 282.77,24.58 280.19,24.58 279.69,25.08 278.87,25.08 278.16,24.37 275.32,24.37 274.96,24.02 273.06,24.02 272.55,23.51 269.19,23.51 268.58,24.12 266.3,24.12 263.73,26.68 v1(263.53,26.68) 262.52,25.69 259.21,25.69 258.38,24.86 v1(257.84,24.86)
  BOTTOM w0.114: U6001.E2 265.65,26.6 265.19,26.6 265,26.42 263.8,26.42 v1(263.53,26.68)
ADP_DET: length 42.6
  IN4 w0.076: v1(267.76,31.83) 266.79,30.85 265.89,30.85 264.95,29.92 264.95,29.33 264.31,28.68 262.04,28.68 261.34,27.98 258.93,27.98 257,26.05 255.73,26.05 254.46,24.78 251.76,24.78 249.68,22.7 249.68,19.4 250.55,18.52 250.55,14.9 250.04,14.39 250.04,9.44 249.84,9.23 v1(249.69,9.23)
  BOTTOM w0.114: v1(249.69,9.23) 249.94,8.98 PR11025.1 PR11027.1 250.34,10.5 250.21,10.64 250.21,11.24 249.26,12.19 PU11000.5 ; U6001.M5 267.92,31.68 v1(267.76,31.83)
ADP_ID_CHK: length 34.2
  TOP w0.114: PR12026.2 295.3,31.96 v1(294.55,31.21) 294.25,31.5 v1(294.25,32.17) 294.22,32.2 294.22,36.35 292.64,37.94 291.75,37.94 PQ12008.2 ; R6407.2 274.99,35.07 v1(274.78,35.27)
  IN1 w0.076: v1(274.78,35.27) 274.78,34.84 275.72,33.9 277.96,33.9 278.94,32.91 279.45,32.91 281.44,30.93 287.26,30.93 288.73,32.4 294.02,32.4 v1(294.25,32.17)
ADP_PRES_OUT: length 276.3
  TOP w0.114: v1(270.9,19.14) 270.79,19.14 R6017.2
  IN1 w0.076: v1(273.85,44.24) 273.47,44.62 272.85,44.62 272.39,44.16 271.61,44.16 270.96,44.81 268.24,44.81 267.68,45.37 267,45.37 264.19,48.17 v1(264.19,49.49)
  IN2 w0.089: v1(177.45,19.37) 177.88,18.94 180.47,18.94 181.8,20.27 191.25,20.27 191.9,20.92 198.86,20.92 199.05,20.73 205.3,20.73 205.78,20.25 214.49,20.25 215.99,21.75 218.36,21.75 223.13,26.52 232.13,26.52 234.26,28.65 236.62,28.65 237.92,29.95 244.79,29.95 250.53,35.7 251.13,35.7 251.36,35.92 251.36,36.29 252.13,37.07 252.13,37.15 253.21,38.22 253.76,38.22 254.31,38.78 255.76,38.78 257.99,41.01 257.99,43.49 263.37,48.87 263.56,48.87 v1(264.19,49.49) 264.19,50.64 263.68,51.14 263.68,51.64 267.4,55.36 268.11,55.36 268.88,56.13 268.88,57.61 270.42,59.15 270.42,61.44 270.31,61.54 270.31,61.54 270.16,61.69 270.16,62.45 270.64,62.93 270.64,67.2 269.21,68.63 269.21,69.42 v3(268.24,70.4) ; v1(273.85,44.24) 273.37,43.75 273.37,39.93 275.75,37.55 275.75,36.41 275.17,35.84 275.17,34.18 274.2,33.21 274.2,28.85 273.6,28.25 273.6,27.89 274.74,26.75 274.74,23.85 273.67,22.77 273.67,22.14 270.9,19.37 v1(270.9,19.14)
  IN4 w0.076: v1(217.86,77.74) 217.86,78.42 217.19,79.1 205.35,79.1 204.63,78.37 201.17,78.37 200.72,78.83 190.75,78.83 189.2,77.28 189.2,69.52 188.51,68.83 188.51,62.28 190.38,60.41 190.38,44.7 189.5,43.82 189.5,30.08 185.6,26.18 183.13,26.18 177.45,20.5 v1(177.45,19.37)
  BOTTOM w0.102: v3(268.24,70.4) 268.03,70.18 267.19,70.18 267.16,70.16 265.69,70.16 265.55,70.01 U9002.BG42
  BOTTOM w0.114: R9090.1 269.89,70.86 269.35,70.32 268.76,70.32 268.69,70.4 v3(268.24,70.4) ; R2143.2 218.98,79.36 217.86,78.25 v1(217.86,77.74)
ADP_PRES_OUT_R: length 8
  TOP w0.114: v3(269.54,26.62) 269.09,26.17 269.09,23.64 269.35,23.38 270.02,23.38 270.29,23.11 270.29,21.93 269.98,21.63 v1(269.98,21.43) 269.98,20.97 270.29,20.66 R6017.1
  BOTTOM w0.114: U6001.F7 v3(269.54,26.62)
ALS_DET#: length 334.4
  IN2 w0.089: v1(272.96,54.95) 270.76,52.76 270.09,52.76 268.71,51.37 268.71,49.27 267.45,48.01 267.45,46.91 264.95,44.41 263.61,44.41 260.82,41.62 260.82,39.84 260.34,39.36 260.34,38.06 260.19,37.92 260.19,37.91 258.32,36.03 255.82,36.03 251.36,31.57 251.36,31.26 247.75,27.65 238.82,27.65 237.57,26.39 235.19,26.39 233.06,24.27 224.13,24.27 219.33,19.46 216.91,19.46 213.1,15.66 207.19,15.66 204.37,18.48 196.55,18.48 195.97,17.9 182.63,17.9 181.05,16.32 176.03,16.32 175.12,15.41 163.87,15.41 162.42,16.86 107.97,16.86 107.15,16.04 104.48,16.04 104.17,16.35 103.54,16.35 103.28,16.09 101.29,16.09 97.83,19.55 97.83,38.38 93.95,42.26 93.44,42.26 91.6,44.1 91.6,46.83 88.94,49.48 74.95,49.48 73.97,48.5 69.18,48.5 67.88,47.2 66.54,45.87 63.08,45.87 60.44,43.22 33.61,43.22 29.62,47.21 26.83,47.21 26.58,46.95 25.48,46.95 v1(24.49,47.94)
  IN4 w0.076: v1(272.96,54.95) 272.15,54.95 271.42,55.69 266.3,55.69 265.77,56.22 265.46,56.22 263.94,57.75 263.94,58.89 261.25,61.58 v3(259.77,61.58)
  BOTTOM w0.089: U9002.AF47 259.92,61.44 v3(259.77,61.58)
  BOTTOM w0.114: v1(24.49,47.94) 21.17,51.26 CON3002.10 ; v1(272.96,54.95) 273.14,54.77 R9382.1 273.82,54.23 R9380.1
ALS_INT#: length 11.3
  BOTTOM w0.114: CON3002.9 20.37,59.35 20.37,59.35 20.37,61.69 19.34,62.71 R3094.1 R3093.2 21.32,63.98 v1(21.32,64.45) 21.32,65.09 20.99,65.42 19.72,65.42 19.59,65.29 U3011.2
AMBER_BATLED#: length 251.4
  TOP w0.114: v1(360.59,150.59) 361.64,151.64 R6095.1
  IN1 w0.076: v1(362.11,100.6) 362.81,100.6 363.63,101.42 363.63,104.41 362.04,106 361.86,106.18 361.86,108.92 360.33,110.45 360.33,111.84 360.39,111.9 360.39,113.04 360.94,113.59 361.19,113.59 361.51,113.91 361.51,115.01 361.04,115.47 360.28,115.47 359.76,115.99 359.76,118.5 360.14,118.88 360.14,119.55 359.63,120.06 359.63,122.81 358.85,123.6 357.56,124.88 357.56,126.3 355.38,128.49 346.44,128.49 343.52,131.41 342.85,132.08 342.37,132.56 342.37,134.66 343.31,135.6 343.31,138.17 344.17,139.03 349.16,139.03 352.97,142.84 352.97,145.51 355.51,148.05 358.05,148.05 v1(360.59,150.59)
  IN3 w0.089: v1(273.34,36.54) 273.83,37.04 275.82,37.04 277.01,35.84 282.9,35.84 283.33,35.41 286.06,35.41 286.84,34.63 296.61,34.63 298.91,32.32 300.9,32.32 302.21,31.02 304.1,31.02 305.01,30.1 307.53,30.1 309.83,27.8 320.02,27.8 320.85,26.96 327.82,26.96 328.91,28.06 329.99,28.06 332.26,30.33 332.26,30.98 333.43,32.15 335.18,32.15 335.97,31.36 336.4,31.36 337.45,30.32 340.52,30.32 341.18,30.98 344.11,30.98 346.03,32.9 348.02,32.9 349.53,34.41 349.53,35.52 349.79,35.78 350.9,35.78 352.3,37.17 355.77,37.17 356.59,37.99 356.59,40.37 356.84,40.62 356.84,41.51 363.58,48.24 363.58,62.9 363.94,63.27 363.94,64.34 362.43,65.85 362.43,68.3 361.05,69.68 361.05,82.57 363.06,84.58 363.06,99.65 v1(362.11,100.6)
  BOTTOM w0.114: v1(273.34,36.54) 273.41,36.46 273.41,34.61 273.08,34.27 273.08,33.99 272.95,33.86 VC6001.1 272.57,33.62 271.02,32.07 271.02,31.31 270.85,31.13 270.85,30.52 270.52,30.19 U6001.L9
AMP_BEEP: length 4.8
  TOP w0.114: U3600.48 343.71,8.28 344.38,7.61 344.38,6.31 344.96,5.73 v1(344.96,5.53) 345.14,5.35 C3621.2
AMP_BEEP_L: length 6.3
  TOP w0.114: C3621.1 347.25,5.35 v1(347.55,5.65) 349.29,7.39 C3626.2 R3631.2 R3630.1
AMP_CLK: length 4
  TOP w0.254: U3601.8 351.95,26 351.83,26.12 R3639.2 352.45,26.52 v1(352.45,26.3) U3601.7
AMP_DATA_A: length 3.5
  TOP w0.114: U3606.1 202.2,157.68 202.34,157.82 R3678.2 202.84,157.66 202.74,157.56 202.74,157.13 v1(202.6,156.99) 202.17,156.99 201.86,156.68 R3652.1
AMP_DATA_B: length 3.6
  TOP w0.114: U3606.3 202.22,158.98 202.36,158.84 R3679.2 202.84,158.6 203.11,158.33 v1(204.5,158.33)
AMP_DATAO_BOT_LEFT: length 21.2
  TOP w0.114: R3679.1 v1(203.62,159.47)
  IN1 w0.076: v3(219.48,157.05) 219.23,156.81 204.25,156.81 203.87,157.19 203.87,159.22 v1(203.62,159.47)
  BOTTOM w0.102: 219.62,157.05 219.73,157.05 220.25,157.57 220.7,157.57 U3603.A3
  BOTTOM w0.114: TP3608.1 v3(219.48,157.05) 219.62,157.05
AMP_DATAO_TOP_RIGHT: length 9.6
  TOP w0.114: R3678.1 203.62,156.94 203.23,156.55 202.5,156.55 202.12,156.17 201.37,156.17 199.8,154.61 199.47,154.61 198.95,154.1 198.95,153.29 TP3607.1 198.69,153.02 v3(198.69,152.47)
  BOTTOM w0.114: v3(198.69,152.47) 199.09,152.87 199.27,152.87 199.38,152.99 U3602.A3
AMP_LINEOUT_L: length 20.3
  TOP w0.254: v1(348.88,21.35) 348.86,21.37 R3636.2 ; R3641.2 356.63,9.04 356.39,8.8 355.54,8.8 355.17,9.17 v1(355.17,9.82)
  IN1 w0.254: v1(348.88,21.35) 349.49,21.35 351.24,19.6 351.92,19.6 352.61,18.91 353.88,18.91 356.09,16.7 356.09,14.52 354.72,13.15 354.72,11.17 355.17,10.71 v1(355.17,9.82)
AMP_LINEOUT_R: length 31
  TOP w0.254: R3637.2 349.57,25.9 v1(350.22,25.24) ; v1(351.49,4.08) 351.79,3.78 R3642.2
  IN1 w0.254: v1(350.22,25.24) 350.4,25.07 350.4,22.01 351.97,20.44 351.97,20.11 352.84,19.24 355.05,19.24 356.75,17.54 356.75,14.21 355.86,13.32 355.86,9.44 354.91,8.49 354.91,5.16 353.83,4.08 v1(351.49,4.08)
AOZ1331_1V8AON_PWREN: length 3.6
  TOP w0.114: PU9501.5 196.01,83.5 196.12,83.39 196.12,82.17 PR9501.1 PC9509.1
AOZ1331_1V8MAIN_PWREN: length 50.7
  TOP w0.178: v1(194.48,82.62) 194.48,82.74 195.21,83.48 PU9501.3
  TOP w0.381: PR9504.2 PC9508.1 v1(194.48,82.62)
  IN4 w0.203: v1(226.32,77.43) 224.57,77.43 224.34,77.66 219.33,77.66 219.27,77.72 218.05,78.95 217.34,79.65 205.33,79.65 204.58,78.89 201.56,78.89 201.38,79.08 193.32,79.08 192.87,79.53 192.87,79.65 192.77,79.75 192.77,80.9 v1(194.48,82.62)
  BOTTOM w0.114: v1(226.32,77.43) 227.06,78.17 227.06,78.99 PR26018.2 ; v1(196.83,86.07) 197.19,85.71 PD9501.2
  BOTTOM w0.381: v1(194.48,82.62) 194.47,82.62 194.47,83.78 194.67,83.99 196.3,83.99 PD9501.2
AUD_AZACPU_SCLK: length 107.7
  TOP w0.114: v1(232.42,82.51) 233.8,83.9 v1(240.72,83.9)
  IN4 w0.076: v1(175.82,120.06) 176.24,120.48 178.21,120.48 179.41,121.68 181.36,121.68 181.79,121.25 182.02,121.25 182.91,122.14 182.91,122.52 183.99,123.6 189.7,123.6 190.07,123.98 191.65,123.98 193.78,121.85 193.78,107.97 194.67,107.07 194.67,95.86 195.36,95.17 195.36,91.41 196.95,89.81 196.95,88.05 201.72,83.28 201.72,82.44 202.83,81.33 204.14,81.33 204.46,81.65 217.83,81.65 220.07,79.4 224.02,79.4 224.7,80.09 225.1,80.09 226.7,81.69 231.59,81.69 v1(232.42,82.51)
  BOTTOM w0.112: v1(175.82,120.06) 175.49,119.74 U9001.G27
  BOTTOM w0.114: R9091.2 240.77,83.9 v1(240.72,83.9)
AUD_AZACPU_SCLK_R: length 8.2
  BOTTOM w0.114: U9002.AM3 246.77,78.86 246.54,79.1 246.54,79.6 245.8,80.33 245.79,80.33 245.78,80.34 245.4,80.34 244.67,81.07 244.67,81.94 243.22,83.38 v1(242.62,83.38) R9091.1
AUD_AZACPU_SDI: length 99.7
  TOP w0.114: v1(245.4,80.94) 244.25,82.08 244.25,82.34 243.12,83.47 233.98,83.47 232.59,82.09 231.79,82.09 v1(231.01,81.31)
  IN4 w0.076: v1(190.82,123.6) 191.38,123.6 193.32,121.66 193.32,107.78 194.29,106.81 194.29,95.7 194.98,95.02 194.98,90.93 196.09,89.81 196.09,88.26 201.33,83.02 201.33,81.39 202.4,80.33 203.68,80.33 204.62,81.27 217.67,81.27 219.91,79.02 224.17,79.02 224.86,79.71 225.26,79.71 226.86,81.31 v1(231.01,81.31)
  BOTTOM w0.114: 247.24,78.61 247.24,78.7 246.82,79.12 246.82,79.63 245.75,80.69 245.65,80.69 v1(245.4,80.94) ; v1(190.82,123.6) 190.67,123.75 R9039.2
AUD_AZACPU_SDI_R: length 16.2
  IN4 w0.076: v1(189.26,124.55) 188.77,124.06 182.85,124.06 181.44,122.65 179.48,122.65 178.09,121.25 176.2,121.25 v1(175.81,121.63)
  BOTTOM w0.114: R9039.1 189.52,124.3 v1(189.26,124.55)
  BOTTOM w0.127: v1(175.81,121.63) 175.81,121.56 U9001.G29
AUD_AZACPU_SDO: length 4.3
  BOTTOM w0.114: U9002.AM2 246.4,78.91 246.15,79.15 246.15,79.66 245.73,80.08 245.69,80.12 245.31,80.12 244.15,81.28 R9087.1
AUD_AZACPU_SDO_R: length 112.9
  TOP w0.114: v1(243.11,82.87) 242.93,83.05 234.15,83.05 232.4,81.31 v1(231.68,81.31)
  IN4 w0.076: v1(175.82,118.49) 176.21,118.88 178.51,118.88 179.19,119.56 179.19,120.75 179.64,121.2 181.25,121.2 181.58,120.87 181.81,120.87 182.23,120.45 183.2,120.45 183.77,121.02 183.77,122.61 184.31,123.14 189.22,123.14 190.2,122.16 192.17,122.16 192.87,121.47 192.87,107.59 193.91,106.54 193.91,95.54 194.6,94.86 194.6,90.77 195.61,89.75 195.61,87.52 198.28,84.85 198.85,84.85 200.95,82.75 200.95,81.24 202.24,79.95 203.84,79.95 204.7,80.81 217.59,80.81 219.76,78.64 224.33,78.64 225.02,79.33 229.7,79.33 v1(231.68,81.31)
  BOTTOM w0.114: R9087.2 243.14,82.87 v1(243.11,82.87)
  BOTTOM w0.127: v1(175.82,118.49) 175.82,118.42 U9001.G25
AUDIOAMPS_CLK: length 260.9
  TOP w0.114: v1(192.34,151.98) 192.19,151.84 R3681.1 192.19,150.72 191.62,150.15 v1(191.62,149.34)
  IN2 w0.089: v1(187.41,38.19) 187.1,38.19 186.25,39.05 186.25,45.13 186.64,45.53 186.64,67.92 183.91,70.65 183.91,82.66 183.31,83.26 183.31,87.14 184.32,88.15 185.12,88.15 187.91,90.94 187.91,92.9 190.75,95.74 190.75,96.82 191.82,97.89 191.82,103.01 192.93,104.11 192.93,118.78 194.03,119.88 194.03,129.31 193.54,129.8 193.54,131.52 192.34,132.72 192.34,148.62 v1(191.62,149.34)
  IN3 w0.089: v1(267.54,36.67) 267.54,37.03 266.65,37.93 258.94,37.93 258.32,37.31 256.46,37.31 256.09,37.68 248.34,37.68 246.95,36.29 244.99,36.29 241.51,32.81 238.63,32.81 232.75,26.93 214.6,26.93 212.37,24.7 191.08,24.7 189.42,23.04 180.48,23.04 179.09,21.64 176.26,21.64 174.27,19.65 v1(174.27,19.42)
  IN4 w0.076: v1(187.41,38.19) 186.85,37.63 186.85,31.02 184.29,28.46 177.37,28.46 175.04,26.13 175.04,24.6 174.27,23.83 v1(174.27,19.42)
  BOTTOM w0.114: Q3602.3 192.68,152.32 v1(192.34,151.98) ; v1(267.54,36.67) 267.54,36.29 267.34,36.08 R6130.2 267.34,33.55 267.7,33.18 268.9,31.98 268.9,30.53 268.57,30.19 U6001.L6
AUDIOAMPS_DAT: length 263.3
  IN2 w0.089: v1(192.31,149.32) 192.68,148.94 192.68,132.86 194.65,130.89 194.65,130.32 194.37,130.04 194.37,119.55 193.27,118.45 193.27,103.97 192.16,102.86 192.16,97.7 191.1,96.64 191.1,95.6 188.25,92.76 188.25,90.8 185.26,87.81 184.46,87.81 183.65,86.99 183.65,83.41 184.25,82.8 184.25,70.9 186.98,68.17 186.98,45.38 186.59,44.99 186.59,42.19 v1(187.41,41.37)
  IN3 w0.089: v1(174.91,19.39) 174.91,19.62 176.41,21.12 179.05,21.12 180.63,22.7 189.57,22.7 191.22,24.35 212.51,24.35 214.74,26.58 232.89,26.58 238.69,32.39 241.85,32.39 245.41,35.94 247.09,35.94 248.49,37.34 255.94,37.34 256.31,36.97 258.46,36.97 259.08,37.59 266.5,37.59 267.08,37.01 267.08,36.5 267.55,36.03 268.42,36.03 v1(269.06,35.38)
  IN4 w0.076: v1(174.91,19.39) 174.73,19.57 174.73,23.83 175.95,25.05 175.95,26.02 178.06,28.13 184.54,28.13 187.78,31.37 187.78,41 v1(187.41,41.37)
  BOTTOM w0.114: v1(269.06,35.38) 269.06,34.36 269.12,34.3 R6131.2 269.12,32.96 269.55,32.53 269.55,30.52 269.22,30.19 U6001.L7 ; v1(192.31,149.32) 191.9,149.72 191.9,149.76 191.88,149.77 191.88,150.32 R3680.1 191.92,151.32 191.92,152.24 192.18,152.5 192.18,153.13 192.44,153.38 193.07,153.38 193.98,154.28 Q3602.6
B/I: length 5.5
  BOTTOM w0.114: PCN12000.3 224.73,5.33 v1(225.08,5.68) PR12013.1 PR12014.2
B_DE: length 5.1
  TOP w0.114: U603.8 59.29,49.87 58.02,48.6 R632.1 57.17,48.1 55.97,48.1 55.64,48.43 R633.2
B_EQ1: length 4.4
  TOP w0.114: v1(65.06,52.54) 65.44,52.16 65.44,51.49 R626.2 R628.1 64.87,50.87 U603.20
B_EQ2: length 8
  TOP w0.114: v1(68.1,45.68) 67.72,45.3 66.45,45.3 66.19,45.57 R627.2 R629.1 65.18,46.19 64.47,46.9 64.47,49.06 64.16,49.37 U603.17
BARREL_ADP_DET: length 208.7
  IN2 w0.089: v1(327.18,29.3) 326.37,30.11 326.11,30.11 325.58,30.64 325.58,31.28 323.65,33.21 323.65,45.24 324.88,46.46 326.73,46.46 327.87,47.6 327.87,48.71 328.13,48.97 328.13,50.7 327.41,51.42 326.8,51.42 326.01,52.21 326.01,53.75 323.79,55.98 323.62,55.98 322.87,56.73 322.87,58.26 322.31,58.82 321.85,58.82 320.03,60.63 318.89,60.63 316.95,62.57 316.95,63.49 317.19,63.73 317.19,69.93 326.8,79.54 326.8,80.13 331.83,85.16 333.25,85.16 334.17,86.07 334.17,91.52 335.54,92.89 335.54,103.83 336.84,105.14 336.84,118.2 334.49,120.55 334.49,124.45 334.5,124.46 334.5,124.5 339.45,129.45 345.88,129.45 350.81,134.39 350.81,135.35 351.95,136.49 v1(351.95,136.5)
  IN4 w0.076: v1(327.18,29.3) 326.8,29.68 325.53,29.68 324.69,28.84 309.47,28.84 308.79,29.52 298.9,29.52 297.8,30.62 290.8,30.62 290.41,31.01 283.37,31.01 282.81,30.45 280.13,30.45 279.75,30.82 278.61,30.82 277.34,29.55 276.59,29.55 274.48,27.45 268.13,27.45 267.91,27.67 267.91,28.25 v3(267.59,28.57)
  BOTTOM w0.114: v1(351.95,136.5) 350.44,138 PR10017.1 349.4,138 349.16,137.76 PR10021.1 348.77,137.01 348.39,137.38 PQ10010.3 ; U6001.H5 v3(267.59,28.57)
BARREL_ADP_EN: length 210.9
  TOP w0.076: 267.01,26.76 266.94,26.69 v3(266.94,26.62)
  TOP w0.114: PQ26006.1 343.47,149.59 344.03,149.03 344.3,149.03 344.66,148.67 PR10023.2 345.54,148.67 345.93,149.06 v1(346.23,149.06) ; v1(267.49,27.22) 267.47,27.22 267.01,26.76
  IN2 w0.089: v1(326.55,29.3) 326.04,29.81 326.04,29.94 325.41,30.57 325.41,31.21 323.48,33.14 323.48,45.31 324.8,46.64 326.66,46.64 327.69,47.68 327.69,48.86 327.95,49.12 327.95,50.63 327.34,51.25 326.73,51.25 325.84,52.14 325.84,53.35 324.05,55.13 323.37,55.13 323,55.5 323,56 322.61,56.39 322.61,58.26 322.23,58.64 321.78,58.64 320.01,60.4 318.87,60.4 316.76,62.51 316.76,65.08 316.33,65.51 316.33,69.34 325.28,78.3 325.28,79.34 328.58,82.64 329.07,82.64 331.76,85.33 333.18,85.33 333.97,86.12 333.97,91.57 335.36,92.96 335.36,118.66 334.31,119.71 334.31,124.64 338.21,128.54 338.21,136.46 345.98,144.24 345.98,148.81 v1(346.23,149.06)
  IN4 w0.076: v3(266.94,26.62) 267.46,27.14 279.81,27.14 280.24,27.56 284.4,27.56 285.41,28.57 290.09,28.57 290.39,28.87 294.32,28.87 294.81,29.36 308.71,29.36 309.38,28.69 325.94,28.69 v1(326.55,29.3)
  BOTTOM w0.114: U6001.F4 v3(266.94,26.62)
BAT_WHITELED#: length 187
  TOP w0.114: R6094.1 361.09,150.46 v1(360.59,149.95) ; v1(276.05,34.63) 275.63,35.06 275.63,35.91 275.88,36.16 v1(275.88,38.62) 275.88,40.73 277.74,42.59 277.74,44.14 282.54,48.95 287.59,48.95 289.65,51.01 289.65,54.83 291.44,56.63 291.45,56.64 291.71,56.89 291.72,56.9 293.11,58.3 294.45,59.63 299.32,59.63 300.31,58.64 302.41,58.64 302.85,58.19 306.55,58.19 306.74,58 307.73,58 308.03,58.31 v1(308.03,58.85)
  IN2 w0.089: v1(317.37,62.77) 317.37,69.85 327.04,79.53 327.04,80.12 331.91,84.98 333.32,84.98 334.37,86.03 334.37,91.47 335.74,92.84 335.74,103.79 337.02,105.06 337.02,118.27 334.68,120.61 334.68,124.42 339.38,129.12 348.99,129.12 354.49,134.62 354.49,144.08 354.77,144.36 355.53,144.36 355.91,144.74 355.91,145.76 356.34,146.19 358.2,146.19 358.6,146.6 358.6,148.99 359.57,149.95 v1(360.59,149.95)
  BOTTOM w0.114: U6001.M11 271.82,31.08 272.14,31.41 272.14,31.92 272.45,32.22 273.47,32.22 VC6002.1 275.54,34.12 v1(276.05,34.63) ; v1(317.37,62.77) 314.37,62.77 312.62,61.02 312.62,58.54 312.21,58.13 308.76,58.13 v1(308.03,58.85)
BATLOW#: length 239.6
  TOP w0.114: v1(280.44,26.25) 280.06,25.87 279.56,25.87 278.43,24.74 Q6001.3 276.81,24.74 276.14,25.41 275.49,25.41 274.52,26.38 v1(273.72,26.38)
  IN2 w0.089: v1(324.97,27.4) 327.01,25.36 330.05,25.36 330.85,26.16 334.09,26.16 335.14,25.12 339.13,25.12 339.33,25.32 340.49,25.32 341.6,26.43 341.6,27.26 341.62,27.28 341.62,27.87 342.81,29.05 343.46,29.05 343.83,29.42 343.83,30.18 342.93,31.08 342.93,31.89 343.95,32.91 345.65,32.91 347.06,34.31 347.9,34.31 349.47,35.87 350.27,35.87 350.68,35.46 357.79,35.46 359.22,36.89 359.22,45.86 355.93,49.15 355.93,60.12 353.02,63.02 353.02,64.83 353.78,65.59 353.78,77.4 354.79,78.41 354.79,83.24 358.43,86.87 358.43,106.26 v1(357.66,107.02)
  IN4 w0.076: v1(280.44,26.25) 281.45,27.26 284.53,27.26 285.54,28.27 290.22,28.27 290.51,28.56 294.44,28.56 294.94,29.06 308.5,29.06 309.18,28.39 319.08,28.39 319.88,27.59 321.25,27.59 321.47,27.8 324.57,27.8 v1(324.97,27.4)
  BOTTOM w0.102: U9002.BF44 265.81,69.34 266.02,69.55 267.41,69.55 267.44,69.57 268.24,69.57 268.41,69.41 268.64,69.41
  BOTTOM w0.114: 268.64,69.41 270.61,69.41 271.98,70.78 272.27,70.78 273.08,71.59 274.18,71.59 R9092.1 274.46,71.87 274.91,71.87 278.1,68.67 278.1,64.75 276.91,63.55 276.16,63.55 275.63,63.01 275.62,63.01 275.11,62.5 275.11,60.74 274.95,60.59 274.95,57.48 275.67,56.76 275.67,56.38 275.39,56.11 275.39,52.34 276.08,51.65 276.08,47.29 278.24,45.13 278.24,36.2 278.81,35.64 278.81,33.9 280.07,32.64 280.07,26.63 v1(280.44,26.25) ; U6001.E11 272.13,25.98 273.32,25.98 v1(273.72,26.38)
  BOTTOM w0.127: R8023.2 v1(357.66,107.02)
BATT+:
  vias: v1(218.5,5.5)
BIOS_WP#: length 8.4
  BOTTOM w0.114: R6221.1 300.51,51.42 v1(300.49,51.4) 299.65,51.4 299.52,51.53 295.05,51.53 294.49,50.96 U6203.3
BIT_CLK_AUDIO: length 157.4
  TOP w0.114: R3608.2 347.15,16.14 347.66,16.65 347.66,17.54 346.84,18.35 346.84,27.22 v1(347.1,27.47) 347.46,27.84 347.46,30.03 348.01,30.57 348.01,38.9 347.82,39.08 347.82,41.53 346.95,42.4 346.95,44.86 346.11,45.7 346.11,48.22 347.08,49.19 347.08,58.18 v1(346.87,58.38)
  IN1 w0.076: v1(252.38,89.88) 252.76,89.5 254.62,89.5 254.74,89.37 258.05,89.37 258.23,89.19 258.53,89.19 258.81,88.91 258.81,87.72 259.87,86.65 260.07,86.65 269.93,76.8 270.11,76.8 270.97,75.93 270.97,75.05 271.56,74.46 273.16,74.46 275.03,72.6 276.01,72.6 280.39,68.21 281.16,68.21 283.51,65.86 286.13,65.86 290.35,61.63 290.35,61.48 291.33,60.5 292.53,60.5 293.1,59.93 296.73,59.93 297.64,59.02 305.68,59.02 306.66,60 315.05,60 315.85,60.8 317.04,60.8 317.75,60.09 328.22,60.09 329.26,59.04 332.47,59.04 333.08,58.43 333.65,58.43 334.41,59.2 339.43,59.2 340.29,58.33 342.12,58.33 342.67,58.88 346.37,58.88 v1(346.87,58.38)
  BOTTOM w0.114: R9080.1 253.02,90.51 v1(252.38,89.88)
BIT_CLK_AUDIO_R: length 6.1
  TOP w0.114: R3608.1 v1(345.84,15.32) C3610.1 344.72,14.47 344.33,14.09 344.33,12.54 344.07,12.28 U3600.58
BKL_PWM_GFX: length 105.6
  TOP w0.114: v1(248.95,31.33) 252.46,34.84 253.93,34.84 255.3,36.21 255.3,39.08 255.94,39.71 255.94,40.8 256.47,41.34 257.63,41.34 257.86,41.11 U3010.3
  IN2 w0.089: v1(223.45,80.02) 223.45,78.91 226.04,76.32 226.04,71.19 230.04,67.18 230.04,42 229.72,41.68 229.31,41.68 228.96,41.32 228.96,39.54 v1(229.55,38.95)
  BOTTOM w0.114: v1(223.45,80.02) 223.88,79.6 224.45,79.6 224.8,79.95 226.96,79.95 227.21,80.2 227.21,80.5 226.66,81.04 226.54,81.04 226.31,81.28 226.31,81.89 226.63,82.21 228.02,82.21 228.35,82.54 228.35,83.45 229.48,84.58 R2233.2 230.1,84.93 230.1,84.93 230.59,85.42 U2011.4 233.4,85.42 233.46,85.35 233.46,84.91 233.36,84.8 232.8,84.8 232.56,84.56 R2152.1 ; v1(229.55,38.95) 230.33,38.95 231.1,38.19 231.1,35.56 233.59,33.06 236.13,33.06 237.11,32.09 241.3,32.09 243.61,34.4 244.91,34.4 245.43,33.88 246.89,33.88 247.43,34.43 247.77,34.43 248.02,34.18 248.02,32.26 v1(248.95,31.33)
BKL_PWM_GFX_R: length 52.3
  IN2 w0.089: v1(217.52,103.79) 217.94,104.21 219.39,104.21 219.62,103.98 219.62,103.47 221.14,101.94 221.14,99.4 221.62,98.92 221.62,96.88 223.7,94.81 225.22,94.81 225.52,95.11 234.19,95.11 v1(235.92,93.39)
  BOTTOM w0.114: v1(235.92,93.39) 235.92,92.5 236.61,91.81 236.61,91.15 236.81,90.95 237.37,90.95 238.23,90.08 238.23,87.19 237.84,86.8 ; U2011.2 234.07,86.07 233.97,86.17 233.97,86.58 234.11,86.72 U2011.1 235.85,86.72 235.92,86.8 237.84,86.8 ; 237.84,86.8 237.9,86.8 237.9,86.15 237.59,85.83 236.46,85.83 235.26,84.63 234.63,84.63 233.43,83.43 232.19,83.43 232.04,83.57 232.04,84.66 231.68,85.02 231.33,85.02 231.07,84.77 231.07,84.12 R2112.2 229.77,83.78 R2233.1
  BOTTOM w0.127: v1(217.52,103.79) 217.52,103.79 U2000.N8
BKL_PWM_PCH: length 54.8
  TOP w0.114: U3010.1 256.56,39.71 256.06,39.21 R3051.2 R9330.1 256.06,34.96 v1(255.63,34.53)
  IN1 w0.076: v1(274.84,51.53) 274.45,51.53 269.78,56.19 269.78,56.66 269.46,56.97 269.46,57.56 268.03,58.99 267.54,58.99 266.01,60.52 v1(266.01,61.81)
  IN2 w0.089: v1(255.63,34.53) 256.2,33.96 256.96,33.96 257.72,34.73 261.22,34.73 261.68,35.18 261.68,35.67 262.21,36.2 262.21,36.33 264.17,38.29 264.17,38.59 264.79,39.21 265.28,39.21 265.8,39.72 266.67,39.72 268.28,41.33 268.28,45.54 270.02,47.28 270.02,48.72 272.7,51.4 274.72,51.4 v1(274.84,51.53)
  BOTTOM w0.114: v1(266.01,61.81) 266.01,61.98 264.47,63.52 264.47,63.92 264.08,64.3 U9002.AU48
BLON_CON: length 11.9
  TOP w0.114: R3025.2 58.07,45.43 v1(58.58,45.94)
  BOTTOM w0.114: v1(58.58,45.94) 56.92,47.6 56.92,49.48 57.06,49.61 Q3009.6 56.92,50.34 R3007.1 56.92,52.25 v1(56.83,52.34) 56.37,52.8 55.35,52.8 54.93,53.22 CON3000.22
BODY_SAR: length 9.4
  IN2 w0.089: v1(335.72,6.85) 329.84,6.85 v1(329.6,6.61)
  BOTTOM w0.114: R4205.1 v1(329.6,6.61) ; v1(335.72,6.85) 336.1,7.23 336.33,7.23 336.75,7.66 CON4201.25
BOOT_SPI#: length 18.1
  TOP w0.114: R9322.1 268.33,64.07 267.87,63.61 266.38,63.61 R17958.1 265.94,64.05 v1(265.75,64.05)
  IN4 w0.076: v1(265.75,64.05) 265.2,64.05 262.96,66.28 262.73,66.28 261.33,67.69 260.16,67.69 258.09,69.75 258.09,70.26 256.75,71.6 256.75,72.11 257.36,72.72 v1(257.95,72.72)
  BOTTOM w0.114: v1(257.95,72.72) 257.67,73 U9002.BA26
BQACDET: length 21.1
  BOTTOM w0.178: v1(249.63,10.99) 249.63,11.45 249.29,11.79 PU11000.6
  BOTTOM w0.203: PD11005.1 252.43,14.66 252.9,14.19 252.98,14.19 253.99,13.21 254.07,13.21 254.4,12.88 254.4,11.43 254.83,11 PR11008.2 254.67,10.62 254.67,10.29 PR11013.1 253.79,10.38 252.88,10.38 PC11013.1 252,9.87 251.87,10 PR11027.2 251.12,9.86 251.64,9.34 251.64,7.99 251.33,7.67 250.94,7.67 250.92,7.69 249.86,7.69 249.21,8.34 249.21,9.45 249.63,9.86 v1(249.63,10.99)
BQACDRV: length 1.2
  BOTTOM w0.178: TP11000.1 249.52,12.53 249.28,12.53 249.22,12.59 PU11000.4
BQACN: length 3.6
  BOTTOM w0.178: PR11005.2 PR11006.1 250.62,13.48 250.31,13.79 PU11000.1
BQACP: length 3.9
  BOTTOM w0.178: PR11004.2 250.62,11.2 250.18,11.65 250.18,12.92 249.66,13.44 249.09,13.44 249.03,13.39 PU11000.2
BQBATDRV: length 3.7
  BOTTOM w0.178: TP11002.1 243.5,11.33 243.5,11.82 243.72,12.04 243.72,12.21 244.1,12.59 PU11000.18
BQBATPRES: length 8.2
  BOTTOM w0.114: PR11021.2 240.32,5.68 v1(240.63,5.99) 243.16,8.52 PR11023.2 243.36,9.2 243.48,9.2 244.23,9.94 244.23,11.29 244.32,11.39 PU11000.15
BQBATSRC: length 7.6
  BOTTOM w0.114: PU11000.17 244.13,12.19 243.98,12.04 243.98,11.93 243.76,11.71 243.76,11.18 242.72,10.14 242.72,9.95 242.47,9.7 242.18,9.7 241.74,9.26 241.74,8.85 241.2,8.31 PR11022.1 239.77,8.31 v1(239.43,7.96)
BQBTST: length 2.7
  BOTTOM w0.178: PU11000.25 246.56,15.41 v1(246.18,15.79)
  BOTTOM w0.254: 246.16,16.53 246.16,15.81 v1(246.18,15.79)
  BOTTOM w0.508: PR11010.2 246.16,16.53
BQCMPIN: length 7.5
  TOP w0.254: v1(245.22,9.59) 245.27,9.59 245.77,10.09 PC11027.2 245.62,10.43 v1(244.89,10.43) 244.14,10.43 PR11038.1 243.49,9.78 243.49,8.8 243.14,8.45 PR11036.1 PR11035.2
  BOTTOM w0.178: v1(245.22,9.59) 245.24,9.59 245.76,10.11 PU11000.13
BQCMPOUT: length 11
  TOP w0.114: v1(241.36,6.03) 241.85,5.54 PR11037.1 242.22,5.3 242.36,5.43 PR11034.1 242.86,6.19 v1(242.98,6.31) 242.98,6.92 243.14,7.08 PR11036.2
  BOTTOM w0.114: v1(241.36,6.03) 241.61,6.29 242.2,6.29 243.95,8.04 243.95,9.31 244.71,10.07 245.27,10.07 245.36,10.17 PU11000.14
BQCMSRC: length 2.1
  TOP w0.508: v1(249.47,12.99) 249.83,12.62 PR11009.1
  BOTTOM w0.178: PU11000.3 v1(249.47,12.99)
BQHIDRV: length 16.3
  TOP w0.114: v1(242.98,25.11) v4(242.09,25.11)
  IN4 w1.016: v4(246.82,16.02) 246.82,16.65 243,20.47 241.27,20.47 240.82,20.92 240.82,23.84 v4(242.09,25.11)
  BOTTOM w0.178: PU11000.26 246.96,15.87 v4(246.82,16.02)
  BOTTOM w0.508: PQ11001.4 v4(242.09,25.11)
BQIADP: length 8.1
  BOTTOM w0.178: PR11028.2 250.52,5.59 251.01,6.09 251.01,6.72 250.5,7.23 PC11023.1 249.88,7.24 248.76,8.36 248.76,9.78 v1(248.9,9.92) 249.13,10.15 249.13,11.17 248.91,11.39 PU11000.7
BQIDCHG: length 4.6
  TOP w0.203: PR11029.2 PC11025.1 250.07,9.52 249.88,9.7 248.76,9.7 v1(248.29,10.17)
  BOTTOM w0.114: PU11000.8 247.76,10.24 247.91,10.1 248.22,10.1 v1(248.29,10.17)
BQILIM: length 45.1
  TOP w0.114: v1(251.92,4.13) 252.36,4.13 253.27,5.04 PQ11003.3
  BOTTOM w0.114: v1(251.92,4.13) 250.91,3.12 237.67,3.12 235.24,5.55 235.24,7.08 236.26,8.11 PR11031.1 236.26,10.12 235.69,10.68 235.69,15.43 237.32,17.06 237.9,17.06 238.39,17.54 241.84,17.54 244.05,15.33 244.05,13.91 244.17,13.79 PU11000.21
BQLODRV: length 14.7
  TOP w0.114: v1(236.47,19.43) v4(236.47,20.2)
  IN4 w1.016: v4(236.47,20.2) 236.47,18.29 237.9,16.85 242.25,16.85 243.57,15.53 v4(245.07,15.53)
  BOTTOM w0.178: v4(245.07,15.53) 245.35,15.53 245.76,15.12 PU11000.23
  BOTTOM w1.016: PQ11002.4 v4(236.47,20.2)
BQPHASE: length 11.7
  IN4 w1.016: v4(247.91,15.71) 248.01,15.81 248.01,17.57 243.69,21.88 v4(242.09,21.88)
  BOTTOM w0.178: v4(247.91,15.71) 247.36,15.17 PU11000.27
  BOTTOM w0.508: PC11012.2 247.81,15.81 v4(247.91,15.71)
  vias: v1(235.36,22.82)
BQPMON: length 3.7
  TOP w0.203: v1(247.76,9.31) 246.97,8.52 PR11033.1 PR11032.1
  BOTTOM w0.114: v1(247.76,9.31) 247.76,9.64 247.36,10.04 PU11000.9
BQPROCHOT: length 10
  BOTTOM w0.114: PU11000.10 246.96,9.85 247.17,9.64 247.17,7.96 247.91,7.23 247.91,6.75 248.27,6.39 249.41,6.39 249.59,6.21 249.59,4.46 v1(250.5,3.55) 250.52,3.56 PR11020.2
BQSCL: length 4.5
  TOP w0.114: PR11019.1 245.5,6.64 245.5,6.65 245.5,7.13 245.88,7.5 245.88,9.36 v1(246.01,9.49)
  BOTTOM w0.114: PU11000.12 246.16,9.83 246.01,9.67 v1(246.01,9.49)
BQSDA: length 5.3
  TOP w0.114: v1(246.69,9.41) 246.39,9.11 246.39,7.36 247.44,6.3 PR11018.1
  BOTTOM w0.114: PU11000.11 246.56,9.54 v1(246.69,9.41)
BQSRN: length 8.6
  TOP w0.203: v1(243.75,12.99) 244.21,12.99 244.48,12.71 v1(244.48,12.59) 244.48,11.72 242.67,9.91 242.67,7.56 PR11026.1
  BOTTOM w0.114: v1(243.75,12.99) PU11000.19
BQSRP: length 23.3
  TOP w0.254: PR11024.1 241.28,8.69 v1(241.28,9.08)
  BOTTOM w0.178: v1(241.28,9.08) 240.06,9.08 239.83,8.85 v1(238.49,8.85) 237.63,9.72 237.63,9.97 235.95,11.65 235.95,15.32 237.43,16.8 238.01,16.8 238.49,17.28 241.73,17.28 243.79,15.22 243.79,13.71 244.11,13.39 PU11000.20
BQTB_STAT: length 1.8
  BOTTOM w0.114: PU11000.16 244.16,11.79 243.99,11.62 243.99,10.8 TP11001.1
BQVCC: length 2
  TOP w0.508: PR11007.2 249.14,17.07 249.14,16.16 v1(249.79,15.51)
  vias: v1(249.33,14.7)
BRD_ID1: length 7.4
  BOTTOM w0.114: R9071.1 267.91,60.18 267.46,60.64 267.44,60.64 266.96,61.11 R9072.2 266.67,62.01 266.67,62.08 265.94,62.81 265.79,62.81 264.91,63.69 264.91,64.16 263.92,65.15 U9002.AV47
BRD_ID2: length 2.7
  TOP w0.114: v1(258.25,67.96) 258.07,67.96 R9073.1 258,67.05 258.05,67.05 R9074.2
  BOTTOM w0.114: U9002.AR35 258.54,68.25 v1(258.25,67.96)
BRD_ID3: length 2.9
  TOP w0.114: v1(258.71,67.49) 258.85,67.63 R9076.2 260,67.63 260.16,67.47 R9075.1
  BOTTOM w0.114: v1(258.71,67.49) 258.92,67.71 U9002.AR37
BRD_ID4: length 11.4
  TOP w0.114: v1(262.62,67.19) 262.8,67.38 263.38,67.38 263.65,67.11 263.81,67.11 264.81,66.11 v1(264.81,65.5) 264.81,64.84 265.28,64.36 265.28,63.66 266.96,61.98 R9078.2 267.68,61.71 268.49,60.89 R9077.1
  BOTTOM w0.114: U9002.AV43 262.38,66.96 v1(262.62,67.19)
BT_DEV_EN_L: length 2.3
  BOTTOM w0.114: U4100.63 339.89,62.95 v1(339.76,62.82) 339.76,62.12 339.88,62 R4115.2
BT_OFF: length 173.2
  TOP w0.114: v1(340.24,27.9) 341,28.67 v1(341.03,28.67) 340.85,28.84 340.85,33.82 338.87,35.8 338.87,43.47 340.25,44.85 340.25,46.84 338.74,48.35 338.74,49.94 336.64,52.03 335.57,52.03 335.27,52.33 335.27,54.18 338.77,57.67 341.85,57.67 342.7,58.52 342.7,59.38 v1(341.92,60.16)
  IN2 w0.089: v1(340.24,27.9) 338.25,25.92 335.47,25.92 334.42,26.96 330.36,26.96 329.91,26.52 328.02,26.52 326.55,27.99 323.82,27.99 321.76,30.05 316.18,30.05 314.97,31.26 314.97,41.59 311.13,45.42 311.13,46.6 309,48.74 306.7,48.74 304.62,50.81 299.58,50.81 297.77,52.62 293.59,52.62 293.48,52.73 291.92,52.73 291.22,53.43 290.77,53.43 290.77,53.44 290.4,53.44 290.26,53.3 289.85,53.3 287.31,55.84 284.21,55.84 284.16,55.89 283.88,55.89 283.69,56.08 283.69,56.08 283.24,56.27 283.23,56.27 283.14,56.33 283.05,56.39 282.7,56.63 282.24,57.09 281.88,57.62 281.88,57.62 281.76,57.81 281.76,57.92 281.69,58.08 281.04,58.73 281.04,60.81 278.05,63.8 278.05,66.27 276.98,67.34 275.27,67.34 274.79,67.83 273.37,67.83 272.85,67.83 272.16,68.52 272.16,68.74 268.57,72.33 268.01,72.33 266.05,74.28 265.72,74.28 265.42,74.58 265.07,74.58 262.97,76.67 262.45,76.67 260.94,78.18 260.94,78.79 261.25,79.1 261.25,79.86 260.31,80.81 259.27,80.81 258.88,81.19 257.77,81.19 v3(257.77,81.19)
  BOTTOM w0.102: R9236.1 259.34,84.36 258.78,83.81 ; U9002.AW18 254.29,76.03 254.16,76.16 254.16,76.42 254.41,76.67 255.43,76.67 255.73,76.97 255.73,77.35 256.19,77.81 256.33,77.81 256.63,78.12 257.18,78.12 257.64,78.57 257.64,81.06 v3(257.77,81.19)
  BOTTOM w0.114: 258.78,83.81 258.73,83.81 258.27,83.35 258.27,83 257.97,82.69 257.97,81.44 257.77,81.24 v3(257.77,81.19) ; v1(341.92,60.16) 341.54,59.78 Q4105.5
BT_OFF#: length 6
  BOTTOM w0.114: R4118.1 340.83,62.21 340.65,62.04 R4115.1 340.65,61.43 340.42,61.19 v1(340.42,60.8) 340.8,60.8 341.16,60.43 Q4105.6 341.58,60.43 341.74,60.59 342.09,60.59 342.42,60.26 342.42,59.4 342.69,59.13 Q4105.3
C1A: length 4.1
  BOTTOM w0.114: v1(22.65,104.24) R602.1 R601.2 24.54,104.61 23.65,105.5 U601.12
C2A: length 3.8
  BOTTOM w0.114: v1(21.88,110.06) R9531.1 R613.2 23.78,109.31 23.65,109.18 U601.6
C3A: length 4
  BOTTOM w0.114: v1(24.54,86.83) R604.1 R603.2 25.56,86.58 26.19,87.21 U600.12
C4A: length 3.8
  BOTTOM w0.114: v1(24.8,90.77) R615.1 R614.2 25.81,91.02 26.19,90.64 U600.6
C_C10#: length 256.6
  IN1 w0.076: v1(106.46,28.54) 106.84,28.54 110.83,24.55 137.13,24.55 137.43,24.25 176,24.25 176.6,23.65 186.21,23.65 187.12,24.55 189.61,24.55 189.92,24.87 205.16,24.87 207.21,22.82 213.93,22.82 217.94,26.84 227.99,26.84 231.89,30.74 252.34,30.74 254,29.07 254.45,29.07 255.43,28.09 256.14,28.09 257.17,27.07 258.01,27.07 260.46,24.61 260.46,23.85 261.3,23.01 261.3,20.84 262.34,19.8 264.23,19.8 265.56,18.47 267.14,18.47 267.54,18.87 269.59,18.87 v1(272.09,21.38)
  BOTTOM w0.114: R17911.1 120.01,88.18 118.97,88.18 118.45,88.71 115.26,88.71 PR26005.2 115.02,88.63 114.35,87.96 PR26006.2 114.2,87.39 113.93,87.39 112.99,86.45 106.97,86.45 106.78,86.27 106.78,57.48 106.84,57.42 106.84,46.45 106.03,45.64 106.03,28.96 v1(106.46,28.54) ; R6020.1 272.19,21.27 v1(272.09,21.38) 272.19,21.48 272.19,22.34 272.09,22.44 272.09,23.42 U6001.A11
C_IN_CLK#_R: length 5.8
  BOTTOM w0.102: C594.2 C586.2 352.08,55.46 351.91,55.29 351.91,55.15 352.01,55.05 352.15,55.05 352.29,55.18 355.83,55.18 356.1,55.46 U12006.48
C_IN_CLK#_R_R: length 48.6
  TOP w0.102: v1(355.25,93.82) 355.47,93.6 356.78,93.6 356.83,93.66 R3207.2 357.52,93.66 357.58,93.6 358.35,93.6 359.06,92.89 359.06,91.6 359.55,91.1 361.17,91.1 361.84,91.77 361.84,95.4 361.77,95.47 361.6,95.47 CON3200.12
  IN3 w0.076: v1(354.37,63.85) 354.49,63.85 354.67,64.03 354.67,64.58 353.09,66.15 353.09,81.23 352.71,81.62 352.71,89.52 354.49,91.3 354.49,93.16 354.76,93.44 355.25,93.44 355.38,93.56 355.38,93.69 v1(355.25,93.82)
  BOTTOM w0.102: U12006.13 356.1,62.15 355.36,62.89 355.06,62.89 354.59,63.36 354.59,63.63 v1(354.37,63.85)
C_IN_CLK_R: length 5.8
  BOTTOM w0.102: C593.2 C585.2 352.08,54.5 352.42,54.85 355.96,54.85 356.5,55.39 U12006.47
C_IN_CLK_R_R: length 48.6
  TOP w0.102: v1(355.25,93.05) 355.47,93.27 356.81,93.27 356.87,93.21 R3207.1 357.52,93.21 357.58,93.27 358.21,93.27 358.73,92.75 358.73,91.46 359.42,90.77 361.31,90.77 362.17,91.63 362.17,95.53 361.91,95.8 361.63,95.8 CON3200.10
  IN3 w0.076: v1(355,63.85) 354.92,63.94 354.92,64.68 353.35,66.26 353.35,81.34 352.97,81.72 352.97,89.42 354.74,91.2 354.74,93.05 354.87,93.18 355.12,93.18 v1(355.25,93.05)
  BOTTOM w0.102: v1(355,63.85) 354.92,63.77 354.92,63.5 355.2,63.22 355.49,63.22 356.5,62.22 U12006.14
C_PEG_TXN0: length 7.6
  BOTTOM w0.079: 181.31,105.98 181.29,105.98 181.27,105.96 178.63,105.96 178.5,106.09 178.5,106.21 178.57,106.28 U9001.B10
  BOTTOM w0.095: 181.31,105.98 182.41,105.98 182.72,105.67 182.72,104.75 182.87,104.6 183.08,104.6 183.23,104.75 183.23,104.96 183.45,105.18 183.74,105.18 183.88,105.32 C9005.2
C_PEG_TXN1: length 7.5
  BOTTOM w0.079: U9001.B11 178.89,106.92 178.89,106.79 179.07,106.62 179.67,106.62 179.95,106.9 180.42,106.9 180.9,106.42 181.27,106.42 181.29,106.4 181.31,106.4
  BOTTOM w0.095: 181.31,106.4 182.62,106.4 182.89,106.13 185.12,106.13 C9007.2
C_PEG_TXN2: length 7.3
  BOTTOM w0.079: 181.31,107.34 181.29,107.34 181.27,107.33 180.96,107.33 180.74,107.54 178.49,107.54 178.4,107.63 178.4,107.77 178.48,107.85 U9001.B12
  BOTTOM w0.095: 181.31,107.34 182.18,107.34 182.34,107.5 182.34,107.88 182.6,108.14 182.97,108.14 183.23,107.88 183.23,107.5 183.38,107.35 183.6,107.35 C9009.2
C_PEG_TXN3: length 8.3
  BOTTOM w0.079: 181.31,107.79 181.29,107.79 181.27,107.8 181.05,107.8 180.89,107.96 180.89,108.28 180.75,108.42 180.11,108.42 179.83,108.14 179.07,108.14 178.88,108.33 178.88,108.51 U9001.B13
  BOTTOM w0.095: 181.31,107.79 181.67,107.79 181.91,108.02 181.91,108.4 182.06,108.56 183.25,108.56 183.63,108.17 185.11,108.17 C9011.2
C_PEG_TXN4: length 7.5
  BOTTOM w0.079: 181.31,109.35 181.29,109.35 181.27,109.33 180.77,109.33 180.55,109.11 178.49,109.11 178.4,109.2 178.4,109.34 178.48,109.43 U9001.B14
  BOTTOM w0.095: C9013.2 183.56,109.34 183.44,109.34 183.28,109.5 183.28,109.93 183.03,110.18 182.67,110.18 182.42,109.93 182.42,109.5 182.26,109.35 181.31,109.35
C_PEG_TXN5: length 7.6
  BOTTOM w0.079: 181.31,110.08 181.3,110.08 181.28,110.1 180.1,110.1 179.75,109.74 179.07,109.74 178.89,109.93 178.89,110.07 U9001.B15
  BOTTOM w0.095: 181.31,110.08 181.93,110.08 182.45,110.6 182.46,110.6 182.47,110.61 183.23,110.61 183.65,110.19 185.13,110.19 C9015.2
C_PEG_TXN6: length 7.2
  BOTTOM w0.079: U9001.B16 178.48,111 178.4,110.92 178.4,110.8 178.48,110.71 180.34,110.71 180.51,110.88 181.27,110.88 181.29,110.89 181.31,110.89
  BOTTOM w0.095: 181.31,110.89 181.62,110.89 182.29,111.56 182.29,111.77 182.54,112.02 182.9,112.02 183.15,111.77 183.15,111.56 183.31,111.4 183.59,111.4 C9017.2
C_PEG_TXN7: length 7.9
  BOTTOM w0.079: U9001.B17 178.87,111.91 178.87,112.08 179.05,112.26 180.18,112.26 180.79,111.66 181.27,111.66 181.29,111.67 181.31,111.67
  BOTTOM w0.095: C9019.2 185.11,112.42 183.47,112.42 183.26,112.63 182.28,112.63 181.65,112.01 181.65,111.83 181.5,111.67 181.31,111.67
C_PEG_TXN8: length 7.3
  BOTTOM w0.079: 181.31,112.68 181.29,112.68 181.27,112.66 180.9,112.66 180.78,112.78 180.78,113.1 180.47,113.4 179.93,113.4 179.55,113.02 178.41,113.02 178.24,112.85 178.24,112.72 U9001.C18
  BOTTOM w0.095: C9021.2 183.59,113.43 183.33,113.43 183.14,113.24 181.76,113.24 181.53,113 181.53,112.79 181.42,112.68 181.31,112.68
C_PEG_TXN9: length 7.3
  BOTTOM w0.079: 181.31,113.66 181.3,113.66 181.28,113.68 179.19,113.68 179.03,113.51 179.03,113.46 179.12,113.37 U9001.A19
  BOTTOM w0.095: C9023.2 185.12,114.26 183.54,114.26 182.95,113.66 181.31,113.66
C_PEG_TXN10: length 7.7
  BOTTOM w0.079: U9001.C20 178.23,114.29 178.23,114.48 178.41,114.65 179.65,114.65 179.87,114.87 181.28,114.87 181.3,114.89 181.31,114.89
  BOTTOM w0.095: 181.31,114.89 181.39,114.89 181.69,115.18 182.06,115.18 182.26,114.97 182.26,114.61 182.42,114.46 182.64,114.46 182.8,114.62 182.8,115.2 183.06,115.46 183.59,115.46 C9025.2
C_PEG_TXN11: length 7.5
  BOTTOM w0.079: U9001.A21 179.12,114.94 179.03,115.03 179.03,115.16 179.12,115.26 180.46,115.26 180.84,115.63 181.27,115.63 181.29,115.62 181.31,115.62
  BOTTOM w0.095: 181.31,115.62 182.59,115.62 183.27,116.3 185.11,116.3 C9027.2
C_PEG_TXN12: length 6.7
  BOTTOM w0.079: U9001.C22 178.24,115.87 178.24,116.01 178.42,116.2 179.48,116.2 179.57,116.2 179.61,116.23 179.83,116.45 181.27,116.45 181.29,116.47 181.31,116.47
  BOTTOM w0.095: C9029.2 183.6,117.51 183.36,117.51 183.34,117.5 183.34,117.5 182.31,116.47 181.31,116.47
C_PEG_TXN13: length 7.7
  BOTTOM w0.079: 181.31,117.11 181.29,117.11 181.27,117.13 180.86,117.13 180.54,116.81 179.09,116.81 179.03,116.74 179.03,116.61 179.12,116.51 U9001.A23
  BOTTOM w0.095: 181.31,117.11 182.36,117.11 183.57,118.32 185.12,118.32 C9031.2
C_PEG_TXN14: length 7.1
  BOTTOM w0.079: 181.31,117.91 181.29,117.91 181.27,117.89 179.79,117.89 179.67,117.77 178.42,117.77 178.24,117.59 178.24,117.44 U9001.C24
  BOTTOM w0.095: 181.31,117.91 182.02,117.91 183.03,118.91 183.03,119.31 183.25,119.54 183.6,119.54 C9033.2
C_PEG_TXN15: length 8.3
  BOTTOM w0.079: 181.31,118.34 181.29,118.34 181.27,118.36 180.09,118.36 180.05,118.4 179.14,118.4 179.04,118.31 179.04,118.18 179.14,118.09 U9001.A25
  BOTTOM w0.095: 181.31,118.34 181.64,118.34 182.02,118.73 182.02,119.38 182.69,120.05 183.47,120.05 183.83,120.4 185.07,120.4 C9035.2
C_PEG_TXP0: length 7.6
  BOTTOM w0.079: 181.31,105.79 181.3,105.79 181.28,105.81 178.56,105.81 178.34,106.02 178.34,106.2 178.27,106.28 U9001.C10
  BOTTOM w0.095: C9004.2 183.72,104.99 183.53,104.99 183.42,104.88 183.42,104.67 183.16,104.41 182.79,104.41 182.53,104.67 182.53,105.59 182.34,105.79 181.31,105.79
C_PEG_TXP1: length 7.4
  BOTTOM w0.079: U9001.A11 179.13,107.07 179.05,106.98 179.05,106.86 179.13,106.78 179.61,106.78 179.89,107.06 180.49,107.06 180.97,106.57 181.27,106.57 181.29,106.59 181.31,106.59
  BOTTOM w0.095: C9006.2 185.11,106.32 182.96,106.32 182.69,106.59 181.31,106.59
C_PEG_TXP2: length 7.4
  BOTTOM w0.079: 181.31,107.15 181.29,107.15 181.27,107.17 180.9,107.17 180.68,107.38 178.42,107.38 178.24,107.57 178.24,107.71 U9001.C12
  BOTTOM w0.095: C9008.2 183.59,107.16 183.3,107.16 183.04,107.42 183.04,107.8 182.89,107.95 182.68,107.95 182.53,107.8 182.53,107.42 182.26,107.15 181.31,107.15
C_PEG_TXP3: length 8.3
  BOTTOM w0.079: 181.31,107.98 181.3,107.98 181.28,107.96 181.11,107.96 181.05,108.02 181.05,108.34 180.82,108.57 180.04,108.57 179.77,108.3 179.13,108.3 179.03,108.4 179.03,108.54 179.13,108.64 U9001.A13
  BOTTOM w0.095: C9010.2 185.12,108.36 183.71,108.36 183.33,108.75 181.98,108.75 181.72,108.48 181.72,108.1 181.6,107.98 181.31,107.98
C_PEG_TXP4: length 7.5
  BOTTOM w0.079: 181.31,109.16 181.29,109.16 181.27,109.17 180.83,109.17 180.61,108.96 178.42,108.96 178.24,109.14 178.24,109.28 U9001.C14
  BOTTOM w0.095: C9012.2 183.62,109.15 183.36,109.15 183.09,109.42 183.09,109.85 182.95,109.99 182.75,109.99 182.61,109.85 182.61,109.42 182.34,109.16 181.31,109.16
C_PEG_TXP5: length 7.6
  BOTTOM w0.079: 181.31,110.27 181.29,110.27 181.27,110.25 180.04,110.25 179.68,109.9 179.14,109.9 179.05,109.99 179.05,110.13 179.14,110.22 U9001.A15
  BOTTOM w0.095: C9014.2 185.11,110.38 183.73,110.38 183.31,110.8 182.39,110.8 182.38,110.79 182.37,110.79 182.31,110.73 181.85,110.27 181.31,110.27
C_PEG_TXP6: length 7.2
  BOTTOM w0.079: 181.31,110.7 181.3,110.7 181.28,110.72 180.57,110.72 180.41,110.56 178.41,110.56 178.24,110.73 178.24,110.86 U9001.C16
  BOTTOM w0.095: 181.31,110.7 181.7,110.7 182.48,111.48 182.48,111.69 182.62,111.83 182.82,111.83 182.96,111.69 182.96,111.48 183.23,111.21 183.61,111.21 C9016.2
C_PEG_TXP7: length 7.9
  BOTTOM w0.079: U9001.A17 179.12,111.79 179.03,111.88 179.03,112.01 179.12,112.1 180.12,112.1 180.72,111.5 181.27,111.5 181.29,111.48 181.31,111.48
  BOTTOM w0.095: C9018.2 185.12,112.23 183.39,112.23 183.18,112.44 182.36,112.44 181.85,111.93 181.85,111.75 181.58,111.48 181.31,111.48
C_PEG_TXP8: length 7.2
  BOTTOM w0.079: U9001.B18 178.48,112.58 178.39,112.66 178.39,112.78 178.48,112.87 179.62,112.87 179.99,113.24 180.41,113.24 180.62,113.03 180.62,112.71 180.83,112.5 181.27,112.5 181.29,112.49 181.31,112.49
  BOTTOM w0.095: C9020.2 183.6,113.24 183.41,113.24 183.22,113.05 181.84,113.05 181.72,112.93 181.72,112.71 181.49,112.49 181.31,112.49
C_PEG_TXP9: length 7.3
  BOTTOM w0.079: U9001.B19 178.87,113.49 178.87,113.58 179.13,113.84 181.28,113.84 181.3,113.85 181.31,113.85
  BOTTOM w0.095: C9022.2 185.12,114.46 183.48,114.46 183.47,114.45 183.46,114.45 182.87,113.85 181.31,113.85
C_PEG_TXP10: length 7.7
  BOTTOM w0.079: U9001.B20 178.5,114.15 178.39,114.26 178.39,114.41 178.47,114.49 179.71,114.49 179.93,114.71 181.28,114.71 181.3,114.7 181.31,114.7
  BOTTOM w0.095: C9024.2 183.6,115.27 183.14,115.27 182.99,115.12 182.99,114.54 182.71,114.27 182.34,114.27 182.07,114.54 182.07,114.89 181.98,114.99 181.76,114.99 181.47,114.7 181.31,114.7
C_PEG_TXP11: length 7.5
  BOTTOM w0.079: 181.31,115.81 181.29,115.81 181.27,115.79 180.77,115.79 180.4,115.42 179.05,115.42 178.87,115.23 178.87,115.06 U9001.B21
  BOTTOM w0.095: C9026.2 185.12,116.49 183.19,116.49 182.51,115.81 181.31,115.81
C_PEG_TXP12: length 6.7
  BOTTOM w0.079: 181.31,116.28 181.29,116.28 181.27,116.29 179.89,116.29 179.72,116.12 179.64,116.04 179.42,116.04 178.49,116.04 178.4,115.95 178.4,115.81 178.49,115.73 U9001.B22
  BOTTOM w0.095: 181.31,116.28 182.39,116.28 183.41,117.31 183.6,117.31 C9028.2
C_PEG_TXP13: length 7.7
  BOTTOM w0.079: 181.31,117.31 181.29,117.31 181.27,117.29 180.8,117.29 180.47,116.96 179.03,116.96 178.87,116.8 178.87,116.64 U9001.B23
  BOTTOM w0.095: C9030.2 185.12,118.52 183.51,118.52 183.5,118.51 183.49,118.51 182.28,117.31 181.31,117.31
C_PEG_TXP14: length 7.1
  BOTTOM w0.079: 181.31,117.72 181.3,117.72 181.28,117.73 179.86,117.73 179.74,117.62 178.49,117.62 178.39,117.52 178.39,117.39 178.49,117.3 U9001.B24
  BOTTOM w0.095: 181.31,117.72 182.1,117.72 183.22,118.83 183.22,119.23 183.32,119.34 183.6,119.34 C9032.2
C_PEG_TXP15: length 8.3
  BOTTOM w0.079: U9001.B25 178.89,118.23 178.89,118.38 179.07,118.56 180.11,118.56 180.16,118.52 181.28,118.52 181.3,118.53 181.31,118.53
  BOTTOM w0.095: C9034.2 185.19,120.59 183.75,120.59 183.39,120.24 182.61,120.24 181.83,119.46 181.83,118.81 181.56,118.53 181.31,118.53
C_TX0_HDMI+_R: length 9
  BOTTOM w0.102: U12006.44 357.7,55.34 357.67,55.31 357.67,54.58 357.54,54.44 357.54,53.47 356.63,52.57 352.42,52.57 352.08,52.22 C587.2 C595.2
C_TX0_HDMI+_R_R: length 42.6
  TOP w0.102: CON3200.7 359.45,97.31 358.92,97.31 358.48,96.87 358.48,96.28 357.87,95.67 357.46,95.67 357.41,95.72 R3206.1 356.79,95.72 356.73,95.66 355.45,95.66 v1(355.26,95.85)
  IN3 w0.076: v1(355.26,95.85) 355.37,95.74 355.61,95.74 356.19,95.16 356.19,91.6 354.36,89.77 354.36,67.25 356.85,64.76 356.85,64.04 v1(357.04,63.85)
  BOTTOM w0.102: U12006.17 357.7,62.35 357.66,62.39 357.66,62.78 357.01,63.44 357.01,63.83 v1(357.04,63.85)
C_TX0_HDMI-_R: length 9
  BOTTOM w0.102: U12006.45 357.3,55.34 357.34,55.29 357.34,54.72 357.21,54.58 357.21,53.61 356.5,52.9 352.29,52.9 352.17,52.77 352.02,52.77 351.92,52.88 351.92,53.02 352.08,53.18 C588.2 C596.2
C_TX0_HDMI-_R_R: length 42.6
  TOP w0.102: v1(355.26,95.09) 355.5,95.33 356.73,95.33 356.79,95.27 R3206.2 357.41,95.27 357.48,95.34 358,95.34 358.81,96.14 358.81,96.73 359.06,96.98 359.45,96.98 CON3200.9
  IN3 w0.076: v1(356.4,63.85) 356.6,64.05 356.6,64.66 354.11,67.15 354.11,89.88 355.94,91.71 355.94,95.06 355.51,95.49 355.39,95.49 355.26,95.36 v1(355.26,95.09)
  BOTTOM w0.102: v1(356.4,63.85) 356.68,63.57 356.68,63.3 357.33,62.65 357.33,62.39 357.3,62.35 U12006.16
C_TX1_HDMI+_R: length 11.6
  BOTTOM w0.102: U12006.41 358.9,52.8 356.38,50.28 352.42,50.28 352.08,49.93 C589.2 C597.2
C_TX1_HDMI+_R_R: length 46.9
  TOP w0.102: CON3200.4 361.53,98.9 361.8,98.9 362.91,97.8 362.91,95.95 362.98,95.87 362.98,91.29 361.65,89.96 358.34,89.96 358.1,89.72 357.48,89.72 357.41,89.65 R3205.1 356.91,89.65 356.86,89.7 356.09,89.7 v1(355.89,89.5)
  IN3 w0.076: v1(359.2,63.85) 359,64.05 359,64.29 355.97,67.32 355.88,67.41 355.61,67.68 355.12,68.16 355.12,89.12 355.63,89.63 355.76,89.63 v1(355.89,89.5)
  BOTTOM w0.102: U12006.20 358.9,62.35 358.86,62.39 358.86,62.76 359.04,62.93 359.04,63.77 359.12,63.85 v1(359.2,63.85)
C_TX1_HDMI-_R: length 11.6
  BOTTOM w0.102: C598.2 C590.2 352.08,50.89 351.93,50.75 351.93,50.6 352.03,50.5 352.18,50.5 352.29,50.61 356.24,50.61 358.57,52.94 358.57,55.27 358.5,55.34 U12006.42
C_TX1_HDMI-_R_R: length 46.8
  TOP w0.102: CON3200.6 361.28,98.45 361.4,98.57 361.67,98.57 362.58,97.66 362.58,95.81 362.65,95.73 362.65,91.43 361.51,90.29 358.2,90.29 357.97,90.05 357.41,90.05 357.36,90.1 R3205.2 356.87,90.1 356.8,90.03 356.11,90.03 v1(355.89,90.26)
  IN3 w0.076: v1(358.56,63.85) 358.74,64.03 358.74,64.19 355.79,67.14 355.7,67.23 355.36,67.57 354.87,68.06 354.87,89.01 354.87,89.22 355.53,89.88 355.89,89.88 356.01,90.01 356.01,90.13 v1(355.89,90.26)
  BOTTOM w0.102: v1(358.56,63.85) 358.71,63.71 358.71,63.07 358.53,62.9 358.53,62.39 358.5,62.35 U12006.19
C_TX2_HDMI+_R: length 14.2
  BOTTOM w0.102: C599.2 C591.2 352.08,47.65 352.42,48 355.87,48 360.2,52.33 360.2,54.56 360.06,54.7 360.06,55.34 360.1,55.37 U12006.38
C_TX2_HDMI+_R_R: length 46.1
  TOP w0.102: v1(356.14,98.52) 356.3,98.36 R3204.1 357.35,98.36 357.41,98.3 357.74,98.3 358.6,99.16 358.6,99.87 359.05,100.31 359.45,100.31 CON3200.1
  IN3 w0.076: v1(361.23,63.85) 361.23,63.89 359.93,65.19 359.53,65.19 356.29,68.43 356.29,86.5 356.45,86.65 356.46,86.66 357.54,87.74 357.54,97.75 356.91,98.39 356.27,98.39 v1(356.14,98.52)
  BOTTOM w0.102: v1(361.23,63.85) 361.17,63.8 361.17,63.21 360.1,62.14 U12006.23
C_TX2_HDMI-_R: length 14.2
  BOTTOM w0.102: C600.2 C592.2 352.08,48.6 351.92,48.45 351.92,48.3 352.02,48.2 352.17,48.2 352.29,48.33 355.73,48.33 359.87,52.47 359.87,54.42 359.73,54.56 359.73,55.34 359.7,55.37 U12006.39
C_TX2_HDMI-_R_R: length 46.1
  TOP w0.102: v1(356.14,97.75) 356.42,98.03 356.68,98.03 356.8,97.91 R3204.2 357.35,97.91 357.41,97.97 357.88,97.97 358.93,99.02 358.93,99.73 359.19,99.98 359.45,99.98 CON3200.3
  IN3 w0.076: v1(360.59,63.85) 360.69,63.95 360.69,64.07 359.83,64.94 359.43,64.94 356.04,68.33 356.04,86.6 356.25,86.81 357.28,87.85 357.28,97.65 356.8,98.13 356.24,98.13 356.14,98.03 v1(356.14,97.75)
  BOTTOM w0.102: v1(360.59,63.85) 360.68,63.85 360.84,63.69 360.84,63.35 359.7,62.2 U12006.22
CALL_ANSWER_LED: length 51.9
  TOP w0.114: Q6801.2 241.71,56.23 242.17,55.77 R6810.1 242.47,55.47 242.68,55.26 246.46,55.26 248.09,53.63 248.09,48.51 248.34,48.26 248.34,45.3 248.83,44.81 248.83,43.84 249.21,43.47 249.21,42.25 248.88,41.93 v1(248.43,41.93)
  IN1 w0.076: v3(271.49,29.22) 271.17,29.54 271.17,30.06 270.92,30.32 269.08,30.32 268.91,30.49 264.69,30.49 264.38,30.8 264.38,32.96 262.96,34.38 258.95,34.38 257.23,36.11 256.26,36.11 254.26,38.1 251.15,38.1 248.43,40.82 v1(248.43,41.93)
  BOTTOM w0.114: U6001.J10 v3(271.49,29.22)

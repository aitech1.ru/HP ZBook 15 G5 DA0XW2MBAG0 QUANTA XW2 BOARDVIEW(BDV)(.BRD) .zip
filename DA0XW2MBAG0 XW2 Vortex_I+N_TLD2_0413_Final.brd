# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_CLKN1: length 64.8
  IN4 w0.076: v1(156.21,95.39) 156.44,95.16 156.65,95.16 156.83,94.97 156.83,89.09 156.56,88.82 156.56,88.07 158.18,86.45 158.18,78.73 149.02,69.56 149.02,69.31 148.83,69.12 148.72,69.12 148.64,69.04 148.64,68.64 148.69,68.58 148.83,68.58 149.02,68.4 149.02,67.86 148.83,67.67 148.69,67.67 148.64,67.62 148.64,66.93 148.51,66.8 148.51,66.57 148.64,66.43 148.64,55.08 148.56,54.99 148.56,54.71 148.64,54.62 148.64,53.63 148.83,53.45 148.83,53.14 148.64,52.96 148.64,52.76 148.69,52.71 149.03,52.71 149.2,52.54 149.2,52.04 149.03,51.87 148.68,51.87 v1(148,51.19)
  BOTTOM w0.076: v1(156.21,95.39) 156.55,95.05 157.09,95.05 157.32,94.83 157.55,94.83 157.94,95.22 157.94,99.87 158.22,100.15 158.22,100.49 158.08,100.63 157.91,100.63 157.83,100.56 U9001.AK1
  BOTTOM w0.102: v1(148,51.19) 147.81,51.19 147.72,51.1 147.72,50.83 147.5,50.6 146.88,50.6 146.78,50.51 146.78,49.84 146.8,49.82 147.07,49.82 147.35,50.1 147.63,50.1 148.16,49.58 148.25,49.58 148.35,49.47 JDIM1001.140
M_A_CLKN2: length 68.3
  TOP w0.102: v1(149.65,51.51) 149.31,51.51 149.13,51.33 149.13,50.16 148.82,49.85 148.43,49.85 148.1,49.53 JDIM1000.139
  IN4 w0.076: v1(156.21,99.2) 156.79,99.2 156.88,99.29 156.88,101.53 157.13,101.79 157.84,101.79 158.24,101.4 158.24,100.08 157.93,99.78 157.93,99.38 158.24,99.07 158.24,96.15 157.85,95.76 157.85,88.63 159.49,86.99 159.49,78.15 150.31,68.97 150.31,64.37 149.94,64 149.94,55.21 150.31,54.84 150.31,51.93 150.1,51.71 149.86,51.71 v1(149.65,51.51)
  BOTTOM w0.076: U9001.AK3 157.61,101.69 157.34,101.95 156.92,101.95 156.62,101.66 156.62,99.62 v1(156.21,99.2)
M_A_CLKN3: length 67.6
  TOP w0.102: JDIM1000.140 148.35,55.56 148.19,55.39 148.19,55.13 148.39,54.92 148.9,54.92 149.12,54.71 149.12,54.33 148.72,53.93 148.72,53.71 148.81,53.63 149.23,53.63 v1(149.66,54.06)
  IN4 w0.076: v1(149.66,54.06) 149.45,53.85 149.36,53.85 149.29,53.92 149.29,64.37 149.37,64.45 149.48,64.45 149.66,64.64 149.66,65.18 149.48,65.36 149.37,65.36 149.29,65.44 149.29,65.82 149.37,65.9 149.48,65.9 149.66,66.08 149.66,66.62 149.48,66.81 149.37,66.81 149.29,66.89 149.29,67.22 149.66,67.59 149.66,69.3 158.83,78.47 158.83,86.72 157.23,88.32 157.23,88.73 157.33,88.83 157.33,95.29 157.02,95.6 157.02,95.96 157.6,96.54 157.6,98.36 157.39,98.56 156.95,98.56 156.73,98.34 156.73,96.94 156.65,96.86 156.57,96.86 156.21,97.22 v1(156.21,97.3)
  BOTTOM w0.076: U9001.AL1 157.09,100.62 157.15,100.67 157.24,100.67 157.39,100.53 157.39,100.26 157.26,100.13 157.26,99.72 157.41,99.56 157.41,98.64 157.32,98.55 157.08,98.55 156.88,98.34 156.88,97.95 157.04,97.78 157.28,97.78 157.36,97.7 157.36,95.8 157.25,95.7 156.96,95.7 156.9,95.75 156.9,96.49 156.21,97.19 v1(156.21,97.3)
M_A_CLKP0: length 66.9
  IN4 w0.076: v1(148,53.1) 147.83,53.26 147.6,53.26 147.44,53.42 147.44,55.2 147.6,55.36 147.76,55.36 147.81,55.41 147.81,55.82 147.73,55.9 147.63,55.9 147.44,56.09 147.44,56.62 147.63,56.81 147.76,56.81 147.81,56.86 147.81,57.29 147.76,57.35 147.63,57.35 147.44,57.53 147.44,58.15 147.63,58.34 147.76,58.34 147.81,58.39 147.81,58.82 147.75,58.87 147.63,58.87 147.44,59.06 147.44,59.6 147.63,59.78 147.73,59.78 147.81,59.86 147.81,60.24 147.73,60.32 147.63,60.32 147.44,60.5 147.44,61.04 147.63,61.23 147.73,61.23 147.81,61.31 147.81,61.69 147.73,61.76 147.63,61.76 147.44,61.95 147.44,62.49 147.63,62.68 147.73,62.68 147.81,62.76 147.81,63.14 147.73,63.21 147.63,63.21 147.44,63.4 147.44,63.94 147.63,64.13 147.73,64.13 147.81,64.2 147.81,64.58 147.73,64.66 147.63,64.66 147.44,64.85 147.44,65.39 147.63,65.57 147.73,65.57 147.81,65.65 147.81,66.03 147.73,66.11 147.63,66.11 147.44,66.3 147.44,66.91 147.81,67.28 147.81,69.54 157.32,79.06 157.32,86.1 155.76,87.66 155.76,89.29 155.95,89.48 156.1,89.48 156.18,89.56 156.18,89.94 156.1,90.01 155.95,90.01 155.76,90.2 155.76,90.74 155.95,90.93 156.1,90.93 156.18,91 156.18,91.39 156.1,91.46 155.95,91.46 155.76,91.65 155.76,91.84 155.61,91.99 155.61,92.89 156.2,93.49 v1(156.22,93.49)
  BOTTOM w0.076: v1(156.22,93.49) 156.45,93.25 158.55,93.25 160.33,95.03 160.33,97.67 160.61,97.95 160.61,100.29 160.51,100.39 U9001.AG1
  BOTTOM w0.102: v1(148,53.1) 147.82,53.27 147.61,53.27 147.48,53.14 146.92,53.14 146.67,53.4 146.67,53.79 146.89,54.02 146.89,54.31 146.67,54.53 146.67,54.95 146.92,55.2 147.63,55.2 147.73,55.3 147.73,55.51 147.6,55.64 JDIM1001.137
M_A_CLKP1: length 64.8
  IN4 w0.076: v1(156.21,94.76) 156.41,94.97 156.57,94.97 156.64,94.89 156.64,89.16 156.37,88.89 156.37,87.99 157.99,86.38 157.99,78.8 148.83,69.64 148.83,69.38 148.75,69.31 148.64,69.31 148.45,69.12 148.45,68.56 148.62,68.39 148.75,68.39 148.83,68.32 148.83,67.94 148.75,67.86 148.62,67.86 148.45,67.7 148.45,67.01 148.32,66.87 148.32,66.49 148.45,66.35 148.45,55.16 148.37,55.07 148.37,54.63 148.45,54.54 148.45,53.55 148.63,53.37 148.63,53.22 148.45,53.04 148.45,52.68 148.62,52.52 148.95,52.52 149.01,52.47 149.01,52.12 148.95,52.07 148.6,52.07 148.45,51.92 148.36,51.83 v1(148,51.83)
  BOTTOM w0.076: U9001.AK2 157.83,100.86 157.91,100.79 158.14,100.79 158.38,100.55 158.38,100.09 158.1,99.81 158.1,95.16 157.61,94.67 157.26,94.67 157.03,94.9 156.35,94.9 v1(156.21,94.76)
  BOTTOM w0.102: JDIM1001.138 147.85,49.59 147.55,49.89 147.44,49.89 147.16,49.61 146.72,49.61 146.58,49.75 146.58,50.59 146.79,50.81 147.41,50.81 147.51,50.91 147.51,51.18 147.58,51.25 147.58,51.41 v1(148,51.83)
M_A_CLKP2: length 68.3
  TOP w0.102: JDIM1000.137 147.6,49.32 148.34,50.05 148.73,50.05 148.93,50.25 148.93,51.42 v1(149.65,52.14)
  IN4 w0.076: v1(156.21,98.57) 156.21,98.65 156.57,99.01 156.87,99.01 157.07,99.21 157.07,101.45 157.21,101.6 157.77,101.6 158.05,101.32 158.05,100.16 157.74,99.86 157.74,99.3 158.05,98.99 158.05,96.23 157.66,95.84 157.66,88.55 159.3,86.91 159.3,78.23 150.12,69.05 150.12,64.45 149.75,64.08 149.75,55.13 150.12,54.76 150.12,52.01 150.02,51.91 149.77,51.91 149.65,52.02 v1(149.65,52.14)
  BOTTOM w0.076: U9001.AL3 156.87,101.69 156.78,101.6 156.78,99.56 156.58,99.36 156.58,98.74 156.41,98.57 v1(156.21,98.57)
M_A_CLKP3: length 67.6
  TOP w0.102: JDIM1000.138 147.85,55.56 147.99,55.43 147.99,55.04 148.31,54.72 148.82,54.72 148.91,54.62 148.91,54.41 148.52,54.02 148.52,53.63 148.73,53.42 v1(149.66,53.42)
  IN4 w0.076: v1(156.21,96.66) 156.73,96.66 156.92,96.86 156.92,98.26 157.03,98.37 157.32,98.37 157.41,98.28 157.41,96.62 156.83,96.04 156.83,95.52 157.14,95.21 157.14,88.91 157.04,88.81 157.04,88.24 158.64,86.64 158.64,78.54 149.47,69.37 149.47,67.67 149.1,67.3 149.1,66.81 149.29,66.62 149.4,66.62 149.47,66.54 149.47,66.16 149.4,66.09 149.29,66.09 149.1,65.9 149.1,65.36 149.29,65.17 149.4,65.17 149.47,65.1 149.47,64.72 149.4,64.64 149.29,64.64 149.1,64.45 149.1,53.84 149.28,53.66 149.43,53.66 v1(149.66,53.42)
  BOTTOM w0.076: U9001.AL2 157.54,100.59 157.54,100.2 157.41,100.07 157.41,99.78 157.56,99.63 157.56,98.57 157.39,98.4 157.14,98.4 157.03,98.28 157.03,98.01 157.11,97.93 157.35,97.93 157.51,97.77 157.51,95.74 157.32,95.55 156.89,95.55 156.75,95.69 156.75,96.43 156.51,96.66 v1(156.21,96.66)
M_A_CS#0: length 62.3
  IN4 w0.114: v1(153.93,52.67) 154.44,53.18 154.44,67.32 163.56,76.45 163.56,86.49 160.36,89.7 160.36,93.66 160.81,94.12 160.81,100.21 162.34,101.74 162.34,102.34 v1(163.31,103.31)
  BOTTOM w0.076: v1(163.31,103.31) 162.98,102.99 U9001.AD5
  BOTTOM w0.102: v1(153.93,52.67) 153.07,53.53 153.07,53.64 152.6,54.1 JDIM1001.149
M_A_CS#1: length 64
  IN4 w0.114: v1(161.23,92.22) 161.66,92.64 161.96,92.64 162.11,92.49 162.11,91.85 162,91.73 161.82,91.73 161.7,91.62 161.7,91.3 161.82,91.18 162,91.18 162.11,91.07 162.11,90.75 162,90.64 161.69,90.64 161.58,90.52 161.58,90.21 161.69,90.09 162,90.09 162.11,89.98 162.11,89.29 165.01,86.39 165.01,75.85 155.91,66.74 155.91,52 155.74,51.84 v1(155.38,51.84)
  BOTTOM w0.076: U9001.AE2 162.12,100.8 161.83,100.51 161.83,100.26 161.96,100.14 161.96,99.16 161.83,99.03 161.83,98.53 160.81,97.51 160.81,92.64 160.9,92.55
  BOTTOM w0.102: JDIM1001.157 154.6,55.62 155.38,54.84 155.38,54.54 155.51,54.41 155.73,54.41 155.84,54.31 155.84,53.98 155.73,53.88 155.48,53.88 155.38,53.78 v1(155.38,51.84)
  BOTTOM w0.178: 160.9,92.55 v1(161.23,92.22)
M_A_CS#2: length 68.8
  TOP w0.102: JDIM1000.149 152.6,50.17 v1(152.39,50.38)
  IN4 w0.114: v1(152.39,50.38) 151.17,50.38 151.06,50.49 151.06,50.87 150.95,50.99 150.63,50.99 150.51,50.87 150.51,50.49 150.4,50.38 149.52,50.38 149.36,50.22 149.36,50 149.51,49.84 152.69,49.84 153.45,50.6 153.89,50.6 154.46,51.18 154.46,51.52 155.49,52.54 155.49,66.92 164.59,76.02 164.59,86.4 161.2,89.8 161.2,91.01 160.84,91.37 160.84,93.09 v1(161.23,93.49)
  BOTTOM w0.076: U9001.AD2 163.27,100.63 163.27,95.52 v1(161.23,93.49)
M_A_CS#3: length 68.6
  TOP w0.102: JDIM1000.157 154.6,49.48 154.95,49.82 155.63,49.82 156.97,51.17 v1(156.97,51.48)
  IN4 w0.114: v1(156.97,51.48) 156.97,50.73 156.85,50.6 156.09,50.6 155.94,50.45 155.94,50.23 156.05,50.11 157.33,50.11 157.48,50.27 157.48,52.1 157.75,52.37 158.11,52.37 158.37,52.63 158.37,57.45 158.72,57.8 158.72,60.73 158.19,61.25 158.19,65.09 167.3,74.19 167.3,86.01 163.29,90.01 163.29,93.15 162.85,93.59 162.85,96.38 162.39,96.84 162.39,98.05 v1(161.23,99.2)
  BOTTOM w0.076: U9001.AE5 162.12,102.77 161.6,102.24 161.6,100.95 161.53,100.87 161.53,100.09 161.62,100 161.62,99.68 161.23,99.3 v1(161.23,99.2)
M_A_DQ0: length 85.5
  TOP w0.102: JDIM1000.7 115.1,49.47 115.2,49.56 115.63,49.56 115.76,49.69 115.76,49.87 115.48,50.15 115.36,50.15 115.08,49.87 114.92,49.87 114.83,49.95 114.83,50.14 115.07,50.38 115.07,50.5 114.7,50.88 114.55,50.88 114.48,50.81 114.48,49.79 114.39,49.7 114.22,49.7 114.06,49.86 v1(114.06,50.44)
  IN4 w0.102: v1(114.06,50.44) 113.89,50.26 112.1,50.26 110.69,51.67 110.69,53.35 112.08,54.74 112.08,55.99 112.66,56.56 112.66,64.26 113.44,65.05 113.44,76.36 123.96,86.88 123.96,88.97 124.57,89.58 124.57,95.99 129.55,100.97 133.07,100.97 134.63,102.53 135.51,102.53 136.18,103.2 v1(137.49,103.2)
  BOTTOM w0.076: v1(137.49,103.2) 137.97,103.67 138.29,103.67 138.44,103.52 139.07,103.52 139.12,103.58 U9001.BR6
  BOTTOM w0.102: JDIM1001.7 115.1,55.31 114.47,54.67 114.47,50.85 v1(114.06,50.44)
M_A_DQ1: length 83.8
  TOP w0.102: v1(116.12,51.92) 116.54,52.34 116.54,54.8 117.35,55.62 JDIM1000.16
  IN4 w0.102: v1(136.09,101.87) 134.91,101.87 133.35,100.31 129.83,100.31 125.23,95.71 125.23,89.31 124.62,88.7 124.62,86.6 114.1,76.09 114.1,64.35 113.98,64.23 113.55,64.23 113.45,64.13 113.45,63.87 113.55,63.77 113.9,63.77 114.03,63.64 114.03,63.26 113.45,62.69 113.45,56.42 112.74,55.71 112.74,54.47 111.35,53.08 111.35,52.06 112.13,51.28 112.98,51.28 113.18,51.48 114.38,51.48 114.59,51.27 115.47,51.27 v1(116.12,51.92)
  BOTTOM w0.076: U9001.BT6 138.73,104.02 137.51,104.02 136.68,103.19 136.68,103.03 136.09,102.44 v1(136.09,101.87)
  BOTTOM w0.102: v1(116.12,51.92) 116.55,51.48 116.55,50.79 116.18,50.42 116.18,49.72 116.34,49.57 116.6,49.57 116.95,49.92 117.21,49.92 117.35,49.77 JDIM1001.16
M_A_DQ2: length 84.5
  TOP w0.102: JDIM1000.20 118.35,55.71 117.3,54.66 117.3,51.48 v1(118.11,50.67)
  IN4 w0.102: v1(137.73,101.02) 137.73,100.44 135.06,97.77 131.01,97.77 127.77,94.53 127.77,88.26 127.16,87.65 127.16,85.55 125.74,84.13 125.74,83.99 125.81,83.92 125.81,83.78 125.63,83.6 125.48,83.6 125.42,83.66 125.27,83.66 125.09,83.48 125.09,83.34 125.16,83.27 125.16,83.13 124.98,82.95 124.84,82.95 124.77,83.02 124.62,83.02 124.45,82.84 124.45,82.69 124.51,82.63 124.51,82.48 124.33,82.3 124.19,82.3 124.12,82.37 123.98,82.37 123.8,82.19 123.8,82.05 123.87,81.98 123.87,81.84 123.69,81.66 123.54,81.66 123.48,81.72 123.33,81.72 123.15,81.54 123.15,81.4 123.22,81.33 123.22,81.19 123.04,81.01 122.9,81.01 122.83,81.08 122.68,81.08 122.51,80.9 122.51,80.75 122.57,80.69 122.57,80.54 122.39,80.36 122.25,80.36 122.18,80.43 122.04,80.43 121.86,80.25 121.86,80.11 121.93,80.04 121.93,79.9 121.75,79.72 121.6,79.72 121.54,79.78 121.39,79.78 121.21,79.6 121.21,79.46 121.28,79.39 121.28,79.25 121.1,79.07 120.96,79.07 120.89,79.14 120.74,79.14 120.57,78.96 120.57,78.81 120.63,78.75 120.63,78.6 120.45,78.42 120.31,78.42 120.24,78.49 120.1,78.49 119.92,78.31 119.92,78.17 119.99,78.1 119.99,77.96 118.88,76.86 118.88,73.65 118.78,73.55 118.55,73.55 118.45,73.45 118.45,73.19 118.55,73.09 118.78,73.09 118.88,72.99 118.88,72.73 118.78,72.63 118.55,72.63 118.45,72.53 118.45,72.28 118.55,72.18 118.78,72.18 118.88,72.07 118.88,71.82 118.78,71.72 118.55,71.72 118.45,71.62 118.45,71.36 118.55,71.26 118.78,71.26 118.88,71.16 118.88,70.91 118.78,70.8 118.55,70.8 118.45,70.7 118.45,63.31 116.49,61.36 116.49,54.06 116.76,53.79 116.76,52.59 117.43,51.92 117.43,50.9 117.66,50.67 v1(118.11,50.67)
  BOTTOM w0.076: U9001.BP3 139.84,102.09 139.28,102.09 139.21,102.01 138.45,102.01 138.33,101.88 138,101.88 137.73,101.61 v1(137.73,101.02)
  BOTTOM w0.102: v1(118.11,50.67) 117.76,50.67 117.63,50.8 117.63,51.85 117.48,52 117.18,52 117,51.82 117,50.5 117.38,50.12 118.24,50.12 118.35,50.01 JDIM1001.20
M_A_DQ3: length 84.5
  TOP w0.102: JDIM1000.3 114.1,49.41 113.04,50.48 113.04,51.08 113.84,51.88 113.84,54.61 v1(114.29,55.07)
  IN4 w0.102: v1(137.28,100.57) 136.23,100.57 134.42,98.76 130.6,98.76 126.78,94.94 126.78,88.67 126.17,88.06 126.17,85.96 116.64,76.44 116.64,76.19 116.75,76.09 116.92,76.09 117.02,75.99 117.02,75.78 116.92,75.68 116.75,75.68 116.64,75.58 116.64,75.38 116.75,75.28 116.92,75.28 117.02,75.17 117.02,74.97 116.92,74.87 116.75,74.87 116.64,74.77 116.64,74.57 116.75,74.46 116.92,74.46 117.02,74.36 117.02,74.16 116.92,74.06 116.75,74.06 116.64,73.96 116.64,73.75 116.75,73.65 116.92,73.65 117.02,73.55 117.02,73.35 116.92,73.24 116.75,73.24 116.64,73.14 116.64,72.94 116.75,72.84 116.92,72.84 117.02,72.74 117.02,72.53 116.92,72.43 116.75,72.43 116.64,72.33 116.64,67.15 116.54,67.05 116.18,67.05 116.08,66.95 116.08,66.75 116.18,66.65 116.54,66.65 116.65,66.54 116.65,66.34 116.54,66.24 116.18,66.24 116.08,66.14 116.08,65.94 116.18,65.83 116.54,65.83 116.65,65.73 116.65,65.53 116.54,65.43 116.16,65.43 116.08,65.35 116.08,65.1 116.16,65.02 116.54,65.02 116.65,64.92 116.65,64.72 116.54,64.61 116.16,64.61 116.08,64.54 116.08,64.28 116.16,64.21 116.54,64.21 116.65,64.11 116.65,63.9 116.54,63.8 116.16,63.8 116.08,63.73 116.08,63.47 116.16,63.4 116.62,63.4 116.72,63.29 116.72,63.09 116.62,62.99 116.23,62.99 116.08,62.84 116.08,62.35 115.35,61.62 115.35,57.09 115.25,56.99 115.1,56.99 115,56.89 115,56.69 115.1,56.59 115.25,56.59 115.35,56.49 115.35,56.28 115.25,56.18 115.1,56.18 115,56.08 115,55.88 115.1,55.77 115.25,55.77 115.35,55.67 115.35,55.34 115.08,55.07 v1(114.29,55.07)
  BOTTOM w0.076: v1(137.28,100.57) 137.83,100.57 138.55,101.3 138.94,101.3 U9001.BR3
  BOTTOM w0.102: v1(114.29,55.07) 114.02,54.8 113.49,54.8 113.39,54.69 113.39,53.91 113.24,53.75 112.98,53.75 112.86,53.88 112.86,54.69 112.76,54.8 112.27,54.8 112.17,54.9 112.17,55.2 112.27,55.3 113.82,55.3 114.1,55.58 JDIM1001.3
M_A_DQ4: length 84.2
  TOP w0.102: JDIM1000.8 115.35,55.24 115.41,55.19 115.41,52.37 115,51.96 v1(115,51.9)
  IN4 w0.102: v1(115,51.9) 114.54,51.9 114.28,52.16 114.28,52.61 113.07,53.81 113.07,55.58 113.78,56.28 113.78,62.55 114.43,63.2 114.43,63.69 114.55,63.81 114.76,63.81 114.86,63.91 114.86,64.16 114.76,64.26 114.55,64.26 114.45,64.36 114.45,64.62 114.55,64.72 114.76,64.72 114.86,64.82 114.86,65.08 114.76,65.18 114.55,65.18 114.45,65.28 114.45,65.53 114.55,65.63 114.76,65.63 114.86,65.74 114.86,65.99 114.76,66.09 114.55,66.09 114.45,66.19 114.45,66.45 114.55,66.55 114.76,66.55 114.86,66.65 114.86,66.9 114.76,67.01 114.55,67.01 114.45,67.11 114.45,67.36 114.55,67.46 114.76,67.46 114.86,67.56 114.86,67.82 114.76,67.92 114.66,67.92 114.55,68.02 114.55,75.06 114.73,75.23 115.32,75.23 115.42,75.34 115.42,75.59 115.32,75.69 114.58,75.69 114.48,75.78 114.48,76 124.95,86.47 124.95,88.56 125.56,89.17 125.56,95.58 129.96,99.98 133.48,99.98 134.92,101.42 v1(135.64,101.42)
  BOTTOM w0.076: 135.97,102.77 137.39,104.19 137.82,104.19 137.91,104.28 139.04,104.28 139.14,104.18 140.02,104.18 140.4,103.8 140.4,103.34 U9001.BN5
  BOTTOM w0.102: v1(115,51.9) 114.9,51.8 114.9,50.37 115.05,50.22 115.31,50.22 115.53,50.43 115.73,50.43 115.88,50.29 115.88,49.83 115.76,49.72 115.48,49.72 115.35,49.59 JDIM1001.8
  BOTTOM w0.165: 135.97,102.77 135.64,102.44 v1(135.64,101.42)
M_A_DQ5: length 85
  TOP w0.102: v1(114.06,51.08) 114.06,54.24 114.7,54.88 114.7,55.31 114.35,55.65 JDIM1000.4
  IN4 w0.102: v1(137.04,102.75) 136.3,102.75 135.76,102.2 134.77,102.2 133.21,100.64 129.69,100.64 124.9,95.85 124.9,89.45 124.29,88.84 124.29,86.74 113.77,76.23 113.77,64.68 113.65,64.56 113.42,64.56 112.99,64.13 112.99,63.87 113.37,63.49 113.37,63.13 113.12,62.89 113.12,56.56 112.41,55.85 112.41,54.61 111.02,53.21 111.02,51.81 112.19,50.64 112.88,50.64 113.32,51.08 v1(114.06,51.08)
  BOTTOM w0.076: v1(137.04,102.75) 137.04,103.3 137.58,103.84 138.47,103.84 138.64,103.67 138.99,103.67 139.19,103.87 139.56,103.87 139.75,103.68 U9001.BP6
  BOTTOM w0.102: JDIM1001.4 114.35,49.82 114.14,50.03 113.57,50.03 113.25,49.72 112.78,49.72 112.5,50 112.5,50.78 112.8,51.08 v1(114.06,51.08)
M_A_DQ6: length 84.4
  TOP w0.102: v1(116.12,53.82) 115.69,53.39 115.69,52.35 115.42,52.09 115.42,51.06 116.09,50.39 116.6,50.39 117.6,49.39 JDIM1000.17
  IN4 w0.102: v1(135.85,99.28) 134.68,98.1 130.87,98.1 127.44,94.67 127.44,88.39 126.83,87.78 126.83,85.69 119.41,78.27 119.41,78.13 119.48,78.05 119.48,77.92 119.29,77.73 119.16,77.73 119.09,77.8 118.94,77.8 118.76,77.62 118.76,77.48 118.84,77.41 118.84,77.27 118.65,77.08 118.51,77.08 118.44,77.16 118.3,77.16 118.04,76.9 118.04,76.48 118.24,76.28 118.45,76.28 118.55,76.18 118.55,75.92 118.45,75.82 118.22,75.82 118.12,75.72 118.12,75.47 118.22,75.36 118.45,75.36 118.55,75.26 118.55,75.01 118.45,74.91 118.22,74.91 118.12,74.81 118.12,74.55 118.22,74.45 118.45,74.45 118.55,74.35 118.55,74.09 118.45,73.99 118.22,73.99 118.12,73.89 118.12,73.62 117.96,73.46 117.79,73.46 117.68,73.36 117.68,73.11 117.79,73.01 118.02,73.01 118.12,72.9 118.12,72.65 118.02,72.55 117.79,72.55 117.68,72.45 117.68,72.19 117.79,72.09 118.02,72.09 118.12,71.99 118.12,71.74 118.02,71.63 117.79,71.63 117.68,71.53 117.68,71.28 117.79,71.18 118.02,71.18 118.12,71.08 118.12,70.82 118.02,70.72 117.79,70.72 117.68,70.62 117.68,70.36 117.79,70.26 118.02,70.26 118.12,70.16 118.12,69.91 118.02,69.81 117.79,69.81 117.68,69.7 117.68,69.45 117.79,69.35 118.02,69.35 118.12,69.25 118.12,68.99 118.02,68.89 117.79,68.89 117.68,68.79 117.68,68.54 117.79,68.43 118.02,68.43 118.12,68.33 118.12,68.08 118.02,67.98 117.79,67.98 117.68,67.88 117.68,67.62 117.79,67.52 118.02,67.52 118.12,67.42 118.12,67.16 118.02,67.06 117.79,67.06 117.68,66.96 117.68,66.71 117.79,66.61 118.02,66.61 118.12,66.5 118.12,66.25 118.02,66.15 117.79,66.15 117.68,66.05 117.68,65.79 117.79,65.69 118.02,65.69 118.12,65.59 118.12,65.34 118.02,65.23 117.79,65.23 117.68,65.13 117.68,64.88 117.79,64.78 118.02,64.78 118.12,64.68 118.12,64.42 118.02,64.32 117.79,64.32 117.68,64.22 117.68,63.96 117.79,63.86 117.94,63.86 118.12,63.68 118.12,63.45 116.12,61.45 v1(116.12,53.82)
  BOTTOM w0.076: U9001.BP2 139.65,100.75 139.65,100.2 139.52,100.07 139.38,100.07 138.59,99.28 135.97,99.28
  BOTTOM w0.102: v1(116.12,53.82) 116.54,53.4 116.54,53.02 116.69,52.87 116.95,52.87 117.1,53.02 117.1,53.88 117.6,54.39 117.6,54.77 117.72,54.89 118.28,54.89 118.4,55.01 118.4,55.3 118.28,55.42 117.72,55.42 117.6,55.54 JDIM1001.17
  BOTTOM w0.165: 135.97,99.28 v1(135.85,99.28)
M_A_DQ7: length 84.2
  TOP w0.102: JDIM1000.21 118.6,49.38 117.39,50.6 116.62,50.6 116.61,50.6 116.18,50.6 115.68,51.09 115.68,52.07 116.12,52.5 v1(116.12,52.55)
  IN4 w0.102: v1(136.28,99.76) 135.77,99.76 134.44,98.43 130.74,98.43 127.11,94.8 127.11,88.53 126.5,87.92 126.5,85.83 117.28,76.61 117.28,76.32 117.41,76.2 117.69,76.2 117.8,76.1 117.8,75.89 117.69,75.79 117.46,75.79 117.35,75.69 117.35,75.49 117.46,75.38 117.69,75.38 117.8,75.28 117.8,75.08 117.69,74.98 117.46,74.98 117.35,74.88 117.35,74.65 117.43,74.57 117.69,74.57 117.8,74.47 117.8,74.27 117.69,74.16 117.46,74.16 117.35,74.06 117.35,72.16 117.28,72.09 117.08,72.09 116.97,71.99 116.97,71.76 117.05,71.68 117.25,71.68 117.35,71.58 117.35,71.38 117.25,71.28 117.08,71.28 116.97,71.17 116.97,70.97 117.08,70.87 117.25,70.87 117.35,70.77 117.35,70.56 117.25,70.46 117.08,70.46 116.97,70.36 116.97,70.16 117.08,70.06 117.25,70.06 117.35,69.95 117.35,69.75 117.25,69.65 117.08,69.65 116.97,69.55 116.97,69.34 117.08,69.24 117.25,69.24 117.35,69.14 117.35,68.94 117.25,68.84 117.08,68.84 116.97,68.74 116.97,68.53 117.08,68.43 117.25,68.43 117.35,68.33 117.35,68.13 117.25,68.02 117.08,68.02 116.97,67.92 116.97,67.72 117.08,67.62 117.25,67.62 117.35,67.52 117.35,67.31 117.25,67.21 117.08,67.21 116.97,67.11 116.97,66.91 117.08,66.8 117.25,66.8 117.35,66.7 117.35,66.5 117.25,66.4 117.08,66.4 116.97,66.3 116.97,66.09 117.08,65.99 117.25,65.99 117.35,65.89 117.35,65.69 117.25,65.59 117.08,65.59 116.97,65.48 116.97,65.28 117.08,65.18 117.25,65.18 117.35,65.08 117.35,64.87 117.25,64.77 117.08,64.77 116.97,64.67 116.97,64.47 117.08,64.37 117.25,64.37 117.35,64.26 117.35,64.06 117.25,63.96 117.08,63.96 116.97,63.86 116.97,63.66 117.08,63.55 117.25,63.55 117.35,63.45 117.35,63.16 115.68,61.49 115.68,52.98 v1(116.12,52.55)
  BOTTOM w0.076: U9001.BN3 140.54,101.53 139.78,101.53 139.68,101.43 139.32,101.43 139.13,101.24 139.11,101.21 139.11,100.86 139.11,100.76 138.52,100.17 138.1,100.17 137.96,100.32 137.55,100.32 137.53,100.3 137.53,100.3 136.92,99.69 136.34,99.69 v1(136.28,99.76)
  BOTTOM w0.102: JDIM1001.21 118.6,54.91 117.63,53.94 117.63,52.76 117.1,52.23 116.44,52.23 v1(116.12,52.55)
M_A_DQ8: length 77
  TOP w0.102: JDIM1000.28 120.35,55.8 120.11,55.56 119.69,55.56 119.12,54.99 118.68,54.99 117.71,54.02 117.71,52.98 v1(118.11,52.58)
  IN4 w0.102: v1(142.4,102.01) 142.18,101.79 140.7,101.79 136.07,97.16 131.54,97.16 128.58,94.19 128.58,85.4 119.7,76.52 119.7,70.11 119.6,70.01 119.36,70.01 119.26,69.91 119.26,69.65 119.36,69.55 119.6,69.55 119.7,69.45 119.7,69.2 119.6,69.1 119.36,69.1 119.26,68.99 119.26,62.98 117.3,61.02 117.3,55.92 117.68,55.54 117.68,55.25 117.3,54.88 117.3,54.4 117.57,54.13 117.57,53.12 v1(118.11,52.58)
  BOTTOM w0.076: v1(142.4,102.01) 142.08,102.34 U9001.BL4
  BOTTOM w0.102: JDIM1001.28 120.35,49.58 119.11,50.83 119.11,52.61 118.88,52.84 118.38,52.84 v1(118.11,52.58)
M_A_DQ9: length 77.6
  TOP w0.102: JDIM1000.24 119.35,55.56 119.17,55.37 118.77,55.37 117.5,54.1 117.5,52.55 v1(118.11,51.94)
  IN4 w0.102: v1(118.11,51.94) 118.09,51.94 117.24,52.79 117.24,53.99 116.97,54.26 116.97,61.16 118.93,63.11 118.93,70.05 119.37,70.48 119.37,76.66 127.64,84.93 127.64,87.45 128.25,88.06 128.25,94.33 131.33,97.41 135.91,97.41 140.54,102.04 141.78,102.04 v1(142.4,102.66)
  BOTTOM w0.076: U9001.BL5 142.08,102.99 v1(142.4,102.66)
  BOTTOM w0.102: JDIM1001.24 119.35,49.7 118.93,50.12 118.76,50.12 118.62,50.25 118.62,50.71 118.88,50.96 118.88,51.25 118.78,51.35 118.62,51.35 118.52,51.45 118.52,51.73 118.62,51.83 118.78,51.83 118.88,51.93 118.88,52.43 118.8,52.51 118.68,52.51 v1(118.11,51.94)
M_A_DQ10: length 75
  TOP w0.102: v1(121.42,52.75) 121.01,53.16 121.01,54.24 121.32,54.54 121.76,54.54 122.85,55.64 JDIM1000.38
  IN4 w0.102: v1(121.42,52.75) 121.01,53.16 121.01,61.14 121.56,61.69 122.11,61.69 122.24,61.81 122.24,70.15 122.59,70.5 122.79,70.5 122.89,70.6 122.89,70.86 122.79,70.96 122.34,70.96 122.24,71.06 122.24,71.31 122.34,71.42 122.79,71.42 122.89,71.52 122.89,71.77 122.79,71.87 122.34,71.87 122.24,71.97 122.24,72.23 122.34,72.33 122.79,72.33 122.89,72.43 122.89,72.69 122.79,72.79 122.34,72.79 122.24,72.89 122.24,73.14 122.34,73.24 122.79,73.24 122.89,73.35 122.89,73.6 122.79,73.7 122.34,73.7 122.24,73.8 122.24,74.06 122.34,74.16 122.79,74.16 122.89,74.26 122.89,76.12 131.45,84.68 131.45,88.76 131.12,89.09 131.12,93.14 133.16,95.17 137.16,95.17 139.99,98.01 v1(139.99,98.91)
  BOTTOM w0.076: v1(139.99,98.91) 140.55,98.91 141.96,100.31 U9001.BL2
  BOTTOM w0.102: v1(121.42,52.75) 121.8,52.75 121.95,52.6 121.95,50.39 122.85,49.48 JDIM1001.38
M_A_DQ11: length 75.6
  TOP w0.102: JDIM1000.42 123.85,55.59 123.51,55.24 123.03,55.24 122.33,54.54 122.33,52.74 122.18,52.59 122.01,52.59 121.86,52.73 121.86,53.58 v1(121.42,54.02)
  IN4 w0.102: v1(121.42,54.02) 121.42,58.33 121.57,58.49 121.9,58.49 122.07,58.66 122.07,60.55 121.93,60.7 121.93,61.03 122.57,61.67 122.57,66.21 122.67,66.31 123.07,66.31 123.17,66.41 123.17,66.67 123.07,66.77 122.67,66.77 122.57,66.87 122.57,67.13 122.67,67.23 123.07,67.23 123.17,67.33 123.17,67.58 123.07,67.68 122.67,67.68 122.57,67.79 122.57,68.04 122.67,68.14 123.07,68.14 123.17,68.24 123.17,68.5 123.07,68.6 122.67,68.6 122.57,68.7 122.57,68.95 122.67,69.06 123.07,69.06 123.17,69.16 123.17,69.41 123.07,69.51 122.67,69.51 122.57,69.62 122.57,69.85 122.66,69.95 123.1,69.95 123.22,70.07 123.22,75.98 131.86,84.62 131.86,88.86 131.45,89.27 131.45,93 133.37,94.92 137.19,94.92 140.92,98.65 v1(140.92,99.8)
  BOTTOM w0.076: v1(140.92,99.8) 141.5,100.39 U9001.BM1
  BOTTOM w0.102: JDIM1001.42 123.85,49.52 123.6,49.78 123.02,49.78 122.33,50.47 122.33,52.64 121.93,53.04 121.93,53.51 v1(121.42,54.02)
M_A_DQ12: length 77.6
  TOP w0.102: v1(119.75,51.39) 119.15,52 118.9,52 118.8,51.9 118.8,50.6 119.3,50.1 120.22,50.1 120.6,49.72 JDIM1000.29
  IN4 w0.102: v1(143.19,102.01) 143.19,102 141.6,100.42 140.04,100.42 136.27,96.65 131.97,96.65 129.24,93.92 129.24,85.13 120.36,76.25 120.36,65.44 119.92,65 119.92,62.7 118.53,61.31 118.53,51.99 119.12,51.39 v1(119.75,51.39)
  BOTTOM w0.076: U9001.BK4 v1(143.19,102.01)
  BOTTOM w0.102: v1(119.75,51.39) 119.35,51.8 119.35,54.22 120.6,55.48 JDIM1001.29
M_A_DQ13: length 78
  TOP w0.102: v1(118.11,53.85) 118.54,53.42 118.54,50.46 119.6,49.4 JDIM1000.25
  IN4 w0.102: v1(118.11,53.85) 118.11,55.62 117.74,56 117.74,56.53 118.11,56.91 118.11,57.24 117.63,57.72 117.63,60.88 119.59,62.84 119.59,65.77 119.69,65.87 119.93,65.87 120.03,65.97 120.03,66.22 119.93,66.32 119.69,66.32 119.59,66.43 119.59,66.68 119.69,66.78 119.93,66.78 120.03,66.88 120.03,67.14 119.93,67.24 119.69,67.24 119.59,67.34 119.59,67.59 119.69,67.7 119.93,67.7 120.03,67.8 120.03,68.05 119.93,68.15 119.69,68.15 119.59,68.25 119.59,68.51 119.69,68.61 119.93,68.61 120.03,68.71 120.03,76.38 128.91,85.27 128.91,94.06 131.76,96.9 136.19,96.9 140.69,101.4 142.33,101.4 142.8,101.88 142.8,102.28 v1(143.19,102.66)
  BOTTOM w0.076: U9001.BK5 v1(143.19,102.66)
  BOTTOM w0.102: JDIM1001.25 119.6,55.71 119.92,55.4 119.92,55.18 119.79,55.05 119.11,55.05 118.98,54.92 118.98,54.67 118.76,54.45 118.76,54.15 119.03,53.88 119.03,53.27 118.9,53.14 118.65,53.14 118.52,53.27 118.52,53.65 118.33,53.85 v1(118.11,53.85)
M_A_DQ14: length 76.2
  TOP w0.102: v1(121.42,52.12) 121.63,52.33 121.88,52.33 122.08,52.13 122.08,50.86 121.55,50.33 121.55,50.15 121.72,49.97 121.89,49.97 122.02,50.1 122.4,50.1 122.74,49.76 123.25,49.76 123.6,49.4 JDIM1000.41
  IN4 w0.102: v1(139.54,98.46) 139.54,97.89 137.08,95.43 132.94,95.43 130.79,93.28 130.79,88.69 131.02,88.46 131.02,84.72 121.91,75.6 121.91,75.27 122.01,75.17 122.46,75.17 122.56,75.07 122.56,74.82 122.46,74.71 122.01,74.71 121.91,74.61 121.91,64.4 121.81,64.3 121.57,64.3 121.47,64.2 121.47,63.95 121.57,63.85 121.81,63.85 121.91,63.74 121.91,63.49 121.81,63.39 121.57,63.39 121.47,63.29 121.47,63.03 121.57,62.93 121.81,62.93 121.91,62.83 121.91,62.5 120.68,61.27 120.68,52.29 120.85,52.12 v1(121.42,52.12)
  BOTTOM w0.076: U9001.BK1 140.43,98.46 v1(139.54,98.46)
  BOTTOM w0.102: v1(121.42,52.12) 120.99,52.55 120.99,54.21 121.57,54.8 122.21,54.8 122.97,55.56 123.4,55.56 123.6,55.76 JDIM1001.41
M_A_DQ15: length 78.1
  TOP w0.102: v1(121.42,50.85) 121.06,50.85 120.83,51.08 120.83,51.9 120.68,52.05 120.43,52.05 120.3,51.93 120.3,50.63 121.22,49.72 122.23,49.72 122.6,49.35 JDIM1000.37
  IN4 w0.102: v1(137.25,96.18) 136.75,95.68 132.73,95.68 130.46,93.41 130.46,84.62 121.58,75.74 121.58,64.78 121.14,64.34 121.14,62.2 120.35,61.41 120.35,51.92 v1(121.42,50.85)
  BOTTOM w0.076: U9001.BK2 143.08,100.75 143.08,99.79 139.69,96.41 139.65,96.41 139.43,96.18 138.65,96.18
  BOTTOM w0.102: JDIM1001.37 122.6,55.64 122.14,55.18 121.66,55.18 120.73,54.25 120.73,51.54 v1(121.42,50.85)
  BOTTOM w0.165: 138.65,96.18 v1(137.25,96.18)
M_A_DQ16: length 75.2
  TOP w0.102: v1(123.39,52.01) 123.86,52.48 123.86,54.54 124.85,55.54 JDIM1000.46
  IN4 w0.102: v1(142.93,98.78) 141.73,98.78 137.77,94.82 137.77,89.38 124.03,75.65 124.03,75.32 124.14,75.21 124.67,75.21 124.77,75.11 124.77,74.86 124.67,74.76 124.14,74.76 124.03,74.66 124.03,74.4 124.14,74.3 124.67,74.3 124.77,74.2 124.77,73.94 124.67,73.84 124.14,73.84 124.03,73.74 124.03,66.13 123.38,65.47 123.38,57.9 123.13,57.65 122.35,57.65 122.23,57.53 122.23,52.97 123.2,52.01 v1(123.39,52.01)
  BOTTOM w0.076: U9001.BG4 144.32,102.34 144.23,102.25 144.23,100.96 144.08,100.81 144.08,100.18 144.43,99.83 144.43,99.45 143.76,98.78 v1(142.93,98.78)
  BOTTOM w0.102: v1(123.39,52.01) 122.92,51.54 122.92,50.5 123.26,50.16 124.53,50.16 124.85,49.84 JDIM1001.46
M_A_DQ17: length 77.6
  TOP w0.102: JDIM1000.50 125.85,55.55 124.24,53.93 124.24,51.59 v1(123.39,50.74)
  IN4 w0.102: v1(123.39,50.74) 121.9,52.22 121.9,57.67 122.56,58.32 122.56,60.98 123.05,61.47 123.05,65.61 123.7,66.27 123.7,75.78 137.5,89.58 137.5,94.83 141.9,99.23 v1(143.38,99.23)
  BOTTOM w0.076: U9001.BG5 143.92,102.39 143.92,100.11 144.22,99.82 144.22,99.51 143.94,99.23 v1(143.38,99.23)
  BOTTOM w0.102: JDIM1001.50 125.85,50.02 125.14,50.74 124.56,50.74 124.43,50.86 124.43,52.08 124.31,52.21 124.1,52.21 123.95,52.05 123.95,50.84 123.85,50.74 v1(123.39,50.74)
M_A_DQ18: length 75.8
  TOP w0.102: JDIM1000.63 129.1,49.8 129.01,49.9 128.63,49.9 128.53,49.99 128.53,50.58 128.41,50.7 128.24,50.7 128.13,50.58 128.13,50.12 128.03,50.02 127.81,50.02 127.72,50.12 127.72,50.48 127.59,50.6 127.34,50.6 127.16,50.78 127.16,51.59 v1(127.16,51.6)
  IN4 w0.102: v1(145.7,102.01) 144.52,100.83 144.52,99.13 141.94,96.55 141.94,95.74 139.57,93.37 139.57,87.64 138.61,86.68 138.61,86.68 127.5,75.57 127.5,70.09 127.4,69.99 127.08,69.99 126.98,69.89 126.98,69.68 127.08,69.58 127.4,69.58 127.5,69.48 127.5,69.28 127.4,69.18 127.08,69.18 126.98,69.07 126.98,68.87 127.08,68.77 127.4,68.77 127.5,68.67 127.5,68.46 127.4,68.36 127.08,68.36 126.98,68.26 126.98,68.06 127.08,67.96 127.4,67.96 127.5,67.85 127.5,67.65 127.4,67.55 127.08,67.55 126.98,67.45 126.98,67.24 127.08,67.14 127.4,67.14 127.5,67.04 127.5,66.84 127.4,66.74 127.08,66.74 126.98,66.64 126.98,66.43 127.08,66.33 127.4,66.33 127.5,66.23 127.5,66.03 127.4,65.92 126.47,65.92 126.24,65.7 126.24,52.41 127.06,51.6 v1(127.16,51.6)
  BOTTOM w0.076: v1(145.7,102.01) 145.38,102.34 U9001.BF4
  BOTTOM w0.102: JDIM1001.63 129.1,55.51 127.77,54.17 127.77,52.21 v1(127.16,51.6)
M_A_DQ19: length 77.8
  TOP w0.102: JDIM1000.58 127.85,55.81 127.6,55.56 126.27,55.56 124.57,53.86 124.57,53.27 124.67,53.17 124.92,53.17 125.05,53.3 125.05,53.73 125.32,54 v1(125.64,54)
  IN4 w0.102: v1(125.64,54) 125.64,57.52 125.26,57.9 125.26,60.4 125.41,60.54 125.73,60.54 125.91,60.73 125.91,66.08 126.09,66.26 126.44,66.26 126.65,66.47 126.65,70.22 126.75,70.32 127.07,70.32 127.17,70.42 127.17,70.62 127.07,70.72 126.75,70.72 126.65,70.83 126.65,71.03 126.75,71.13 127.07,71.13 127.17,71.23 127.17,71.44 127.07,71.54 126.75,71.54 126.65,71.64 126.65,71.84 126.75,71.94 127.07,71.94 127.17,72.05 127.17,72.25 127.07,72.35 126.75,72.35 126.65,72.45 126.65,72.66 126.75,72.76 127.07,72.76 127.17,72.86 127.17,73.06 127.07,73.16 126.75,73.16 126.65,73.26 126.65,73.47 126.75,73.57 127.07,73.57 127.17,73.67 127.17,73.87 127.07,73.98 126.75,73.98 126.65,74.08 126.65,74.28 126.75,74.38 127.07,74.38 127.17,74.48 127.17,74.69 127.07,74.79 126.75,74.79 126.65,74.89 126.65,75.18 139.29,87.83 139.29,93.47 141.3,95.48 141.3,96.37 144.25,99.32 144.25,101.53 145.38,102.66 v1(145.7,102.66)
  BOTTOM w0.076: v1(145.7,102.66) 145.38,102.99 U9001.BF5
  BOTTOM w0.102: JDIM1001.58 127.85,49.37 127.44,49.78 126.69,49.78 125.21,51.27 125.21,53.57 v1(125.64,54)
M_A_DQ20: length 75.8
  TOP w0.102: v1(123.39,53.28) 122.96,52.84 122.96,50.57 123.32,50.2 124.79,50.2 125.6,49.38 JDIM1000.49
  IN4 w0.102: v1(123.39,53.28) 122.56,54.1 122.56,55.06 122.71,55.21 123.37,55.21 123.48,55.31 123.48,55.59 123.37,55.69 122.66,55.69 122.56,55.79 122.56,56.07 122.66,56.17 123.37,56.17 123.48,56.28 123.48,56.56 123.37,56.66 122.82,56.66 122.71,56.76 122.71,57.09 122.82,57.19 123.2,57.19 123.71,57.7 123.71,65.34 124.37,65.99 124.37,72.65 125.1,73.39 125.1,76.24 138.05,89.19 138.05,94.75 141.15,97.86 v1(142.03,97.86)
  BOTTOM w0.076: U9001.BG2 144.52,100.79 144.23,100.49 144.23,100.25 144.63,99.84 144.63,99.4 143.66,98.42 143.15,98.42 142.53,97.8 142.09,97.8 v1(142.03,97.86)
  BOTTOM w0.102: v1(123.39,53.28) 123.95,53.84 124.09,53.84 124.31,53.62 124.46,53.62 124.65,53.81 124.65,53.96 124.19,54.42 124.19,54.62 124.34,54.77 124.52,54.77 124.77,54.52 124.77,54.52 124.99,54.3 125.14,54.3 125.34,54.5 125.34,54.64 124.97,55 124.97,55.15 125.16,55.34 125.5,55.34 125.6,55.44 JDIM1001.49
M_A_DQ21: length 75.4
  TOP w0.102: JDIM1000.45 124.6,49.3 123.94,49.97 123.27,49.97 122.75,50.48 122.75,53.91 v1(123.39,54.55)
  IN4 w0.102: v1(123.39,54.55) 124.04,55.2 124.04,60.9 124.68,61.54 124.68,61.82 124.58,61.92 124.14,61.92 124.04,62.03 124.04,62.3 124.14,62.41 124.58,62.41 124.68,62.51 124.68,62.79 124.58,62.89 124.14,62.89 124.04,62.99 124.04,63.27 124.14,63.37 124.58,63.37 124.68,63.47 124.68,63.75 124.58,63.85 124.14,63.85 124.04,63.96 124.04,64.24 124.14,64.34 124.58,64.34 124.68,64.44 124.68,64.72 124.58,64.82 124.14,64.82 124.04,64.92 124.04,65.2 124.14,65.3 124.58,65.3 124.7,65.42 124.7,66.64 124.97,66.92 124.97,67.43 124.7,67.71 124.7,72.52 125.43,73.25 125.43,76.11 138.33,89.01 138.33,94.73 141.05,97.45 v1(141.54,97.45)
  BOTTOM w0.076: v1(141.54,97.45) 141.62,97.37 142.63,97.37 143.4,98.13 143.62,98.13 144.84,99.35 144.84,99.86 144.52,100.17 U9001.BG1
  BOTTOM w0.102: JDIM1001.45 124.6,55.43 124.29,55.12 123.16,55.12 122.33,54.29 122.33,53.09 122.46,52.96 122.76,52.96 122.9,53.1 122.9,54.05 v1(123.39,54.55)
M_A_DQ22: length 75.2
  TOP w0.102: v1(127.16,54.14) 126.96,54.14 126.65,53.83 126.65,53.27 126.52,53.14 126.32,53.14 126.19,53.27 126.19,53.98 127.39,55.18 128.4,55.18 128.85,55.63 JDIM1000.62
  IN4 w0.102: v1(127.16,54.14) 127.37,54.14 127.53,54.29 127.53,54.6 127.43,54.7 126.98,54.7 126.91,54.78 126.91,55.03 126.98,55.11 127.43,55.11 127.53,55.21 127.53,55.41 127.43,55.51 127.01,55.51 126.91,55.62 126.91,55.82 127.01,55.92 127.43,55.92 127.53,56.02 127.53,56.23 127.43,56.33 127.01,56.33 126.91,56.43 126.91,56.63 127.01,56.73 127.43,56.73 127.53,56.84 127.53,57.04 127.43,57.14 127.01,57.14 126.91,57.24 126.91,57.47 126.98,57.55 127.43,57.55 127.53,57.65 127.53,61.81 127.63,61.91 128.06,61.91 128.16,62.01 128.16,62.22 128.06,62.32 127.63,62.32 127.53,62.42 127.53,62.62 127.63,62.73 128.06,62.73 128.16,62.83 128.16,63.03 128.06,63.13 127.63,63.13 127.53,63.23 127.53,63.44 127.63,63.54 128.06,63.54 128.16,63.64 128.16,63.84 128.06,63.94 127.63,63.94 127.53,64.05 127.53,64.38 128.16,65.01 128.16,75.3 140.13,87.27 140.13,93.04 142.82,95.73 142.82,96.57 145.22,98.97 145.22,99.57 v1(145.7,100.06)
  BOTTOM w0.076: U9001.BF1 145.38,100.39 v1(145.7,100.06)
  BOTTOM w0.102: v1(127.16,54.14) 126.73,53.7 126.73,51.29 127.84,50.18 128.04,50.18 128.85,49.37 JDIM1001.62
M_A_DQ23: length 73.7
  TOP w0.102: JDIM1000.59 128.1,49.42 126.73,50.79 126.73,52.43 v1(127.16,52.87)
  IN4 w0.102: v1(145.7,100.71) 144.89,99.89 144.89,99.04 142.32,96.48 142.32,95.74 139.85,93.27 139.85,87.45 127.83,75.43 127.83,65.89 127.43,65.49 126.68,65.49 126.57,65.39 126.57,65.19 126.68,65.09 127.36,65.09 127.46,64.98 127.46,64.78 127.36,64.68 126.68,64.68 126.57,64.58 126.57,64.37 126.68,64.27 127.1,64.27 127.2,64.17 127.2,63.97 127.1,63.87 126.68,63.87 126.57,63.76 126.57,63.56 126.68,63.46 127.1,63.46 127.2,63.36 127.2,63.15 127.1,63.05 126.68,63.05 126.57,62.95 126.57,62.75 126.68,62.65 127.1,62.65 127.2,62.55 127.2,62.34 127.1,62.24 126.68,62.24 126.57,62.14 126.57,61.94 126.68,61.83 127.1,61.83 127.2,61.73 127.2,61.53 127.1,61.43 126.68,61.43 126.57,61.33 126.57,61.12 126.68,61.02 127.1,61.02 127.2,60.92 127.2,60.72 126.57,60.09 126.57,53.45 v1(127.16,52.87)
  BOTTOM w0.076: v1(145.7,100.71) 145.38,101.04 U9001.BF2
  BOTTOM w0.102: v1(127.16,52.87) 127.57,53.27 127.57,54.39 127.29,54.67 127.29,54.94 127.48,55.13 127.71,55.13 127.88,54.96 128.08,54.96 128.25,55.13 128.25,55.35 128.1,55.5 JDIM1001.59
M_A_DQ24: length 71.8
  TOP w0.102: JDIM1000.66 129.85,55.71 129.65,55.5 129.17,55.5 128.94,55.27 128.94,55.02 128.78,54.87 127.74,54.87 127.57,54.7 127.57,53.5 127.67,53.4 127.87,53.4 127.98,53.51 127.98,54.22 128.06,54.3 128.31,54.3 v1(128.39,54.22)
  IN4 w0.102: v1(144.36,97.42) 144.36,96.86 144.18,96.68 144.18,96.3 140.77,92.89 140.77,86.75 129.26,75.25 129.26,72.76 129.16,72.66 129.08,72.66 128.97,72.56 128.97,72.33 129.05,72.25 129.16,72.25 129.26,72.15 129.26,71.95 129.16,71.84 129.08,71.84 128.97,71.74 128.97,71.54 129.08,71.44 129.16,71.44 129.26,71.34 129.26,71.13 129.16,71.03 129.08,71.03 128.97,70.93 128.97,70.73 129.08,70.63 129.16,70.63 129.26,70.52 129.26,70.32 129.16,70.22 129.08,70.22 128.97,70.12 128.97,69.89 129.05,69.81 129.16,69.81 129.26,69.71 129.26,69.51 129.16,69.41 129.08,69.41 128.97,69.3 128.97,69.1 129.08,69 129.16,69 129.26,68.9 129.26,68.7 129.16,68.59 129.08,68.59 128.97,68.49 128.97,68.26 129.05,68.19 129.16,68.19 129.26,68.09 129.26,67.88 129.16,67.78 129.08,67.78 128.97,67.68 128.97,67.45 129.05,67.37 129.16,67.37 129.26,67.27 129.26,67.07 129.16,66.97 129.08,66.97 128.97,66.87 128.97,66.66 129.08,66.56 129.16,66.56 129.26,66.46 129.26,66.26 129.16,66.16 129.05,66.16 128.97,66.08 128.97,65.82 129.05,65.75 129.16,65.75 129.26,65.65 129.26,65.44 129.16,65.34 129.08,65.34 128.97,65.24 128.97,58 128.39,57.42 v1(128.39,54.22)
  BOTTOM w0.076: U9001.BD2 147.04,100.8 146.74,100.51 146.74,100.06 146.82,99.98 146.82,98.89 146.01,98.08 145.55,98.08 144.89,97.42 v1(144.36,97.42)
  BOTTOM w0.102: JDIM1001.66 129.85,49.45 127.97,51.33 127.97,53.8 v1(128.39,54.22)
M_A_DQ25: length 69.6
  TOP w0.102: v1(128.39,52.95) 127.98,52.54 127.98,51.51 130.1,49.39 JDIM1000.67
  IN4 w0.102: v1(128.39,52.95) 128.13,52.95 128.01,53.06 128.01,60.52 128.11,60.62 128.54,60.62 128.64,60.72 128.64,60.92 128.54,61.03 128.11,61.03 128.01,61.13 128.01,61.33 128.11,61.43 128.54,61.43 128.64,61.53 128.64,73.09 128.75,73.19 128.83,73.19 128.93,73.29 128.93,73.49 128.83,73.6 128.75,73.6 128.64,73.7 128.64,73.9 128.75,74 128.83,74 128.93,74.1 128.93,74.31 128.83,74.41 128.75,74.41 128.64,74.51 128.64,75.1 140.49,86.94 140.49,92.98 143.91,96.4 v1(143.91,96.97)
  BOTTOM w0.076: U9001.BD1 147.04,98.5 146.27,97.74 145.64,97.74 144.87,96.97 v1(143.91,96.97)
  BOTTOM w0.102: v1(128.39,52.95) 128.75,52.59 128.96,52.59 129.14,52.76 129.14,52.94 128.84,53.25 128.84,54.44 130.1,55.71 JDIM1001.67
M_A_DQ26: length 72.4
  TOP w0.102: JDIM1000.80 133.35,55.78 131.99,54.42 131.16,54.42 130.67,53.93 130.67,52.87 v1(131.08,52.46)
  IN4 w0.102: v1(131.08,52.46) 131.4,52.46 131.48,52.54 131.48,53.96 131.18,54.26 131.18,54.76 131.29,54.87 131.38,54.87 131.48,54.97 131.48,55.17 131.38,55.27 131.29,55.27 131.18,55.37 131.18,55.58 131.29,55.68 131.38,55.68 131.48,55.78 131.48,55.98 131.38,56.08 131.29,56.08 131.18,56.19 131.18,56.39 131.29,56.49 131.38,56.49 131.48,56.59 131.48,56.8 131.38,56.9 131.29,56.9 131.18,57 131.18,57.2 131.29,57.3 131.38,57.3 131.48,57.41 131.48,57.61 131.38,57.71 131.29,57.71 131.18,57.81 131.18,61.5 131.48,61.8 131.48,74.29 142.82,85.63 142.82,92.54 146.59,96.3 146.59,101.08 146.69,101.18 146.95,101.18 147.05,101.08 147.05,100.75 147.15,100.65 147.4,100.65 147.5,100.75 147.5,101.3 v1(148.22,102.01)
  BOTTOM w0.076: v1(148.22,102.01) 147.89,102.34 U9001.BC4
  BOTTOM w0.102: JDIM1001.80 133.35,49.55 131.49,51.42 131.49,52.01 131.83,52.36 131.83,52.57 131.64,52.76 131.38,52.76 v1(131.08,52.46)
M_A_DQ27: length 73.6
  TOP w0.102: v1(131.08,53.73) 131.4,53.73 131.6,53.53 131.6,53.01 131.76,52.86 131.96,52.86 132.11,53.02 132.11,54.05 133.48,55.42 134.14,55.42 134.35,55.63 JDIM1000.84
  IN4 w0.102: v1(131.08,53.73) 130.85,53.96 130.85,61.64 131.15,61.94 131.15,74.48 142.49,85.82 142.49,92.53 146.34,96.38 146.34,101.44 146.66,101.76 147.38,101.76 147.5,101.89 147.5,102.14 147.4,102.25 146.49,102.25 146.36,102.37 146.36,102.69 146.46,102.79 146.95,102.79 147.3,103.14 147.74,103.14 v1(148.22,102.66)
  BOTTOM w0.076: U9001.BC5 147.89,102.99 v1(148.22,102.66)
  BOTTOM w0.102: v1(131.08,53.73) 132.11,52.7 132.11,51.38 133.66,49.84 133.84,49.84 134.35,49.32 JDIM1001.84
M_A_DQ28: length 73
  TOP w0.102: JDIM1000.71 131.1,49.58 130.21,50.48 130.21,53.23 v1(129.63,53.81)
  IN4 w0.102: v1(145.7,98.79) 145.96,98.54 145.96,97.9 144.68,96.63 144.68,96.05 141.4,92.77 141.4,86.45 129.93,74.98 129.93,64.77 129.83,64.67 129.74,64.67 129.63,64.57 129.63,64.37 129.74,64.27 129.83,64.27 129.93,64.16 129.93,63.96 129.83,63.86 129.74,63.86 129.63,63.76 129.63,63.55 129.74,63.45 129.83,63.45 129.93,63.35 129.93,63.15 129.83,63.05 129.74,63.05 129.63,62.94 129.63,62.74 129.74,62.64 129.86,62.64 129.93,62.56 129.93,62.44 129.63,62.14 129.63,57.27 129.53,57.16 129.19,57.16 129.1,57.07 129.1,56.82 129.16,56.76 129.53,56.76 129.63,56.66 129.63,56.45 129.53,56.35 129.19,56.35 129.1,56.26 129.1,56.01 129.16,55.94 129.53,55.94 129.63,55.84 129.63,55.64 129.53,55.54 129.19,55.54 129.1,55.45 129.1,55.19 129.16,55.13 129.53,55.13 129.63,55.03 129.63,54.83 129.53,54.73 129.19,54.73 129.1,54.63 129.1,54.38 129.16,54.32 129.53,54.32 129.63,54.22 v1(129.63,53.81)
  BOTTOM w0.076: v1(145.7,98.79) 146.08,99.17 146.08,99.37 146.44,99.73 146.44,101.04 146.52,101.12 146.52,102.47 U9001.BD5
  BOTTOM w0.102: v1(129.63,53.81) 129.95,54.12 129.95,54.29 129.57,54.67 129.57,54.85 129.73,55 129.92,55 130.36,54.57 131.28,54.57 131.4,54.69 131.4,54.93 131.28,55.05 130.97,55.05 130.84,55.18 130.84,55.43 131.1,55.69 JDIM1001.71
M_A_DQ29: length 72.7
  TOP w0.102: JDIM1000.70 130.85,55.7 130.4,55.24 129.76,55.24 128.8,54.28 128.8,52.08 v1(128.39,51.68)
  IN4 w0.102: v1(128.39,51.68) 128.77,51.3 128.99,51.3 129.15,51.46 129.15,52.97 128.77,53.34 128.77,57.33 129.3,57.86 129.3,64.82 129.6,65.11 129.6,75.12 141.05,86.56 141.05,92.79 144.44,96.19 144.44,96.66 145.25,97.47 v1(145.25,98.34)
  BOTTOM w0.076: v1(145.25,98.34) 145.82,98.34 146.59,99.12 146.59,100.68 146.74,100.83 146.74,102.04 U9001.BD4
  BOTTOM w0.102: v1(128.39,51.68) 129.13,51.68 129.23,51.58 129.23,51.38 129.09,51.24 128.68,51.24 128.58,51.14 128.58,51.01 128.83,50.76 128.97,50.76 129.06,50.85 129.2,50.85 129.4,50.65 129.4,50.51 129.31,50.42 129.31,50.28 129.75,49.84 130.66,49.84 130.85,49.64 JDIM1001.70
M_A_DQ30: length 71.8
  TOP w0.102: v1(133.28,50.79) 132.97,50.79 132.85,50.91 132.85,51.93 132.72,52.05 132.52,52.05 132.39,51.93 132.39,50.45 132.49,50.35 132.87,50.35 133.13,50.1 133.89,50.1 134.1,49.88 JDIM1000.83
  IN4 w0.076: 144.02,93.17 143.48,92.64 143.48,92.29
  IN4 w0.102: 143.48,92.29 143.48,85.37 143.49,85.36 132.14,74.02 132.14,61.53 131.84,61.23 131.84,58.18 132.14,57.88 132.14,52.49 132.49,52.14 132.49,50.69 132.67,50.51 133,50.51 v1(133.28,50.79) ; v1(148.22,100.11) 147.1,98.99 147.1,96.25 144.02,93.17
  BOTTOM w0.076: v1(148.22,100.11) 147.94,100.39 U9001.BC1
  BOTTOM w0.102: v1(133.28,50.79) 132.67,51.4 132.67,54.57 133.55,55.45 133.85,55.45 134.1,55.7 JDIM1001.83
M_A_DQ31: length 72.2
  TOP w0.102: JDIM1000.79 133.1,49.61 132.75,49.97 132.21,49.97 132.09,50.1 132.09,51.01 131.99,51.11 131.71,51.11 131.6,51.01 131.6,50.1 131.48,49.97 131.22,49.97 130.59,50.6 130.59,50.99 130.79,51.19 v1(131.08,51.19)
  IN4 w0.102: v1(131.08,51.19) 131.24,51.03 131.55,51.03 131.99,51.46 131.99,52.18 131.81,52.35 131.81,57.75 131.51,58.05 131.51,61.36 131.81,61.66 131.81,74.16 143.15,85.5 143.15,92.59 146.84,96.27 146.84,99.36 v1(148.22,100.74)
  BOTTOM w0.076: v1(148.22,100.74) 147.92,101.04 U9001.BC2
  BOTTOM w0.102: v1(131.08,51.19) 130.64,51.63 130.64,53.87 130.93,54.16 131.54,54.16 133.1,55.73 JDIM1001.79
M_A_DQ32: length 69.3
  TOP w0.102: JDIM1000.174 158.85,55.74 159.54,55.05 160.48,55.05 160.71,54.82 160.71,54.57 160.12,53.97 160.12,53.34 160.21,53.24 160.4,53.24 160.57,53.41 160.57,53.79 160.68,53.9 v1(160.98,53.9)
  IN4 w0.102: v1(160.98,53.9) 160.98,54.41 160.79,54.61 160.79,54.94 160.89,55.04 161.04,55.04 161.14,55.14 161.14,55.35 161.04,55.45 160.89,55.45 160.79,55.55 160.79,55.75 160.89,55.85 161.04,55.85 161.14,55.95 161.14,56.16 161.04,56.26 160.89,56.26 160.79,56.36 160.79,56.56 160.89,56.67 161.04,56.67 161.14,56.77 161.14,56.97 161.04,57.07 160.89,57.07 160.79,57.17 160.79,62.89 160.69,62.99 160.2,62.99 160.1,63.1 160.1,63.3 160.2,63.4 160.69,63.4 160.79,63.5 160.79,63.7 160.69,63.81 160.2,63.81 160.1,63.91 160.1,64.11 160.2,64.21 160.69,64.21 160.79,64.31 160.79,64.57 160.66,64.7 160.66,64.87 167.4,71.61 167.89,71.61 168.57,72.28 168.57,72.65 169.42,73.51 169.42,85.56 164.66,90.32 164.66,93.84 164.2,94.29 v1(164.2,96.8)
  BOTTOM w0.076: v1(164.2,96.8) 164.75,97.35 164.75,100.05 164.7,100.1 164.7,100.32 U9001.AB1
  BOTTOM w0.102: v1(160.98,53.9) 160.43,53.35 160.43,51.15 158.85,49.57 JDIM1001.174
M_A_DQ33: length 69.7
  TOP w0.102: JDIM1000.169 157.6,49.62 158.43,50.45 158.43,51.93 158.53,52.03 158.8,52.03 158.91,51.93 158.91,51.08 159.04,50.96 159.28,50.96 v1(159.67,51.35)
  IN4 w0.102: v1(163.76,97.27) 163.76,94.27 164.41,93.62 164.41,90.29 169.02,85.68 169.02,73.57 168.24,72.79 168.24,72.42 167.76,71.94 167.26,71.94 159.76,64.43 159.76,62.86 159.95,62.67 160.14,62.67 160.46,62.35 160.46,52.94 160.1,52.58 160.1,51.57 159.88,51.35 v1(159.67,51.35)
  BOTTOM w0.076: U9001.AB2 164.36,100.76 164.36,100.27 164.55,100.08 164.55,98.06 v1(163.76,97.27)
  BOTTOM w0.102: v1(159.67,51.35) 158.78,52.24 158.78,54.35 157.6,55.53 JDIM1001.169
M_A_DQ34: length 70.2
  TOP w0.102: JDIM1000.186 161.85,55.58 162.01,55.43 162.59,55.43 162.71,55.31 162.71,55.05 162.58,54.92 161.68,54.92 161.58,54.82 161.58,54.54 161.7,54.41 162.77,54.41 162.97,54.21 162.97,53.86 v1(162.77,53.65)
  IN4 w0.102: v1(162.77,53.65) 162.77,54.29 163.15,54.67 163.15,60.21 162.72,60.64 162.72,61.19 162.84,61.32 163.05,61.32 163.15,61.42 163.15,61.62 163.05,61.73 162.82,61.73 162.72,61.83 162.72,62.03 162.82,62.13 163.05,62.13 163.15,62.23 163.15,62.44 163.05,62.54 162.82,62.54 162.72,62.64 162.72,62.84 162.82,62.94 163.05,62.94 163.15,63.05 163.15,63.25 163.05,63.35 162.82,63.35 162.72,63.45 162.72,63.66 162.82,63.76 163.05,63.76 163.15,63.86 163.15,65 164.12,65.97 164.37,65.97 164.76,66.36 164.76,66.7 165.39,67.33 165.81,67.33 170.12,71.64 170.12,72.01 170.99,72.88 170.99,85.51 169.7,86.8 169.7,87.31 166.04,90.97 166.04,95.46 165.38,96.12 165.38,96.66 164.7,97.34 164.7,100.89 v1(165.82,102.01)
  BOTTOM w0.076: v1(165.82,102.01) 165.49,102.34 U9001.AA4
  BOTTOM w0.102: JDIM1001.186 161.85,51.08 162.72,51.94 162.9,51.94 163.17,52.21 163.17,53.25 v1(162.77,53.65)
M_A_DQ35: length 69.6
  TOP w0.102: v1(162.77,52.38) 161.96,53.19 161.96,53.65 161.26,54.35 161.26,54.86 160.85,55.26 JDIM1000.182
  IN4 w0.102: v1(165.82,102.66) 164.45,101.29 164.45,97.27 165.11,96.6 165.11,96.01 165.82,95.31 165.82,90.69 169.32,87.18 169.32,86.77 170.66,85.43 170.66,73.02 169.79,72.14 169.79,71.78 168.4,70.39 167.96,70.39 167.69,70.12 167.69,69.93 167.74,69.88 167.74,69.74 167.6,69.59 167.46,69.59 167.38,69.67 167.24,69.67 167.09,69.52 167.09,69.38 167.17,69.3 167.17,69.16 167.02,69.02 166.88,69.02 166.8,69.09 166.66,69.09 166.52,68.95 166.52,68.81 166.59,68.73 166.59,68.59 166.45,68.44 166.31,68.44 166.23,68.52 166.09,68.52 165.94,68.37 165.94,68.23 166.02,68.15 166.02,68.01 165.87,67.87 165.73,67.87 165.65,67.94 165.51,67.94 162.39,64.82 162.39,55.26 162.52,55.13 162.52,54.54 162.39,54.41 162.39,52.76 v1(162.77,52.38)
  BOTTOM w0.076: U9001.AA5 165.5,102.99 v1(165.82,102.66)
  BOTTOM w0.102: JDIM1001.182 160.85,49.59 160.59,49.86 160.59,50.45 160.99,50.86 161.24,50.86 v1(162.77,52.38)
M_A_DQ36: length 71.6
  TOP w0.102: v1(159.67,53.89) 159.53,54.03 159.29,54.03 159.22,53.96 159.22,53.15 159.1,53.03 158.9,53.03 158.81,53.11 158.81,54.09 159.32,54.59 159.32,54.9 159.03,55.19 158.08,55.19 157.85,55.41 JDIM1000.170
  IN4 w0.102: v1(163.76,99.22) 163.06,98.52 163.06,96.95 163.3,96.71 163.3,93.96 163.89,93.38 163.89,90.18 168.21,85.86 168.21,73.81 159.1,64.71 159.1,61.63 159.67,61.06 159.67,57.47 159.27,57.07 159.27,55.94 159.38,55.84 159.7,55.84 159.8,55.74 159.8,55.54 159.7,55.44 159.38,55.44 159.27,55.33 159.27,55.13 159.38,55.03 159.7,55.03 159.8,54.93 159.8,54.72 159.7,54.62 159.38,54.62 159.27,54.52 159.27,54.02 159.41,53.89 v1(159.67,53.89)
  BOTTOM w0.076: U9001.AB5 164.05,102.4 164.05,100.12 164.17,100.01 164.17,99.63 v1(163.76,99.22)
  BOTTOM w0.102: JDIM1001.170 157.85,49.29 158.73,50.16 159.16,50.16 160.08,51.08 160.08,53.48 v1(159.67,53.89)
M_A_DQ37: length 69.3
  TOP w0.102: JDIM1000.173 158.6,49.71 160.1,51.2 160.1,52.19 v1(159.67,52.62)
  IN4 w0.102: v1(159.67,52.62) 160.13,53.07 160.13,56.17 160.03,56.27 159.68,56.27 159.6,56.35 159.6,56.6 159.68,56.68 160.03,56.68 160.13,56.78 160.13,61.41 160.03,61.51 159.69,61.51 159.59,61.61 159.59,61.81 159.69,61.91 160.03,61.91 160.13,62.02 160.13,62.21 160.03,62.31 159.52,62.31 159.43,62.4 159.43,64.57 167.23,72.37 167.37,72.37 167.48,72.27 167.62,72.27 167.76,72.41 167.76,72.56 167.66,72.66 167.66,72.8 168.61,73.75 168.61,85.76 164.16,90.21 164.16,93.49 163.53,94.11 163.53,96.89 163.3,97.11 163.3,98.26 163.62,98.57 v1(163.76,98.57)
  BOTTOM w0.076: U9001.AB4 164.35,102.04 164.35,101.2 164.21,101.06 164.21,100.21 164.32,100.09 164.32,99.48 164.14,99.29 164.14,98.96 163.75,98.57 v1(163.76,98.57)
  BOTTOM w0.102: JDIM1001.173 158.6,55.17 159.04,54.73 159.04,52.68 159.23,52.48 159.54,52.48 v1(159.67,52.62)
M_A_DQ38: length 69.7
  TOP w0.102: JDIM1000.183 161.1,49.75 161.58,50.22 161.58,52.43 161.73,52.59 162.02,52.59 162.19,52.41 162.19,51.38 162.34,51.24 162.59,51.24 v1(162.77,51.41)
  IN4 w0.102: v1(162.77,51.41) 163.38,52.02 163.38,54.33 163.48,54.43 163.48,64.53 170.45,71.5 170.45,71.87 171.32,72.75 171.32,85.56 169.96,86.93 169.96,87.36 166.27,91.04 166.27,95.61 165.67,96.22 165.67,96.69 164.97,97.39 164.97,99.87 v1(165.82,100.73)
  BOTTOM w0.076: v1(165.82,100.73) 165.49,101.04 U9001.AA2
  BOTTOM w0.102: JDIM1001.183 161.1,55.55 162.24,54.41 162.58,54.41 163.38,53.62 163.38,52.02 v1(162.77,51.41)

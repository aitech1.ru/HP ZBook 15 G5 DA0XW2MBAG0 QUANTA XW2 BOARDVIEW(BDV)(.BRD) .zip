# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EXT_DPE_HPD: length 122.2
  TOP w0.114: R2118.2 235.89,87.55 236,87.44 C2218.2 ; Q2022.2 228.85,89.03 231.35,91.53 236.81,91.53 237.8,90.54 237.8,89.91 v1(236.89,88.99) 236.63,88.74 C2218.2 ; v1(238.56,86.37) 238.24,86.37 237.16,87.44 C2218.2
  IN2 w0.089: v1(323.24,52.84) 322.86,53.22 322.82,53.22 322.35,53.69 321.53,53.69 318.81,56.41 313.79,56.41 312.58,57.62 307.12,57.62 306.48,56.99 301.15,56.99 300.9,57.24 299.88,57.24 299.22,57.9 294.78,57.9 293.94,58.73 293.87,58.73 292.69,59.91 291.26,59.91 289.95,61.21 289.95,61.66 285.82,65.8 283.43,65.8 281.95,67.29 281.95,67.84 277.89,71.9 276.92,71.9 275.79,73.02 275.53,73.02 273.79,74.77 272.7,74.77 271.69,75.78 271.28,75.78 267.86,79.2 267.86,79.55 262.95,84.46 262.6,84.46 262.03,85.03 260.64,85.03 260.29,84.69 259.97,84.69 258.65,86.01 258.36,86.01 257.76,86.61 255.21,86.61 254.34,85.75 248.96,85.75 248.57,86.14 247.81,86.14 247.44,85.77 245.7,85.77 244.83,84.91 243.56,84.91 243.33,84.68 243.33,84.29 243.06,84.01 241.18,84.01 239.96,85.23 239.59,85.23 239.29,85.53 239.29,85.64 v1(238.56,86.37)
  BOTTOM w0.114: v1(323.24,52.84) 323.81,53.41 U500.16
EXT_DPE_TXN0: length 158.6
  IN3 w0.089: v1(328.58,47.06) 328.38,47.26 327.89,47.26 326.93,46.31 322.93,46.31 321.99,47.25 321.99,48.11 321,49.1 317.58,49.1 317.01,49.67 314.03,49.67 312.5,51.21 311.7,51.21 308.8,54.11 307.07,54.11 305.71,55.48 297.64,55.48 297.31,55.15 295.98,55.15 293.83,57.29 290.1,57.29 285.58,61.81 282.1,61.81 280.03,63.88 280.03,65.48 277.14,68.37 276.01,68.37 274.33,70.06 273.7,70.06 272.62,71.13 272.15,71.13 271.68,71.6 269.44,71.6 268.83,72.22 268.16,72.22 262.4,77.98 262.4,78.79 261.93,79.26 261.93,80.17 260.54,81.57 259.79,81.57 257.65,83.71 257.65,84.58 255.61,86.62 250.05,86.62 249.74,86.93 249.21,86.93 248.53,86.26 247.63,86.26 247.32,85.94 243.15,85.94 241.46,87.63 235.19,87.63 234.33,86.78 230.97,86.78 230.36,86.17 230.07,86.17 229.51,85.61 226.09,85.61 225.6,86.11 224.86,86.11 223.74,84.98 222.17,84.98 222,84.81 213.35,84.81 210.02,88.14 210.02,95.61 208.55,97.08 208.55,99.16 209.08,99.69 v1(209.19,99.69)
  BOTTOM w0.102: U2000.AD3 v1(209.19,99.69)
  BOTTOM w0.114: v1(328.58,47.06) 327.91,47.73 327.91,48.09 328.21,48.4 328.21,48.84 C524.1
EXT_DPE_TXN0_C: length 4.9
  BOTTOM w0.114: C524.2 328.44,50.13 v2(328.44,50.79) 328.44,52.51 328.26,52.69 328.26,53.78 328.21,53.83 U500.5
EXT_DPE_TXN1: length 159.7
  IN3 w0.089: v1(210.03,98.08) 210.03,98.29 209.95,98.36 209.68,98.36 209.61,98.29 209.61,97.83 209.82,97.61 209.82,97.31 210.92,96.21 210.92,88.51 213.37,86.07 219.15,86.07 219.46,85.77 221.67,85.77 222.14,86.23 223.67,86.23 224.61,87.17 230.07,87.17 231.84,88.95 233.14,88.95 233.52,88.57 234.82,88.57 235.43,89.18 236.34,89.18 236.43,89.27 236.43,89.79 236.64,90.01 237.24,90.01 237.46,89.79 237.46,89.27 237.54,89.18 239.74,89.18 239.83,89.27 239.83,89.66 240.04,89.88 240.64,89.88 240.85,89.66 240.85,89.27 240.94,89.18 241.32,89.18 243.56,86.95 246.96,86.95 248.76,88.74 251.42,88.74 252.62,87.53 255.98,87.53 260.66,82.85 260.66,82.72 262.86,80.52 262.86,79.63 263.3,79.19 263.3,78.35 268.32,73.33 269.05,73.33 269.88,72.51 272.19,72.51 272.54,72.16 272.92,72.16 274.07,71.01 274.64,71.01 276.38,69.27 277.58,69.27 281.08,65.78 281.08,64.34 282.61,62.82 285.92,62.82 289.95,58.79 291.29,58.79 291.83,58.26 294.25,58.26 294.51,57.99 299.37,57.99 299.66,58.28 300.77,58.28 302.01,57.04 303.92,57.04 304.65,57.77 306.55,57.77 306.56,57.79 308.05,57.79 309.26,56.57 309.26,55.04 312.08,52.22 312.8,52.22 314.4,50.62 318.29,50.62 318.88,50.04 321.36,50.04 322.84,48.55 322.84,47.89 323.51,47.22 326.38,47.22 326.82,47.65 326.82,50.04 326.96,50.18 326.96,50.31 v1(326.85,50.41)
  BOTTOM w0.102: v1(210.03,98.08) 209.61,98.5 U2000.AC1
  BOTTOM w0.114: C526.1 326.92,51.14 327.12,50.94 327.12,50.68 v1(326.85,50.41)
EXT_DPE_TXN1_C: length 2.6
  BOTTOM w0.114: U500.8 327.01,53.76 327.09,53.68 327.09,52.23 327.08,52.23 327.08,52.2 C526.2
EXT_DPE_TXN2: length 155.6
  IN3 w0.089: v1(325.66,48.17) 325.66,48.17 325.83,48.17 325.89,48.23 325.89,48.24 325.89,48.78 325.52,49.15 324.5,49.15 323.41,50.24 323.41,50.45 322.74,51.11 314.59,51.11 313,52.71 313,52.92 312.17,53.75 311.25,53.75 310.14,54.85 310.14,56.4 308.3,58.24 302.92,58.24 302.42,58.75 299.26,58.75 299.03,58.52 294.66,58.52 294.36,58.83 293.08,58.83 292.12,59.79 289.71,59.79 285.71,63.79 283.85,63.79 277.9,69.74 276.98,69.74 275.22,71.5 274.47,71.5 272.73,73.24 270.08,73.24 263.43,79.9 263.43,80.62 261.46,82.59 261.46,82.82 256.25,88.03 252.86,88.03 251.5,89.38 248.69,89.38 246.89,87.59 243.69,87.59 240.93,90.36 239.5,90.36 239.31,90.17 239.31,89.87 239.1,89.65 238.5,89.65 238.28,89.87 238.28,90.59 237.47,91.4 237.01,91.4 235.29,89.68 231.77,89.68 230.37,88.28 224.37,88.28 223.12,87.03 222.27,87.03 222.01,86.77 221.94,86.69 221.15,86.69 220.72,86.26 219.63,86.26 219.35,86.54 213.58,86.54 211.5,88.62 211.5,91.77 212.44,92.71 212.44,95.99 210.71,97.72 210.71,98.17 209.61,99.27 209.61,100.1 v1(209.2,100.5)
  BOTTOM w0.102: v1(209.2,100.5) 209.58,100.13 U2000.AC3
  BOTTOM w0.114: v1(325.66,48.17) 325.72,48.24 325.72,48.79 C528.1
EXT_DPE_TXN2_C: length 4.8
  BOTTOM w0.114: U500.11 325.81,53.86 325.89,53.78 v2(325.89,53.05) 325.89,50.11 C528.2
EXT_DPE_TXN3: length 156.8
  IN3 w0.089: v1(324.47,50.38) 324.62,50.38 324.74,50.5 324.74,50.67 323.58,51.82 314.92,51.82 313.9,52.85 313.9,54.75 311.91,56.75 310.88,56.75 309.05,58.57 309.05,59.05 309.05,59.05 309.05,59.07 308.73,59.39 307.1,59.39 306.82,59.11 303.19,59.11 302.86,59.44 296.68,59.44 296.53,59.59 294.05,59.59 291.72,61.91 289.24,61.91 286.35,64.8 283.84,64.8 277.82,70.82 277.11,70.82 275.57,72.35 274.7,72.35 273.11,73.94 270.38,73.94 264.39,79.93 264.39,80.94 261.53,83.8 261.53,84.33 258.17,87.68 258.17,88.09 257.8,88.46 257.8,88.64 257.77,88.67 257.77,88.68 257.42,89.03 254.81,89.03 254.15,89.69 254.15,89.69 253.61,90.22 253.31,90.22 253.1,90.43 248.74,90.43 247.83,89.52 246.81,88.5 243.78,88.5 240.27,92.01 237.93,92.01 237.39,92.55 236.76,92.55 235.49,91.28 234.84,91.28 234.63,91.49 234.63,92.7 234.54,92.79 234.12,92.79 234.03,92.7 234.03,91.49 233.81,91.28 231.07,91.28 230.35,90.55 230.35,89.7 229.61,88.97 223.24,88.97 221.65,87.38 219.23,87.38 219.07,87.23 213.87,87.23 212.19,88.91 212.19,91.47 213.14,92.42 213.14,96.48 211.61,98.01 211.61,98.85 209.18,101.28 v1(209.18,101.31)
  BOTTOM w0.102: U2000.AC5 209.57,101.7 v1(209.18,101.31)
  BOTTOM w0.114: C530.1 324.54,50.86 324.54,50.46 v1(324.47,50.38)
EXT_DPE_TXN3_C: length 2.8
  BOTTOM w0.114: C530.2 324.59,52.24 324.59,52.75 325.03,53.19 325.03,53.73 325.01,53.76 U500.13
EXT_DPE_TXP0: length 158.6
  IN3 w0.089: v1(328.58,47.69) 328.37,47.47 327.8,47.47 326.84,46.52 323.02,46.52 322.21,47.34 322.21,48.2 321.09,49.32 317.67,49.32 317.1,49.89 314.12,49.89 312.59,51.42 311.79,51.42 308.89,54.33 307.16,54.33 305.8,55.69 297.55,55.69 297.22,55.36 296.07,55.36 293.92,57.51 290.19,57.51 285.67,62.03 282.19,62.03 280.24,63.97 280.24,65.57 277.23,68.59 276.1,68.59 274.42,70.27 273.79,70.27 272.71,71.35 272.24,71.35 271.77,71.82 269.53,71.82 268.92,72.43 268.25,72.43 262.62,78.07 262.62,78.88 262.15,79.35 262.15,80.26 260.62,81.78 259.88,81.78 257.87,83.8 257.87,84.67 255.7,86.84 250.14,86.84 249.83,87.15 249.12,87.15 248.44,86.48 247.54,86.48 247.23,86.16 243.24,86.16 241.55,87.85 235.1,87.85 234.24,87 230.88,87 230.82,86.93 230.27,86.39 229.98,86.39 229.42,85.83 226.18,85.83 225.69,86.32 224.77,86.32 223.65,85.2 222.08,85.2 221.91,85.03 213.44,85.03 210.24,88.23 210.24,95.7 208.77,97.17 208.77,99.07 208.99,99.29 209.26,99.29 209.33,99.23 209.33,99.02 v1(209.18,98.88)
  BOTTOM w0.102: U2000.AD2 208.78,99.27 v1(209.18,98.88)
  BOTTOM w0.114: v1(328.58,47.69) 328.36,47.69 328.2,47.85 328.2,47.97 328.5,48.27 328.5,49.11 328.61,49.21 328.85,49.21 C523.1
EXT_DPE_TXP0_C: length 4.9
  BOTTOM w0.114: U500.4 328.61,53.83 328.56,53.78 328.56,52.81 328.73,52.63 v2(328.73,52.19) 328.73,50.11 C523.2
EXT_DPE_TXP1: length 159.7
  IN3 w0.089: v1(327.49,50.41) 327.17,50.09 327.03,49.95 327.03,47.56 326.47,47 323.42,47 322.62,47.8 322.62,48.47 321.27,49.82 318.79,49.82 318.2,50.41 314.31,50.41 312.71,52.01 311.99,52.01 309.05,54.95 309.05,56.48 307.96,57.57 306.65,57.57 306.64,57.56 304.74,57.56 304.01,56.82 301.92,56.82 300.68,58.07 299.75,58.07 299.46,57.77 294.42,57.77 294.16,58.04 291.74,58.04 291.2,58.57 289.86,58.57 285.83,62.6 282.52,62.6 280.87,64.25 280.87,65.69 277.5,69.06 276.29,69.06 274.55,70.8 273.98,70.8 272.83,71.95 272.45,71.95 272.1,72.29 269.79,72.29 268.96,73.12 268.23,73.12 263.09,78.26 263.09,79.1 262.64,79.54 262.64,80.43 260.45,82.63 260.45,82.76 255.89,87.31 252.53,87.31 251.33,88.52 248.85,88.52 247.05,86.73 243.47,86.73 242.34,87.86 241.23,88.97 240.85,88.97 240.64,89.18 240.64,89.58 240.55,89.66 240.13,89.66 240.04,89.58 240.04,89.18 239.83,88.97 237.46,88.97 237.24,89.18 237.24,89.7 237.15,89.79 236.73,89.79 236.64,89.7 236.64,89.18 236.43,88.97 235.52,88.97 234.91,88.36 233.43,88.36 233.05,88.74 231.93,88.74 230.16,86.96 224.7,86.96 223.75,86.02 222.23,86.02 221.76,85.55 219.37,85.55 219.06,85.85 213.28,85.85 210.71,88.43 210.71,96.12 209.61,97.22 209.61,97.53 209.39,97.74 209.39,97.89 v1(209.19,98.09)
  BOTTOM w0.102: U2000.AD1 v1(209.19,98.09)
  BOTTOM w0.114: C525.1 327.58,51.14 327.41,50.97 327.41,50.48 v1(327.49,50.41)
EXT_DPE_TXP1_C: length 2.7
  BOTTOM w0.114: U500.7 327.38,54.36 v2(327.38,52.93) 327.38,52.35 C525.2
EXT_DPE_TXP2: length 155.6
  IN3 w0.089: v1(326.42,48.17) 326.26,48.17 326.1,48.33 326.1,48.87 325.61,49.37 324.59,49.37 323.63,50.33 323.63,50.54 322.83,51.33 314.68,51.33 313.21,52.8 313.21,53.01 312.26,53.96 311.34,53.96 310.36,54.94 310.36,56.49 308.39,58.46 303.01,58.46 302.51,58.97 299.17,58.97 298.94,58.74 294.75,58.74 294.45,59.05 293.17,59.05 292.21,60 289.8,60 285.79,64.01 283.94,64.01 277.99,69.96 277.07,69.96 275.31,71.72 274.56,71.72 272.82,73.46 270.17,73.46 263.65,79.99 263.65,80.71 261.68,82.68 261.68,82.91 256.34,88.24 252.95,88.24 251.59,89.6 248.6,89.6 246.8,87.81 243.78,87.81 241.02,90.58 239.41,90.58 239.1,90.26 239.1,89.96 239.01,89.87 238.59,89.87 238.5,89.96 238.5,90.68 237.56,91.62 236.92,91.62 235.2,89.89 231.68,89.89 230.28,88.5 224.28,88.5 223.03,87.24 222.18,87.24 221.85,86.91 221.06,86.91 220.63,86.48 219.72,86.48 219.64,86.55 219.44,86.76 213.67,86.76 211.72,88.71 211.72,91.68 212.66,92.62 212.66,96.08 210.92,97.81 210.92,98.26 209.82,99.36 209.82,99.5 v1(210.01,99.68)
  BOTTOM w0.102: v1(210.01,99.68) 209.62,99.3 U2000.AC2
  BOTTOM w0.114: v1(326.42,48.17) 326.27,48.17 326.02,48.43 326.02,49.04 326.12,49.14 326.39,49.14 C527.1
EXT_DPE_TXP2_C: length 4.8
  BOTTOM w0.114: U500.10 326.21,53.77 326.18,53.75 326.18,53.05 326.18,53.05 v2(326.18,50.82) 326.18,50.13 C527.2
EXT_DPE_TXP3: length 156.8
  IN3 w0.089: v1(325.15,50.38) 325.14,50.38 324.95,50.57 324.95,50.76 323.67,52.04 315.01,52.04 314.12,52.94 314.12,54.84 311.99,56.96 310.97,56.96 309.27,58.66 309.27,59.14 309.27,59.14 309.27,59.16 308.82,59.6 307.01,59.6 306.73,59.32 303.28,59.32 302.95,59.65 296.77,59.65 296.62,59.81 294.14,59.81 291.81,62.13 289.33,62.13 286.44,65.01 283.93,65.01 277.91,71.03 277.2,71.03 275.66,72.57 274.79,72.57 273.2,74.16 270.47,74.16 264.6,80.02 264.6,81.03 261.74,83.89 261.74,84.42 258.39,87.77 258.39,88.18 258.01,88.55 258.01,88.74 257.51,89.24 254.9,89.24 253.7,90.44 253.4,90.44 253.19,90.64 248.65,90.64 246.72,88.71 243.87,88.71 240.35,92.23 238.02,92.23 237.48,92.76 236.67,92.76 235.4,91.49 234.93,91.49 234.84,91.58 234.84,92.79 234.63,93 234.03,93 233.81,92.79 233.81,91.58 233.72,91.49 230.98,91.49 230.13,90.64 230.13,89.79 229.52,89.18 223.15,89.18 221.56,87.59 219.14,87.59 218.98,87.44 213.96,87.44 212.4,89 212.4,91.38 213.35,92.33 213.35,96.57 211.83,98.1 211.83,98.94 209.96,100.8 v1(209.96,101.31)
  BOTTOM w0.102: v1(209.96,101.31) 209.96,101.28 U2000.AC4
  BOTTOM w0.114: v1(325.15,50.38) 324.83,50.7 324.83,50.99 324.98,51.14 C529.1
EXT_DPE_TXP3_C: length 2.9
  BOTTOM w0.114: C529.2 324.88,52.31 324.88,52.63 325.33,53.07 325.33,53.68 325.41,53.76 U500.12
EXT_DPF_AUX_SRCN: length 7.3
  BOTTOM w0.114: U501.61 340.97,34.36 340.94,34.32 v2(340.94,33.26) 340.94,32.74 340.04,31.84 339.2,31.84 338.96,31.6 338.96,30.41 338.4,29.85 337.95,29.85 C565.2
EXT_DPF_AUX_SRCP: length 7.2
  BOTTOM w0.114: C564.2 337.76,30.23 337.85,30.14 338.28,30.14 338.66,30.53 v2(338.66,30.95) 338.66,31.72 339.08,32.13 339.92,32.13 340.65,32.86 340.65,34.29 340.57,34.36 U501.62
EXT_DPF_AUXN: length 182.1
  TOP w0.114: R10042.2 207.15,95.63 207.53,95.63 207.64,95.73 207.64,96.01 207.77,96.14 207.77,96.94 208.02,97.19 208.02,98.65 207.78,98.89 v1(207.49,98.89)
  IN3 w0.089: v1(327.92,37.35) 328.13,37.14 328.13,36.99 327.99,36.86 324.94,36.86 321.99,39.8 319.68,39.8 319.34,39.45 312.04,39.45 308.63,42.86 307.41,42.86 305.26,45.01 305.26,45.38 304.81,45.84 302.3,45.84 301.3,46.84 297.2,46.84 296.23,45.87 289.15,45.87 286.8,48.22 284.17,48.22 282.75,49.65 281.33,49.65 280.18,50.79 279.22,50.79 276.73,53.28 272.18,53.28 271.14,54.32 269.49,54.32 268.37,55.44 266.53,55.44 265.84,56.12 265.84,57.59 265.21,58.22 264.23,58.22 263.14,59.31 263.14,60.2 263.37,60.43 263.37,62.1 262.54,62.93 261.98,62.93 259.46,65.46 258.67,65.46 253.92,70.21 253.92,71.2 252.97,72.15 252.28,72.15 251.26,73.17 251.12,73.17 250.77,73.52 250.77,74.91 249.93,75.75 249.93,76.38 249.37,76.94 248.85,76.94 248.6,77.19 248.6,77.56 246.98,79.17 244.44,79.17 243.54,80.08 243.54,80.18 240.09,83.63 234.08,83.63 232.39,81.94 229.92,81.94 229.44,82.42 213.1,82.42 208.08,87.44 207.87,87.44 206.92,88.39 206.92,90.41 207.82,91.32 207.82,96.21 207.08,96.95 207.08,99.15 207.23,99.3 207.37,99.3 207.49,99.18 v1(207.49,98.89)
  BOTTOM w0.102: U2000.AF2 v1(207.49,98.89)
  BOTTOM w0.114: C565.1 336.98,30 336.89,30.09 336.73,30.09 336.59,29.94 335.52,29.94 335.12,29.54 333.39,29.54 331.4,31.53 v2(331.4,32.53) 331.4,33.08 328.19,36.29 328.19,37.09 v1(327.92,37.35)
EXT_DPF_AUXP: length 182.1
  TOP w0.114: R10043.2 208.06,96.81 208.31,97.07 208.31,98.77 207.46,99.62 v1(207.46,99.7)
  IN3 w0.089: v1(207.46,99.7) 207.28,99.51 207.14,99.51 206.86,99.24 206.86,96.86 207.6,96.13 207.6,91.41 206.7,90.5 206.7,88.3 207.78,87.22 208,87.22 213.01,82.2 229.35,82.2 229.83,81.72 232.48,81.72 234.17,83.42 240.01,83.42 243.33,80.09 243.33,79.99 244.35,78.96 246.89,78.96 248.38,77.47 248.38,77.1 248.76,76.72 249.28,76.72 249.71,76.29 249.71,75.66 250.55,74.82 250.55,73.43 251.03,72.95 251.17,72.95 252.19,71.94 252.88,71.94 253.7,71.11 253.7,70.12 258.58,65.24 259.37,65.24 261.89,62.71 262.45,62.71 263.15,62.01 263.15,60.52 262.92,60.29 262.92,59.22 264.14,58 265.12,58 265.63,57.5 265.63,56.03 266.44,55.22 268.28,55.22 269.4,54.1 271.05,54.1 272.09,53.06 276.64,53.06 279.13,50.57 280.09,50.57 281.24,49.43 282.66,49.43 284.08,48.01 286.71,48.01 289.06,45.66 296.32,45.66 297.29,46.62 301.21,46.62 302.21,45.62 304.72,45.62 305.05,45.29 305.05,44.92 307.32,42.65 308.54,42.65 310.19,41 311.95,39.24 319.43,39.24 319.77,39.59 321.9,39.59 324.85,36.64 328.08,36.64 328.34,36.9 328.34,37.14 v1(328.56,37.35)
  BOTTOM w0.102: v1(207.46,99.7) 207.46,99.72 U2000.AF3
  BOTTOM w0.114: v1(328.56,37.35) 328.48,37.28 328.48,36.41 331.69,33.2 331.69,31.65 333.51,29.83 335,29.83 335.4,30.24 336.47,30.24 336.51,30.28 336.88,30.65 C564.1
EXT_DPF_HPD: length 193.3
  TOP w0.114: Q2023.5 223.04,88.23 225,86.27 v1(225,85.61) ; v1(233.89,69.74) 234.33,69.3 C2220.2 R2123.2
  IN2 w0.089: v1(337.45,41.44) 338.13,40.76 338.13,33.34 337.95,33.16 337.95,30.67 337.22,29.94 335.04,29.94 v1(334.7,30.28) ; v1(233.08,34.41) 234.13,34.41 234.83,35.11 234.83,37.91 235.37,38.45 235.37,47.66 234.88,48.15 234.88,58.1 236.02,59.24 236.02,60.53 235.19,61.36 235.19,63.36 234.82,63.72 234.82,64.99 234.73,65.09 234.73,68.96 233.95,69.74 v1(233.89,69.74) 233.87,69.76 233.87,72.41 234.22,72.76 234.22,73.22 233.76,73.67 233.35,73.67 232.07,74.96 231.67,74.96 230.43,76.19 229.78,76.19 229.36,76.61 229.36,79.17 227.81,80.73 227.81,81.51 226.03,83.29 226.03,84.59 v1(225,85.61)
  IN3 w0.089: v1(245.62,34.61) 246.16,35.14 249.21,35.14 250.6,36.54 252.83,36.54 253.55,35.82 254.48,35.82 254.83,36.17 265.36,36.17 266.67,34.86 270.15,34.86 271.49,33.52 279.36,33.52 281.05,31.83 282.22,31.83 282.63,32.25 285.17,32.25 285.4,32.48 285.4,33.64 286.03,34.27 296.46,34.27 298.79,31.94 300.78,31.94 302.06,30.66 303.84,30.66 304.78,29.72 307.41,29.72 309.68,27.45 319.87,27.45 320.71,26.61 329.05,26.61 332.29,29.86 334.28,29.86 v1(334.7,30.28)
  BOTTOM w0.114: v1(233.08,34.41) 233.56,33.92 235.92,33.92 237.3,32.55 241.11,32.55 243.42,34.86 245.38,34.86 v1(245.62,34.61) ; v1(337.45,41.44) U501.16
EXT_DPF_TXN0: length 172
  IN3 w0.089: v1(208.34,100.49) 207.87,100.03 207.87,99.16 208.15,98.88 208.15,96.85 209.33,95.66 209.33,87.84 213.05,84.13 222.28,84.13 222.45,84.3 224.02,84.3 224.3,84.58 230.07,84.58 230.57,85.08 230.96,85.08 231.6,85.73 234.51,85.73 235.54,86.76 241.36,86.76 242.95,85.17 245.26,85.17 247.39,83.03 248.15,83.03 248.81,82.37 248.81,82 250.9,79.91 251.83,79.91 252.6,79.15 252.6,77.61 252.43,77.44 252.43,76.8 252.98,76.25 254.25,76.25 254.71,76.71 255.49,76.71 257.29,74.91 257.29,74.58 256.52,73.81 256.52,71.36 257.68,70.21 257.68,70 258.64,69.04 259.05,69.04 259.13,69.12 259.86,69.12 260.12,68.86 260.12,68.2 260.88,67.44 261.31,67.44 262.43,66.32 262.96,66.32 264.74,64.54 264.74,63.86 266.83,61.76 266.83,60.95 269.27,58.51 271.13,58.51 274.87,54.76 276.99,54.76 279.8,51.96 280.79,51.96 281.64,51.11 282.95,51.11 284.14,49.91 287.6,49.91 289.81,47.7 294.08,47.7 295.42,49.05 300.88,49.05 301.58,48.35 305.73,48.35 306.21,47.88 306.42,47.67 306.42,46.74 308.13,45.02 308.54,45.02 312.59,40.97 322.5,40.97 324.72,38.75 327.63,38.75 327.92,39.04 327.92,39.38 v1(328.05,39.51)
  BOTTOM w0.102: U2000.AE4 v1(208.34,100.49)
  BOTTOM w0.114: C557.1 332.81,34.99 331.05,34.99 329.3,36.73 329.3,37.7 328.05,38.95 v1(328.05,39.51)
EXT_DPF_TXN0_C: length 6.4
  BOTTOM w0.114: U501.5 337.85,37.04 337.78,36.97 337.25,36.97 335.77,35.5 335.77,34.97 335.6,34.8 335.22,34.8 v1(334.75,35.27) 334.25,34.76 334.02,34.76 333.75,35.03 C557.2
EXT_DPF_TXN1: length 174.3
  IN3 w0.089: v1(333.61,38.01) 333.81,37.81 334.14,37.81 334.35,38.01 334.35,38.24 334.12,38.47 330.56,38.47 329.37,37.28 329.37,36.73 328.58,35.94 324.55,35.94 321.94,38.55 311.66,38.55 308.88,41.33 307.52,41.33 305.52,43.33 303.19,43.33 301.94,44.59 298.89,44.59 298.52,44.96 286.61,44.96 286.1,45.47 285.64,45.47 282.4,48.71 280.94,48.71 279.94,49.71 279,49.71 276.41,52.3 271.46,52.3 270.57,53.19 268.34,53.19 267.07,54.46 265.63,54.46 264.83,55.26 264.83,55.46 263.3,56.99 263.3,57.34 261.82,58.83 261.82,60.16 261.66,60.32 261.66,61.16 258.41,64.42 257.69,64.42 252.99,69.12 252.99,70.78 252.58,71.19 251.43,71.19 249.37,73.24 249.37,74.41 248.05,75.73 248.05,76.43 247.67,76.81 247.67,77.17 246.79,78.04 244.15,78.04 243.81,78.39 243.26,78.39 241.5,80.15 241.5,80.31 239.35,82.45 234.18,82.45 231.93,80.2 230.38,80.2 229.45,81.14 225.04,81.14 224.9,80.99 223.26,80.99 222.73,81.52 212.73,81.52 207.71,86.53 207.44,86.53 206.01,87.96 206.01,90.81 206.92,91.71 206.92,96.05 206.45,96.52 206.45,99.75 206.63,99.94 206.7,100.01 206.79,100.1 206.79,100.59 v1(207.49,101.29)
  BOTTOM w0.102: U2000.AF5 v1(207.49,101.29)
  BOTTOM w0.114: C559.1 334.08,37.86 333.76,37.86 v1(333.61,38.01)
EXT_DPF_TXN1_C: length 3.5
  BOTTOM w0.114: U501.8 337.67,38.24 337.62,38.19 336.63,38.19 336.22,37.78 335.6,37.78 C559.2
EXT_DPF_TXN2: length 177.2
  IN3 w0.089: v1(330.33,37.3) 330.55,37.09 330.79,37.09 331.1,36.78 331.1,35.94 330.33,35.17 324.34,35.17 321.64,37.87 311.35,37.87 308.83,40.39 307.38,40.39 305.22,42.55 302.71,42.55 301.36,43.89 286.71,43.89 286.25,44.35 285.74,44.35 282.14,47.96 280.69,47.96 279.9,48.74 278.86,48.74 278.33,49.28 277.84,49.28 276.23,50.89 274.3,50.89 274.03,51.16 268.57,51.16 266.01,53.72 264.94,53.72 262.19,56.48 262.19,57.38 259.2,60.36 259.2,61.5 256.38,64.31 256.38,64.73 251.44,69.67 251.44,70.17 248.48,73.13 248.48,74.16 246.91,75.73 246.91,76.09 245.73,77.27 243.12,77.27 238.63,81.76 234.46,81.76 232.21,79.52 229.37,79.52 228.78,80.11 227.36,80.11 226.97,79.72 226.35,79.72 225.63,80.44 223.03,80.44 222.88,80.29 220.42,80.29 219.88,80.83 212.44,80.83 209.4,83.87 206.39,83.87 205.45,84.81 205.45,87.35 205.28,87.53 205.28,91.62 206.23,92.58 206.23,94.07 205.94,94.36 205.94,99.88 206.32,100.26 206.32,101.22 206.98,101.88 207.07,101.97 208.26,101.97 v1(208.36,102.07)
  BOTTOM w0.102: v1(208.36,102.07) 208.73,101.7 U2000.AD5
  BOTTOM w0.114: C561.1 331.43,40.21 330.93,40.21 330.68,39.96 330.68,37.64 v1(330.33,37.3)
EXT_DPF_TXN2_C: length 6.4
  BOTTOM w0.114: C561.2 332.65,40.05 334.77,40.05 334.83,39.98 v2(335.34,39.98) 336.16,39.98 336.76,39.38 337.72,39.38 337.78,39.44 U501.11
EXT_DPF_TXN3: length 171.3
  IN3 w0.089: v1(207.49,98.09) 207.93,97.65 207.93,96.74 208.81,95.86 208.81,90.98 208.39,90.56 208.05,90.56 207.6,90.11 207.6,88.67 208.15,88.12 208.37,88.12 213.3,83.19 220.63,83.19 220.94,83.49 222.87,83.49 223,83.62 225.14,83.62 225.63,84.11 229.01,84.11 229.08,84.04 231.68,84.04 232.83,85.19 241.29,85.19 242.65,83.83 243.35,83.83 245.09,82.09 245.51,82.09 247.1,80.51 248.97,80.51 250.28,79.2 250.28,78.52 250.66,78.14 251.07,78.14 252.03,77.18 252.03,76.39 252.59,75.83 252.59,75.14 252.79,74.94 253.63,74.94 254.77,73.8 255.28,73.8 256.01,73.07 256.01,71.13 255.51,70.63 255.51,69.97 256.6,68.87 257.18,68.87 257.26,68.95 257.79,68.95 258.17,68.57 258.91,68.57 261.99,65.48 262.43,65.48 262.64,65.27 263.02,65.27 264.03,64.26 264.03,63.76 265.61,62.17 265.61,60.95 268.54,58.03 269.97,58.03 270.75,57.25 270.75,56.02 272.68,54.09 276.94,54.09 279.56,51.48 280.55,51.48 281.64,50.38 282.99,50.38 284.13,49.24 287,49.24 289.01,47.23 295.33,47.23 296.17,48.07 298.76,48.07 298.93,48.24 301.01,48.24 302.69,46.56 305.1,46.56 305.91,45.75 306.6,45.75 307.57,44.78 307.57,44.32 308.16,43.73 308.79,43.73 312.02,40.5 322.28,40.5 324.54,38.24 328.66,38.24 329.59,39.18 329.59,39.32 329.57,39.35 329.57,39.44 329.5,39.51 v1(329.32,39.51)
  BOTTOM w0.102: U2000.AF1 206.77,98.5 206.66,98.39 206.66,98.19 207.1,97.75 207.25,97.75 207.49,98 v1(207.49,98.09)
  BOTTOM w0.114: v1(329.32,39.51) 329.42,39.51 329.53,39.63 329.53,39.78 329.64,39.88 329.64,40.45 330.42,41.23 332.69,41.23 332.87,41.05 v2(333.34,41.05) 333.72,41.05 334.3,41.62 C563.1
EXT_DPF_TXN3_C: length 3.7
  BOTTOM w0.114: U501.13 337.54,40.24 337.51,40.21 337.03,40.21 v2(336.64,40.6) 335.92,41.32 335.49,41.32 C563.2
EXT_DPF_TXP0: length 172
  IN3 w0.089: v1(208.34,99.69) 208.16,99.69 208.09,99.63 208.09,99.25 208.36,98.97 208.36,96.94 209.55,95.75 209.55,87.93 213.14,84.34 222.19,84.34 222.36,84.51 223.93,84.51 224.21,84.79 229.98,84.79 230.48,85.3 230.87,85.3 231.51,85.94 234.42,85.94 235.45,86.97 241.45,86.97 243.04,85.38 245.35,85.38 247.48,83.25 248.24,83.25 249.03,82.46 249.03,82.09 250.99,80.13 251.92,80.13 252.81,79.24 252.81,77.52 252.65,77.35 252.65,76.88 253.07,76.47 254.16,76.47 254.62,76.93 255.58,76.93 257.5,75 257.5,74.49 256.74,73.72 256.74,71.45 257.89,70.3 257.89,70.09 258.73,69.26 258.96,69.26 259.04,69.33 259.95,69.33 260.33,68.95 260.33,68.29 260.97,67.65 261.4,67.65 262.52,66.54 263.05,66.54 264.95,64.63 264.95,63.95 267.05,61.85 267.05,61.04 269.36,58.73 271.22,58.73 274.96,54.98 277.08,54.98 279.89,52.17 280.88,52.17 281.73,51.32 283.04,51.32 284.23,50.13 287.69,50.13 289.9,47.92 293.99,47.92 295.33,49.27 300.97,49.27 301.67,48.57 305.82,48.57 306.15,48.24 306.36,48.03 306.63,47.76 306.63,46.83 308.22,45.24 308.63,45.24 312.68,41.19 322.59,41.19 324.81,38.97 327.54,38.97 327.7,39.13 327.7,39.22 v1(327.41,39.51)
  BOTTOM w0.102: U2000.AE3 v1(208.34,99.69)
  BOTTOM w0.114: C556.1 333.23,34.39 333.23,34.61 333.14,34.7 v2(331.73,34.7) 330.93,34.7 329.01,36.61 329.01,37.57 327.76,38.83 327.76,39.17 v1(327.41,39.51)
EXT_DPF_TXP0_C: length 6.4
  BOTTOM w0.114: C556.2 333.75,34.24 333.97,34.47 334.28,34.47 v1(334.75,34) 335.26,34.51 335.72,34.51 336.06,34.85 336.06,35.38 337.37,36.68 337.77,36.68 337.81,36.64 U501.4
EXT_DPF_TXP1: length 174.3
  IN3 w0.089: v1(333.61,37.38) 333.83,37.59 334.23,37.59 334.56,37.92 334.56,38.33 334.21,38.69 330.48,38.69 329.15,37.37 329.15,36.82 328.49,36.16 324.64,36.16 322.03,38.77 311.75,38.77 308.97,41.54 307.61,41.54 305.6,43.55 303.28,43.55 302.03,44.81 298.98,44.81 298.61,45.18 286.7,45.18 286.19,45.68 285.73,45.68 282.49,48.92 281.03,48.92 280.03,49.93 279.09,49.93 276.5,52.52 271.55,52.52 270.66,53.41 268.43,53.41 267.16,54.68 265.72,54.68 265.04,55.35 265.04,55.55 263.52,57.08 263.52,57.43 262.03,58.92 262.03,60.25 261.88,60.41 261.88,61.25 258.5,64.63 257.78,64.63 253.21,69.21 253.21,70.87 252.67,71.4 251.52,71.4 249.59,73.33 249.59,74.5 248.27,75.82 248.27,76.52 247.89,76.9 247.89,77.26 246.88,78.26 244.24,78.26 243.9,78.6 243.35,78.6 241.71,80.24 241.71,80.4 239.44,82.67 234.09,82.67 231.84,80.42 230.47,80.42 229.54,81.35 224.95,81.35 224.81,81.21 223.35,81.21 222.82,81.73 212.82,81.73 207.8,86.75 207.53,86.75 206.23,88.05 206.23,90.72 207.13,91.62 207.13,96.14 206.66,96.61 206.66,99.67 206.78,99.79 206.85,99.85 207,100.01 207,100.5 207.15,100.65 207.33,100.65 v1(207.49,100.49)
  BOTTOM w0.102: U2000.AF4 v1(207.49,100.49)
  BOTTOM w0.114: C558.1 334.41,37.29 334.13,37.57 333.8,37.57 v1(333.61,37.38)
EXT_DPF_TXP1_C: length 3.4
  BOTTOM w0.114: U501.7 337.67,37.84 337.62,37.9 336.75,37.9 336.34,37.49 335.51,37.49 C558.2
EXT_DPF_TXP2: length 177.1
  IN3 w0.089: v1(208.36,101.28) 208.36,101.49 208.1,101.75 207.16,101.75 207.13,101.73 206.53,101.13 206.53,100.17 206.15,99.79 206.15,94.45 206.45,94.16 206.45,92.49 205.49,91.53 205.49,87.62 205.67,87.44 205.67,84.9 206.48,84.09 209.49,84.09 212.53,81.05 219.97,81.05 220.51,80.51 222.79,80.51 222.94,80.65 225.72,80.65 226.44,79.94 226.88,79.94 227.27,80.32 228.87,80.32 229.46,79.73 232.12,79.73 234.37,81.98 238.72,81.98 243.21,77.48 245.82,77.48 247.12,76.18 247.12,75.82 248.7,74.25 248.7,73.22 251.66,70.26 251.66,69.76 256.6,64.82 256.6,64.4 259.42,61.59 259.42,60.45 262.4,57.47 262.4,56.57 265.03,53.94 266.1,53.94 268.66,51.37 274.12,51.37 274.39,51.11 276.32,51.11 277.93,49.49 278.42,49.49 278.95,48.96 279.99,48.96 280.78,48.17 282.23,48.17 285.83,44.57 286.34,44.57 286.8,44.11 301.45,44.11 302.8,42.76 305.31,42.76 307.47,40.6 308.92,40.6 311.44,38.08 321.73,38.08 324.43,35.38 330.24,35.38 330.88,36.03 330.88,36.69 330.7,36.87 330.54,36.87 v1(330.33,36.67)
  BOTTOM w0.102: v1(208.36,101.28) 208.75,100.9 U2000.AD4
  BOTTOM w0.114: v1(330.33,36.67) 330.76,37.09 330.76,37.31 330.97,37.52 330.97,39.84 331.05,39.92 331.76,39.92 331.83,39.84 331.83,39.6 C560.1
EXT_DPF_TXP2_C: length 6.4
  BOTTOM w0.114: U501.10 337.83,39.04 337.78,39.09 336.64,39.09 336.04,39.69 334.71,39.69 334.64,39.75 v2(333.37,39.75) 332.77,39.75 C560.2
EXT_DPF_TXP3: length 171.3
  IN3 w0.089: v1(329.95,39.51) 329.81,39.37 329.81,39.09 328.75,38.03 324.45,38.03 322.19,40.29 311.93,40.29 308.7,43.51 308.07,43.51 307.35,44.23 307.35,44.69 306.51,45.53 305.82,45.53 305.01,46.34 302.6,46.34 300.92,48.02 299.02,48.02 298.85,47.86 296.26,47.86 295.42,47.02 288.92,47.02 286.91,49.02 284.04,49.02 282.9,50.17 281.55,50.17 280.46,51.26 279.47,51.26 276.85,53.88 272.59,53.88 270.53,55.93 270.53,57.16 269.88,57.81 268.45,57.81 265.4,60.86 265.4,62.08 263.81,63.67 263.81,64.17 262.93,65.05 262.55,65.05 262.34,65.27 261.91,65.27 258.82,68.35 258.08,68.35 257.7,68.73 257.35,68.73 257.26,68.65 256.51,68.65 255.29,69.88 255.29,70.72 255.8,71.22 255.8,72.98 255.19,73.59 254.68,73.59 253.54,74.73 252.7,74.73 252.38,75.05 252.38,75.74 251.81,76.3 251.81,77.09 250.98,77.92 250.57,77.92 250.07,78.43 250.07,79.11 248.88,80.29 247.01,80.29 245.42,81.88 245,81.88 243.26,83.62 242.56,83.62 241.2,84.98 232.92,84.98 231.77,83.82 228.99,83.82 228.92,83.89 225.72,83.89 225.23,83.4 223.09,83.4 222.96,83.28 221.03,83.28 220.72,82.97 213.21,82.97 208.28,87.91 208.06,87.91 207.38,88.58 207.38,90.2 207.96,90.78 208.3,90.78 208.59,91.07 208.59,95.77 207.72,96.65 207.72,97.15 v1(207.51,97.35)
  BOTTOM w0.102: v1(207.51,97.35) 207.31,97.55 207.02,97.55 206.46,98.11 206.46,98.32 U2000.AG1
  BOTTOM w0.114: C562.1 334.55,40.6 334.73,40.78 334.73,41.06 334.59,41.2 334.29,41.2 333.85,40.76 332.75,40.76 332.57,40.93 330.54,40.93 329.93,40.32 329.93,39.54 v1(329.95,39.51)
EXT_DPF_TXP3_C: length 3.8
  BOTTOM w0.114: C562.2 335.62,41.03 335.8,41.03 336.91,39.92 337.52,39.92 337.6,39.84 U501.12
EXT_EDP_AUXN: length 166.1
  IN3 w0.089: v1(187.78,82.45) 187.85,82.53 187.93,82.53 188.54,83.14 188.54,87.48 187.95,88.06 177.41,88.06 164.94,75.59 104.17,75.59 102.24,73.66 94.71,73.66 93.96,72.91 92.24,72.91 90.33,71 90.33,70.47 88.91,69.05 88.04,69.05 86.9,67.91 78.37,67.91 77.35,66.89 71.3,66.89 68.56,69.64 68.56,69.76 v1(68.14,70.19)
  BOTTOM w0.114: U2000.AK2 203.58,99.3 203.5,99.21 203.5,99.07 203.32,98.89 203.32,97.25 203.36,97.21 203.36,95.98 202.95,95.57 202.95,95.33 203.23,95.05 R2103.1 202.77,94.35 202.77,94.21 201.61,93.05 198.1,93.05 196.51,91.46 195.03,91.46 188.83,85.26 188.83,83.32 188.4,82.89 187.96,82.45 v1(187.78,82.45) ; C3057.2 67.91,68.75 68.02,68.85 68.02,69.01 67.65,69.38 67.65,69.69 v1(68.14,70.19)
EXT_EDP_AUXN_C: length 6.8
  TOP w0.114: U3007.27 64.33,69.72 64.62,70.02 64.62,70.27 v1(64.8,70.45)
  BOTTOM w0.114: v1(64.8,70.45) 64.73,70.38 64.73,69.24 64.95,69.02 65.05,69.02 R2102.1 64.79,68.87 64.6,68.67 64.6,68.37 64.89,68.07 65.5,68.07 65.7,68.28 66.2,68.28 C3057.1
EXT_EDP_AUXP: length 166.1
  IN3 w0.089: v1(187.75,83.29) 187.64,83.29 187.56,83.21 187.56,82.91 187.64,82.84 187.93,82.84 188.32,83.23 188.32,87.39 187.87,87.85 177.5,87.85 165.03,75.38 104.26,75.38 102.33,73.45 94.8,73.45 94.05,72.69 92.33,72.69 90.54,70.91 90.54,70.38 89,68.84 88.13,68.84 86.99,67.69 78.46,67.69 77.44,66.68 71.21,66.68 68.34,69.55 v1(68.13,69.55)
  BOTTOM w0.114: v1(187.75,83.29) 187.75,83.11 187.87,83 188.09,83 188.28,83.18 188.37,83.27 188.54,83.44 188.54,85.38 194.91,91.75 196.39,91.75 197.98,93.35 201.49,93.35 202.48,94.33 R2105.1 202.66,95.24 202.66,95.69 203.07,96.1 203.07,97.21 203.11,97.25 203.11,98.98 203.28,99.16 203.28,99.6 U2000.AK3 ; v1(68.13,69.55) 68.13,69.32 68.31,69.13 68.31,68.73 68.03,68.46 67.86,68.46 67.73,68.33 67.35,68.33 67.27,68.24 67.27,67.97 C3056.2
EXT_EDP_AUXP_C: length 6.8
  TOP w0.114: v1(64.17,70.45) 64.32,70.3 64.32,70.12 63.93,69.74 U3007.28
  BOTTOM w0.114: v1(64.17,70.45) 64.42,70.19 64.42,69.3 R2104.1 64.31,68.55 64.31,68.24 64.77,67.78 65.62,67.78 65.82,67.99 66.47,67.99 C3056.1
EXT_EDP_HPD: length 222.2
  TOP w0.114: R2111.2 C2216.2 235.17,61.57 233.59,59.98 v1(233.59,59.83)
  IN2 w0.089: v1(233.59,59.83) 234.04,59.37 234.04,37.62 232.09,35.67 232.09,33.94 230.69,32.55 229.48,32.55 228.97,32.05 222.92,32.05 222.22,31.36 220.9,31.36 217.85,28.31 206.28,28.31 204.96,27 181.98,27 181.61,26.63 179.86,26.63 179.25,27.24 169.56,27.24 168.82,26.5 108.24,26.5 106.79,27.95 106.12,27.95 105.3,28.77 105.3,29.43 103.37,31.36 103.37,42.25 96.95,48.67 96.95,49.96 94.45,52.47 91.16,52.47 88.88,54.75 87.44,54.75 86.64,55.54 84.92,55.54 83.85,56.61 80.86,56.61 78.49,58.99 73.9,58.99 72.82,60.06 v1(71.15,60.06)
  BOTTOM w0.114: R3054.2 68.88,62.84 71.15,60.57 v1(71.15,60.06)
EXT_EDP_TXN0: length 147.8
  TOP w0.114: v1(187.75,85.19) 188.03,85.19 189.02,86.18 189.02,86.6 189.78,87.36 189.78,88.48 191.05,89.74 194.78,89.74 200.65,95.61 200.65,96.3 201.25,96.9 v1(201.25,96.99) ; v1(75.6,61.56) 75.25,61.22 75.07,61.22 74.84,60.99 74.37,60.99 C3069.2
  IN3 w0.089: v1(75.6,61.56) 75.8,61.36 75.98,61.36 77.54,62.92 82.24,62.92 83.41,64.09 90.39,64.09 91.73,65.42 91.73,67.73 93.57,69.57 98.34,69.57 99.05,70.28 104.34,70.28 106.85,72.8 166.36,72.8 177.12,83.56 177.49,83.94 185.58,83.94 186.42,84.77 187.42,84.77 187.75,85.11 v1(187.75,85.19)
  BOTTOM w0.114: v1(201.25,96.99) 201.3,96.94 201.45,96.94 201.59,97.08 201.59,97.19 201.67,97.27 201.67,98.89 U2000.AM2
EXT_EDP_TXN0_C: length 7
  TOP w0.114: C3069.1 73.01,60.78 72.65,60.78 72.52,60.91 v1(72.52,61.28) 72.04,60.8 69.25,60.8 68.79,61.25 68.08,61.25 68,61.33 U3007.2
EXT_EDP_TXN1: length 150.9
  TOP w0.114: v1(201.65,100.55) 201.46,100.55 201.03,100.12 200.36,100.12 197.91,97.67 197.91,96.33 197.27,95.7 196.22,95.7 195.14,94.62 195.14,93.52 194.13,92.51 193.38,92.51 193.15,92.28 189.98,92.28 185.33,87.63 184.86,87.63 184.33,87.11 184.33,86.77 v1(184.09,86.53) ; v1(74.91,63.97) 75.1,63.79 75.1,62.41 74.71,62.03 71.69,62.03 71.54,61.88 71.34,61.88 71.03,62.19 C3071.2
  IN3 w0.089: v1(74.91,63.97) 75.46,64.52 81.27,64.52 83.29,66.54 87.51,66.54 88.65,67.68 89.52,67.68 92.78,70.94 97.25,70.94 97.96,71.66 102.95,71.66 105.48,74.18 165.67,74.18 177.3,85.82 184.06,85.82 184.32,86.08 184.32,86.3 v1(184.09,86.53)
  BOTTOM w0.114: v1(201.65,100.55) 202.05,100.95 U2000.AM4
EXT_EDP_TXN1_C: length 3.2
  TOP w0.114: C3071.1 69.94,62 69.83,62 69.34,62.49 67.96,62.49 67.92,62.53 U3007.5
EXT_EDP_TXN2: length 149
  TOP w0.114: v1(73.87,63.31) 73.87,63.17 73.79,63.1 73.3,63.1 73.3,63.09 73.19,63.2 C3073.2 ; v1(202.51,100.44) 202.08,100.02 202.08,99.5 201.78,99.2 201.3,99.2 200.46,98.36 200.34,98.36 198.89,96.92 198.89,96.14 197.46,94.71 196.76,94.71 196.07,94.02 196.07,93.29 194.12,91.34 190.29,91.34 188.12,89.17 188.12,88.27 187.87,88.02 186.89,88.02 185.85,86.99 185.81,86.95 185.68,86.82 v1(185.68,86.53)
  IN3 w0.089: v1(185.68,86.53) 185.73,86.53 186,86.26 186,85.52 185.24,84.76 177.29,84.76 166.01,73.48 106.27,73.48 103.75,70.97 98.72,70.97 98.01,70.26 93.08,70.26 88.35,65.53 83.38,65.53 81.57,63.72 76,63.72 75.48,63.2 73.98,63.2 v1(73.87,63.31)
  BOTTOM w0.114: v1(202.51,100.44) 202.51,100.53 U2000.AL4
EXT_EDP_TXN2_C: length 5.3
  TOP w0.114: U3007.7 67.95,63.33 67.99,63.3 69.67,63.3 69.88,63.09 v2(70.81,63.09) 71.5,63.09 71.67,63.26 72.08,63.26 C3073.1
EXT_EDP_TXN3: length 154.4
  TOP w0.114: v1(74.2,65.11) 74.29,65.03 74.29,64.85 74.15,64.72 73.98,64.72 73.63,64.37 71.49,64.37 71.39,64.27 71.03,64.27 70.97,64.33 70.97,64.67 C3075.2 ; v1(203.26,102.2) 203.56,102.2 203.66,102.1 203.66,102 203.68,101.98 203.68,101.66 203.19,101.18 203.19,98.86 202.7,98.36 201.58,98.36 200.79,97.58 200.66,97.58 199.8,96.72 199.8,95.9 194.46,90.55 190.63,90.55 188.98,88.9 188.98,87.7 188.16,86.87 187.87,86.87 187.74,87 v1(187.74,87.09)
  IN3 w0.089: v1(74.2,65.11) 74.52,65.44 74.52,65.62 74.85,65.94 81.7,65.94 82.99,67.22 87.2,67.22 88.35,68.37 89.21,68.37 92.47,71.63 94.08,71.63 94.8,72.34 101.9,72.34 102.25,72.69 102.73,72.69 104.93,74.89 165.32,74.89 177.78,87.35 186.94,87.35 187.31,86.98 187.64,86.98 v1(187.74,87.09)
  BOTTOM w0.114: U2000.AK5 203.68,101.5 203.6,101.42 203.33,101.42 203.26,101.5 v1(203.26,102.2)
EXT_EDP_TXN3_C: length 3.3
  TOP w0.114: U3007.10 68.05,64.53 68.49,64.1 68.87,64.1 69.16,64.39 69.91,64.39 C3075.1
EXT_EDP_TXP0: length 147.8
  TOP w0.114: v1(75.6,60.92) 75.19,60.92 74.97,60.7 74.15,60.7 74.02,60.57 74.02,60.32 C3068.2 ; v1(187.75,84.56) 187.81,84.56 189.31,86.06 189.31,86.48 190.07,87.24 190.07,88.36 191.17,89.45 194.9,89.45 200.95,95.49 200.95,96.18 201.28,96.51 v1(201.68,96.51)
  IN3 w0.089: v1(75.6,60.92) 75.81,61.14 76.07,61.14 77.63,62.7 82.33,62.7 83.5,63.87 90.48,63.87 91.94,65.33 91.94,67.64 93.66,69.36 98.43,69.36 99.14,70.07 104.43,70.07 106.94,72.58 166.44,72.58 177.58,83.72 185.67,83.72 186.51,84.56 v1(187.75,84.56)
  BOTTOM w0.102: U2000.AM1 201.89,98.31
  BOTTOM w0.114: 201.89,98.31 201.89,96.83 201.68,96.63 v1(201.68,96.51)
EXT_EDP_TXP0_C: length 7.1
  TOP w0.114: U3007.1 67.93,60.93 67.95,60.96 68.67,60.96 69.13,60.5 72.03,60.5 v1(72.52,60.01) 72.52,60.4 72.61,60.49 73.21,60.49 73.4,60.3 C3068.1
EXT_EDP_TXP1: length 150.9
  TOP w0.114: C3070.2 71.31,61.58 71.66,61.58 71.81,61.74 74.84,61.74 75.39,62.29 75.39,63.81 v1(75.55,63.97) ; v1(201.65,99.7) 201.76,99.8 201.76,100.09 201.71,100.14 201.46,100.14 201.15,99.83 200.48,99.83 198.2,97.55 198.2,96.21 197.39,95.4 196.34,95.4 195.43,94.5 195.43,93.4 194.25,92.22 193.5,92.22 193.28,91.99 190.1,91.99 185.45,87.34 184.98,87.34 184.63,86.99 184.63,86.76 v1(184.86,86.53)
  IN3 w0.089: v1(184.86,86.53) 184.54,86.21 184.54,85.99 184.14,85.6 177.39,85.6 165.76,73.97 105.57,73.97 103.04,71.44 98.05,71.44 97.34,70.73 92.87,70.73 89.61,67.46 88.74,67.46 87.6,66.32 83.38,66.32 81.36,64.3 75.88,64.3 v1(75.55,63.97)
  BOTTOM w0.114: U2000.AM3 202.05,100.1 v1(201.65,99.7)
EXT_EDP_TXP1_C: length 3.2
  TOP w0.114: C3070.1 69.85,61.71 69.7,61.71 69.21,62.2 v2(68.76,62.2) 67.96,62.2 67.89,62.13 U3007.4
EXT_EDP_TXP2: length 148.9
  TOP w0.114: v1(73.87,62.63) 73.69,62.8 73.42,62.8 C3072.2 ; v1(202.51,99.7) 202.51,99.51 201.99,98.99 201.91,98.91 201.42,98.91 200.58,98.07 200.46,98.07 199.18,96.79 199.18,96.01 197.58,94.41 196.88,94.41 196.36,93.9 196.36,93.17 194.24,91.05 190.41,91.05 188.41,89.05 188.41,88.15 187.99,87.73 187.01,87.73 186.07,86.79 186.07,86.32 186.16,86.22 186.34,86.22 186.49,86.37 v1(186.49,86.53)
  IN3 w0.089: v1(73.87,62.63) 74.23,62.98 75.57,62.98 76.09,63.5 81.66,63.5 83.47,65.31 88.44,65.31 93.17,70.04 98.1,70.04 98.81,70.75 103.84,70.75 106.36,73.27 166.1,73.27 177.38,84.55 185.33,84.55 186.21,85.43 186.21,86.25 v1(186.49,86.53)
  BOTTOM w0.114: U2000.AL3 202.53,99.7 v1(202.51,99.7)
EXT_EDP_TXP2_C: length 5.4
  TOP w0.114: C3072.1 72.02,62.97 71.79,62.97 71.62,62.8 69.76,62.8 69.55,63.01 68.03,63.01 67.95,62.93 U3007.6
EXT_EDP_TXP3: length 154.4
  TOP w0.114: v1(74.96,65.11) 74.28,64.43 74.11,64.43 73.75,64.07 71.61,64.07 71.51,63.98 71.29,63.98 C3074.2 ; v1(204.07,102.17) 203.97,102.07 203.97,101.54 203.49,101.06 203.49,98.74 202.82,98.07 201.7,98.07 200.91,97.28 200.78,97.28 200.1,96.6 200.1,95.78 194.58,90.26 190.75,90.26 189.27,88.78 189.27,87.57 188.28,86.58 187.87,86.58 v1(187.74,86.45)
  IN3 w0.089: v1(74.96,65.11) 74.74,65.34 74.74,65.53 74.94,65.72 81.79,65.72 83.08,67.01 87.29,67.01 88.44,68.15 89.3,68.15 92.56,71.41 94.17,71.41 94.89,72.13 101.99,72.13 102.34,72.47 102.82,72.47 105.02,74.67 165.41,74.67 177.87,87.13 186.85,87.13 187.22,86.77 187.48,86.77 187.74,86.51 v1(187.74,86.45)
  BOTTOM w0.114: U2000.AK4 204.07,101.19 v1(204.07,102.17)
EXT_EDP_TXP3_C: length 3.3
  TOP w0.114: C3074.1 69.87,64.1 69.28,64.1 68.99,63.81 68.36,63.81 68.04,64.13 U3007.9
EXT_HPD_PIN3: length 1.8
  TOP w0.114: U3007.3 v1(68.26,61.73)
  BOTTOM w0.114: v1(68.26,61.73) 67.93,62.06 R3054.1
EXT_MIC_L: length 41.8
  TOP w0.203: U3600.37 339.23,5.68 339.33,5.58 339.63,5.89 U3600.38
  TOP w0.254: 339.33,5.58 339.33,2.43 v1(339.38,2.38) 339.58,2.17 340.54,2.17 C3611.1 341.15,2.49 341.46,2.17 342.32,2.17 v1(342.47,2.33) ; v1(357.13,6.54) 356.78,6.89 C3641.1 VC3602.1 358.93,8.22 360.59,6.57 364.14,6.57 366.55,4.16 CON3601.4
  IN1 w0.254: v1(357.13,6.54) 357.13,4.69 354.6,2.16 344.82,2.16 343.96,3.01 343.16,3.01 v1(342.47,2.33)
EXT_SMI#: length 10
  BOTTOM w0.114: R9067.2 260.19,49.47 v1(259.62,49.47) 259.49,49.6 259.49,50.28 259.29,50.48 258.83,50.48 256.65,52.67 U9002.T48
FAN1_PWM: length 346.7
  IN3 w0.089: v3(270.19,27.92) 269.67,27.4 265.72,27.4 265.34,27.01 264.57,27.01 264.32,27.27 262.8,27.27 261.05,29.02 259.94,29.02 259.56,29.39 257.7,29.39 256.64,30.45 251.9,30.45 250.73,29.28 239.84,29.28 234.16,23.6 222.71,23.6 217.11,18 217.11,17.03 216.41,16.32 213.75,16.32 212.66,15.23 207.59,15.23 203.86,18.96 183.25,18.96 179.71,15.43 143.8,15.43 142.65,16.58 107.23,16.58 104.45,19.36 101.28,19.36 101.02,19.61 101.02,20.61 98.82,22.82 98.82,40.45 94.66,44.61 93.98,44.61 93.64,44.95 93.64,46.23 90.39,49.48 89.36,49.48 89.25,49.6 74.7,49.6 73.2,48.1 68.87,48.1 66.71,45.94 60.58,45.94 59.61,46.91 55.56,46.91 54.77,46.12 34.24,46.12 31.97,48.39 25.98,48.39 14.89,59.48 14.89,68.14 24.54,77.79 24.54,81.97 21.55,84.97 21.55,89.76 20.06,91.24 20.06,94.62 v1(19.59,95.09)
  BOTTOM w0.114: U6301.1 21.23,97.74 20.99,97.5 20.99,95.98 20.1,95.09 v1(19.59,95.09) ; U6001.G8 v3(270.19,27.92)
FAN1_PWM_Y: length 12.7
  TOP w0.114: v1(30.21,97.5) 30.21,98.13 26.47,101.87 v1(25.18,101.87)
  BOTTOM w0.114: v1(25.18,101.87) 25.57,101.48 C6305.1 25.03,99.5 24.73,99.5 24.26,99.04 U6301.4 ; 29.08,97.06 v1(30.21,97.5)
FAN2_PWM: length 118.8
  TOP w0.114: v1(324.77,25.24) 323.23,26.77 323.23,38.33 322.38,39.18 322.38,47.58 322.19,47.78 322.19,49.22 321.65,49.75 321.65,51.9 322.5,52.74 322.5,53.7 322.68,53.88 322.68,58.98 323.93,60.23 323.93,63.42 322.03,65.32 322.03,67.45 323.22,68.65 325.51,68.65 326.34,69.48 v1(326.68,69.48)
  IN3 w0.089: v3(270.84,27.92) 271.48,27.28 274.68,27.28 274.91,27.05 277.29,27.05 277.4,26.93 284.7,26.93 285.42,27.66 288,27.66 288.9,28.56 294.41,28.56 295.11,29.26 303.13,29.26 308.04,24.35 311.48,24.35 314.15,21.67 316.76,21.67 317.15,22.06 318.52,22.06 321.31,24.85 324.38,24.85 v1(324.77,25.24)
  BOTTOM w0.114: v1(326.68,69.48) 326.4,69.76 325.84,69.76 324.86,70.74 324.86,74.68 324.38,75.16 U6300.1 ; U6001.G9 v3(270.84,27.92)
FAN2_PWM_Y: length 33.1
  IN4 w0.076: v1(333.81,95.06) 333.81,94.73 333,93.92 333,93.64 332.37,93 332.37,89.24 331.38,88.25 331.38,81.24 328.45,78.32 327.31,78.32 322.23,73.24 v1(322.23,72.99)
  BOTTOM w0.114: U6300.4 322.37,73.86 322.98,73.25 C6309.1 322.49,72.73 v1(322.23,72.99) ; v1(333.81,95.06) 334.37,95.62 335.18,95.62 CON6301.4
FB_CAL_PD_VDDQ: length 13.8
  TOP w0.114: R2010.2 218.68,130.97 220.66,129 220.66,123.6 220.45,123.4 220.45,122.48 v1(220.71,122.22) 221.42,121.52 221.42,121.05 220.94,120.58 v1(220.88,120.58)
  BOTTOM w0.114: v1(220.88,120.58) 220.9,120.58 U2000.J27
FB_CAL_PU_GND: length 13.3
  TOP w0.114: v1(221.68,120.6) 221.68,121.61 221.15,122.14 221.15,122.61 221.34,122.8 221.34,123.59 221.14,123.79 221.14,129.17 219.79,130.52 R2011.2
  BOTTOM w0.3: v1(221.68,120.6) 221.78,120.6 U2000.H27
FB_CAL_TERM_GND: length 6.9
  TOP w0.114: R2012.2 219.88,121.49 220.45,120.92 220.45,120.28 220.63,120.11 221.27,120.11 221.9,119.47 221.9,118.96 221.5,118.57 221.5,118.18 221.66,118.03 v1(222.58,118.03)
  BOTTOM w0.114: U2000.H25 222.58,118.05 v1(222.58,118.03)
FB_GND_SENSE: length 8.5
  BOTTOM w0.127: TP2005.1 228.28,95.94 227.24,95.94 225.63,97.54 224.91,97.54 224.2,98.26 224.2,98.88 U2000.F2
FBA_CMD0: length 24.5
  IN3 w0.089: v1(215,123.1) 215.43,123.52 215.43,124.34 215.43,124.34 215.43,125.94 216.14,126.65 216.14,127.59 217.26,128.72 217.87,128.72 223.76,134.61 223.76,134.85 224.9,135.99 224.9,141.24 v1(224.39,141.75)
  BOTTOM w0.114: U2000.U30 214.98,123.1 v1(215,123.1)
  BOTTOM w0.14: v1(224.39,141.75) 224.41,141.72 224.41,141.72 VRAM2501.G12
FBA_CMD1: length 22.7
  IN3 w0.089: v1(215,123.9) 215,124.94 215.08,125.01 215.08,127.25 217.2,129.37 217.47,129.37 218.78,130.67 218.78,131.86 223,136.08 223,141.19 v1(223.57,141.76)
  BOTTOM w0.14: v1(215,123.9) 215.03,123.9 U2000.T31 ; VRAM2501.H10 v1(223.57,141.76)
FBA_CMD2: length 25.9
  IN3 w0.089: v1(215,122.27) 215,122.45 214.6,122.86 214.6,125.01 214.78,125.19 214.78,127.45 217.09,129.76 217.09,131.97 217.62,132.5 218.41,132.5 220.19,134.28 220.19,134.29 222.28,136.38 222.28,141.52 223.29,142.53 v1(223.6,142.53)
  BOTTOM w0.14: v1(215,122.27) U2000.U29 ; VRAM2501.H11 v1(223.6,142.53)
FBA_CMD3: length 21.8
  BOTTOM w0.14: U2000.R34 216.62,126.24 216.62,127.12 219.09,129.58 219.09,131.66 v1(219.59,132.17) 222.29,134.87 222.29,142.17 222.15,142.31 222.15,143.07 222.46,143.38 223.61,143.38 VRAM2501.K11
FBA_CMD4: length 22.4
  BOTTOM w0.102: 216.31,126.66 216.31,126.58 215.92,126.19 215.92,125.7 216.28,125.35 U2000.R33
  BOTTOM w0.14: 216.31,126.66 216.31,127.75 218.41,129.86 218.41,131.94 v1(220.41,133.95) 221.57,135.1 221.57,143.22 222.1,143.75 VRAM2501.K10
FBA_CMD5: length 26.3
  BOTTOM w0.102: U2000.U32 215.02,124.74 215.02,125.39 215.19,125.56 215.19,126.18 215.14,126.23 215.14,126.42
  BOTTOM w0.14: VRAM2501.L12 224.37,144.14 222.86,144.14 222.69,144.31 221.75,144.31 220.84,143.41 220.84,135.35 v1(217.67,132.18) 217.1,131.61 217.1,130.37 215.56,128.83 215.56,127.43 215.14,127.01 215.14,126.42
FBA_CMD6: length 22.3
  BOTTOM w0.102: U2000.U33 214.58,125.28 214.95,125.65 214.95,126.08 214.85,126.17 214.85,126.41
  BOTTOM w0.14: 214.85,126.41 214.85,127.21 215.09,127.44 215.09,129.32 216.41,130.65 216.41,131.87 v1(218.5,133.96) 220.12,135.58 220.12,142.89 219.66,143.35 218.78,143.35 VRAM2501.K4
FBA_CMD7: length 29.1
  IN3 w0.089: v1(219.75,143.89) 220.18,143.89 221.56,142.52 221.56,136.68 218.11,133.24 217.32,133.24 216.37,132.29 216.37,129.64 214.43,127.7 214.43,125.45 213.73,124.75 213.73,122.97 214.01,122.69 214.34,122.69 214.58,122.45 214.58,121.83 v1(214.18,121.42)
  BOTTOM w0.14: v1(219.75,143.89) 219.6,143.75 VRAM2501.K5 ; v1(214.18,121.42) 214.58,121.02 U2000.U28
FBA_CMD8: length 28.7
  IN3 w0.089: v1(218.78,142.55) 220.11,141.22 220.11,137.36 219.28,136.53 218.68,136.53 218.2,136.05 218.2,135.34 217.56,134.7 216.11,134.7 214.47,133.06 214.47,128.84 213.73,128.1 213.73,125.45 213.23,124.95 213.23,124.15 212.83,123.75 212.83,122.1 213.11,121.82 213.14,121.82 213.59,121.82 213.75,121.65 213.75,121.2 214.18,120.77 v1(214.18,120.6)
  BOTTOM w0.14: U2000.V28 v1(214.18,120.6) ; VRAM2501.J4 v1(218.78,142.55)
FBA_CMD9: length 26
  IN3 w0.089: v1(219.65,142.65) 220.83,141.47 220.83,136.98 217.82,133.98 216.9,133.98 215.63,132.7 215.63,129.4 214.08,127.85 214.08,125.45 213.48,124.85 213.48,122.81 214.04,122.26 v1(214.16,122.26)
  BOTTOM w0.14: VRAM2501.J5 219.35,142.95 v1(219.65,142.65) ; v1(214.16,122.26) 214.16,122.23 U2000.V29
FBA_CMD10: length 29
  IN3 w0.089: v1(213.32,121.39) 213.27,121.39 213.12,121.39 212.53,121.98 212.53,123.95 212.96,124.38 212.96,125.08 213.43,125.55 213.43,128.58 213.75,128.9 213.75,134.01 216.23,136.49 217.61,136.49 218.38,137.26 218.96,137.26 219.38,137.68 219.38,141.15 v1(218.78,141.75)
  BOTTOM w0.14: U2000.V30 213.63,122.7 213.23,123.1 212.78,123.1 212.48,122.8 212.48,122.23 v1(213.32,121.39) ; VRAM2501.H4 v1(218.78,141.75)
FBA_CMD11: length 18.7
  BOTTOM w0.14: VRAM2501.H5 219.49,142.15 219.61,142.03 219.61,136.04 v1(216.5,132.93) 215.73,132.16 215.73,130.93 214.51,129.71 214.51,125.97 U2000.U34
FBA_CMD12: length 25.1
  IN4 w0.089: v1(214.18,123.9) 214.18,128.92 212.94,130.16 212.94,140.89 214.58,142.54 v1(217.96,142.54)
  BOTTOM w0.14: VRAM2501.G3 217.96,141.73 v1(217.96,142.54) ; v1(214.18,123.9) U2000.U31
FBA_CMD13: length 22.2
  BOTTOM w0.14: VRAM2501.J2 216.4,143.32 215.8,143.32 215.6,143.53 214.67,143.53 214.41,143.26 R2062.1 212.7,142.04 212.79,141.96 v1(212.79,135.17) 212.79,129.89 213.28,129.4 213.28,127.9 213.78,127.4 U2000.V34
FBA_CMD14: length 21.2
  BOTTOM w0.14: U2000.V33 213.78,125.35 214.18,125.75 214.18,127.64 213.85,127.97 213.85,129.73 213.62,129.96 v1(213.62,132.06) R2064.2 213.62,141.16 215,142.54 217.16,142.54 VRAM2501.J3
FBA_CMD15: length 29.1
  IN4 w0.089: v1(214.18,123.1) 213.71,123.57 213.71,127.91 212.34,129.29 212.34,141.26 214.7,143.62 216.64,143.62 217.17,144.15 v1(217.98,144.15)
  BOTTOM w0.114: v1(214.18,123.1) 213.63,123.1 213.46,123.27 213.33,123.4 213.33,123.7 213.27,123.77 213.13,123.9 212.48,123.9 U2000.Y32
  BOTTOM w0.14: VRAM2501.L3 v1(217.98,144.15)
FBA_CMD16: length 27.4
  IN3 w0.089: v1(210.01,123.12) 210.43,123.54 210.43,124.28 210.6,124.45 210.6,127.63 209.05,129.18 209.05,130.14 205.67,133.53 204.22,133.53 201.63,136.12 201.63,138 198.93,140.71 197.46,140.71 v1(197.18,140.98)
  BOTTOM w0.14: v1(197.18,140.98) 197.55,141.35 VRAM2500.L12 ; U2000.AA31 210.9,123.12 v1(210.01,123.12)
FBA_CMD17: length 28.8
  IN3 w0.089: v1(198.79,141.76) 199.93,141.76 203.08,138.6 203.08,136.71 204.21,135.58 205.81,135.58 210.43,130.96 210.43,129.47 211.29,128.61 211.29,124.61 211.56,124.34 211.56,123.62 211.16,123.22 211.16,122.85 211.29,122.73 211.29,121.78 v1(210.92,121.41)
  BOTTOM w0.14: v1(210.92,121.41) 211.28,121.77 U2000.AA29 ; VRAM2500.K10 v1(198.79,141.76)
FBA_CMD18: length 29.8
  IN3 w0.089: v1(197.98,141.76) 198.5,141.24 199.42,141.24 202.36,138.3 202.36,136.41 204.25,134.51 205.76,134.51 209.71,130.57 209.71,129.29 210.96,128.04 210.96,124.48 211.29,124.15 211.29,123.73 210.41,122.85 210.41,121.75 210.46,121.7 210.46,120.99 v1(210.86,120.6)
  BOTTOM w0.14: U2000.AA28 210.88,120.6 v1(210.86,120.6) ; VRAM2500.K11 198.37,142.15 v1(197.98,141.76)
FBA_CMD19: length 25.1
  BOTTOM w0.14: VRAM2500.H11 198.78,143.35 199.34,143.35 199.55,143.13 199.55,134.83 199.88,134.51 199.88,132.83 v1(201.83,130.87) 202.66,130.04 206.57,130.04 206.88,129.73 206.88,129.19 209.27,126.8 209.27,126.21 U2000.AC34
FBA_CMD20: length 25.8
  BOTTOM w0.14: U2000.AC33 209.97,125.49 209.97,126.1 209.66,126.41 209.66,127.17 207.61,129.22 207.61,130.03 206.87,130.77 202.99,130.77 v1(201.34,132.41) 200.57,133.19 200.57,134.81 200.28,135.09 200.28,142.99 199.52,143.75 VRAM2500.H10
FBA_CMD21: length 28.7
  BOTTOM w0.14: U2000.AA32 210.88,124.7 210.88,125.25 210.66,125.47 210.66,126.97 208.33,129.3 208.33,130.33 207.17,131.49 204.57,131.49 v1(202.57,133.49) 201.69,134.36 201.69,135.25 201,135.94 201,143.34 200.18,144.16 197.97,144.16 VRAM2500.G12
FBA_CMD22: length 25.5
  BOTTOM w0.14: U2000.AA33 211.28,125.25 210.92,125.61 210.92,127.56 209.05,129.43 209.05,130.63 207.47,132.22 205.07,132.22 v1(204.3,132.99) 202.46,134.83 202.46,135.63 201.9,136.19 201.9,142.82 202.43,143.35 203.58,143.35 VRAM2500.H4
FBA_CMD23: length 30.4
  IN4 w0.089: v1(212.47,121.39) 212.83,121.75 212.83,124.3 213.29,124.76 213.29,125.88 213.29,125.89 213.29,127.5 211.79,128.99 211.79,139.63 207.44,143.98 203.7,143.98 v1(203.58,144.1)
  BOTTOM w0.136: v1(212.47,121.39) U2000.Y28
  BOTTOM w0.14: VRAM2500.H5 203.53,144.1 v1(203.58,144.1)
FBA_CMD24: length 28
  IN4 w0.089: v1(211.68,121.42) 212.24,121.99 212.24,123.76 212.08,123.92 212.08,127.94 211.25,128.77 211.25,138.8 208.04,142.01 207.58,142.47 207.42,142.64 206.78,142.64 206.43,142.99 204.86,142.99 v1(204.38,142.51)
  BOTTOM w0.14: VRAM2500.J4 203.98,142.91 204.18,142.71 v1(204.38,142.51) ; v1(211.68,121.42) 211.68,121.45 U2000.Y29
FBA_CMD25: length 25.9
  IN3 w0.089: v1(211.68,123.1) 211.83,123.25 211.83,124.47 211.64,124.65 211.64,129.71 211.48,129.88 211.48,131.06 206.52,136.01 206.52,140.44 206.34,140.62 204.63,140.62 203.6,141.66 v1(203.6,142.53)
  BOTTOM w0.14: v1(203.6,142.53) 203.59,142.53 VRAM2500.J5 ; v1(211.68,123.1) 212.25,123.1 212.65,123.5 U2000.W31

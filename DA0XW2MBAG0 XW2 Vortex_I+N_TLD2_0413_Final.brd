# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMB_WCK01#: length 20.8
  IN1 w0.081: v1(240.53,106.54) 240.76,106.54 240.9,106.4 240.9,105.56 240.47,105.13 232.96,105.13 231.44,103.61 225.08,103.61 224.72,103.97 224.72,104.47 224.94,104.7 v1(225.08,104.7)
  BOTTOM w0.114: VRAM2503.D5 240.93,106.42 240.82,106.54 v1(240.53,106.54) ; v1(225.08,104.7) 224.88,104.7 224.68,104.5 U2000.E8
VMB_WCK23: length 25
  IN4 w0.081: v1(248.53,106.54) 248.09,106.1 248.09,105.31 247.44,104.66 231.92,104.66 229.83,102.56 228.83,102.56 228.74,102.65 228.74,102.92 228.85,103.02 v1(229.01,103.02)
  BOTTOM w0.114: U2000.A5 228.03,101.95 228.03,101.95 228.05,101.96 228.39,101.96 228.82,102.39 228.82,102.83 v1(229.01,103.02) ; VRAM2503.P4 v1(248.53,106.54)
VMB_WCK23#: length 25.1
  IN4 w0.081: v1(228.28,103.02) 228.48,103.02 228.57,102.94 228.57,102.58 228.76,102.39 229.9,102.39 231.99,104.48 247.51,104.48 248.26,105.24 248.26,105.68 248.32,105.74 v1(248.53,105.74)
  BOTTOM w0.114: v1(248.53,105.74) 248.53,105.97 248.7,106.14 VRAM2503.P5 ; v1(228.28,103.02) 228.51,103.02 228.6,102.93 228.6,102.48 228.3,102.18 228.03,102.18 227.88,102.33 U2000.A6
VMB_WCK45: length 19.5
  IN4 w0.081: v1(225.88,118.03) 225.75,118.03 225.61,118.16 225.61,118.55 225.83,118.78 230.35,118.78 230.76,119.18 232.07,119.18 234.28,121.39 239.76,121.39 240.15,121.01 240.15,119.77 v1(240.5,119.42)
  BOTTOM w0.114: U2000.D24 225.88,118 v1(225.88,118.03) ; VRAM2502.P4 240.54,119.42 v1(240.5,119.42)
VMB_WCK45#: length 19.5
  IN4 w0.081: v1(225.08,118.02) 225.37,118.02 225.44,118.1 225.44,118.62 225.76,118.95 230.28,118.95 230.69,119.36 232,119.36 234.21,121.56 239.83,121.56 240.32,121.08 240.32,120.34 240.42,120.24 v1(240.55,120.24)
  BOTTOM w0.114: VRAM2502.P5 240.62,120.61 240.55,120.55 v1(240.55,120.24) ; U2000.D25 225.08,118.05 v1(225.08,118.02)
VMB_WCK67: length 26.1
  IN4 w0.081: v1(227.49,119.69) 227.72,119.46 229.19,119.46 229.85,120.12 231.69,120.12 234.01,122.44 248.49,122.44 249.03,121.9 249.03,120.88 248.53,120.38 v1(248.53,120.22)
  BOTTOM w0.102: U2000.B27 v1(227.49,119.69)
  BOTTOM w0.114: v1(248.53,120.22) 248.93,119.82 VRAM2502.D4
VMB_WCK67#: length 26.1
  IN4 w0.081: v1(248.53,121.01) 248.58,121.01 248.86,121.29 248.86,121.83 248.42,122.27 234.08,122.27 231.76,119.95 229.92,119.95 229.26,119.29 227.09,119.29 v1(226.67,119.71)
  BOTTOM w0.102: U2000.C27 226.49,120.1 226.67,119.92 v1(226.67,119.71)
  BOTTOM w0.114: v1(248.53,121.01) 248.53,120.79 248.71,120.61 VRAM2502.D5
VOLTAGE_ADC: length 4.4
  BOTTOM w0.114: R6025.2 260.68,24.4 260.95,24.13 PC12002.2 PR12003.1 PR12001.1 260.95,20.98 v1(260.64,20.66)
VOLTAGE_ADC_R: length 7
  BOTTOM w0.114: U6001.C2 265.65,25.31 265,25.31 264.83,25.14 264.09,25.14 263.25,24.3 v1(262.54,24.3) 262.02,24.3 R6025.1 260.45,25.86 C6011.2
VR_SCL_P: length 356.5
  TOP w0.114: PR19006.1 129.19,154.66 v1(129.19,155.03)
  IN3 w0.076: v3(267.59,25.32) 267.26,24.99 267.26,24.46 267.15,24.35
  IN3 w0.089: v1(129.19,155.03) 128.48,154.32 128.48,154.32 128.18,154.02 126.78,154.02 125.49,152.73 125.49,148.33 120.49,143.33 120.49,140.75 121.38,139.86 121.38,133.5 115.95,128.08 115.95,122.61 114.97,121.63 114.97,118.06 113.72,116.8 113.72,111.83 116.36,109.18 116.36,104.11 110.81,98.55 109.37,98.55 108.74,97.92 108.74,97.23 109.09,96.88 109.09,94.73 107.58,93.22 107.58,92.5 105.84,90.76 105.84,90.08 105.05,89.29 105.05,87.42 104.05,86.43 v1(103.41,86.43) ; v1(104.72,17.27) 104.77,17.22 104.77,16.59 105.23,16.13 106,16.13 106.68,15.45 142.18,15.45 143.33,14.3 180.18,14.3 183.72,17.83 203.39,17.83 207.12,14.1 208.16,14.1 208.36,13.9 208.36,12.79 209.72,11.43 232.13,11.43 232.51,11.05 238.34,11.05 239.92,9.46 241.11,9.46 241.12,9.47 243.67,9.47 244.64,8.5 245.58,8.5 245.67,8.41 248.17,8.41 248.26,8.5 248.27,8.5 250.15,10.38 250.15,10.75 250.15,11.04 251.21,12.11 251.88,12.11 252.46,12.68 252.46,13.35 254.02,14.91 254.02,15.93 255.61,17.53 256.21,17.53 257.78,19.1 257.78,22.5 255.9,24.38 253.07,24.38 252.2,25.25 252.2,26.68 254.79,29.28 255.8,29.28 257.32,27.75 258.69,27.75 261.39,25.05 261.39,24.16 261.93,23.61 263.4,23.61 264.07,24.28 267.08,24.28 267.15,24.35
  BOTTOM w0.114: U6001.D5 v3(267.59,25.32) ; v1(104.72,17.27) 104.27,17.72 104.27,18.49 105.04,19.25 105.04,24.17 104.19,25.02 104.19,46.67 104.94,47.42 104.94,85.3 103.82,86.43 v1(103.41,86.43) ; v1(129.19,155.03) 129.91,154.32 PR19014.1
VR_SDA_P: length 355.8
  TOP w0.076: v3(266.94,25.32) 266.86,25.32 266.61,25.06 266.61,24.28 266.55,24.22
  TOP w0.114: v1(128.43,155.03) PR19007.1 ; 266.55,24.22 266.43,24.09 v1(266.33,24.09)
  IN3 w0.076: 265.97,24.99 266.61,24.99 v3(266.94,25.32)
  IN3 w0.089: v1(103.41,87.06) 103.42,87.05 104.05,87.05 104.6,87.6 104.6,89.47 105.39,90.26 105.39,90.94 107.13,92.69 107.13,93.4 108.65,94.92 108.65,96.61 108.28,96.99 108.28,98.09 109.21,99.03 110.65,99.03 115.92,104.29 115.92,109 113.27,111.65 113.27,116.99 114.53,118.25 114.53,121.81 115.51,122.79 115.51,128.26 120.92,133.67 120.92,139.6 120.04,140.47 120.04,143.56 125.04,148.56 125.04,152.91 126.61,154.48 127.88,154.48 v1(128.43,155.03) ; v1(104.77,17.96) 105.21,17.52 105.21,16.78 105.42,16.58 106.18,16.58 106.87,15.89 142.36,15.89 143.51,14.74 180,14.74 183.53,18.28 203.57,18.28 207.3,14.54 208.36,14.54 208.81,14.1 208.81,13.02 209.95,11.88 232.32,11.88 232.7,11.5 238.52,11.5 240.11,9.91 240.93,9.91 240.94,9.91 243.85,9.91 244.82,8.94 245.76,8.94 245.85,8.85 247.99,8.85 248.08,8.94 248.08,8.94 249.7,10.56 249.7,11.22 251.03,12.55 251.7,12.55 252.01,12.87 252.01,13.53 253.57,15.1 253.57,16.12 255.43,17.97 256.03,17.97 257.33,19.28 257.33,22.32 255.71,23.94 252.88,23.94 251.75,25.07 251.75,26.93 254.41,29.59 256.11,29.59 257.51,28.2 258.87,28.2 261.83,25.24 261.83,24.34 262.12,24.06 263.22,24.06 263.89,24.72 265.53,24.72 265.79,24.99 265.97,24.99
  BOTTOM w0.114: v1(104.77,17.96) 104.77,18.33 105.51,19.06 105.51,24.37 104.66,25.21 104.66,46.46 105.41,47.21 105.41,85.51 103.86,87.06 v1(103.41,87.06) ; PR19016.1 129.22,154.32 128.5,155.03 v1(128.43,155.03) ; U6001.D4 v3(266.94,25.32)
VR_STB: length 114.5
  TOP w0.254: v1(143.8,159.73) PR20007.1 ; v1(167.29,159.73) PR20052.1 ; v1(159.16,159.73) PR20037.1 ; PR20022.1 v1(151.29,159.73)
  IN1 w0.203: v1(167.29,159.73) 167.93,159.09 175,159.09 177.58,156.52 177.58,152.01 179.54,150.05 v1(180.05,150.05)
  IN2 w0.203: v1(121.16,116.47) 121.06,116.58 120.43,116.58 117.89,119.11 117.89,127.15 118.44,127.7 120.91,127.7 v1(121.06,127.85) 121.06,128.23 120.68,128.61 120.68,133.47 129.7,142.48 129.7,143.85 130.72,144.87 130.72,145.89 129.27,147.33 129.27,154.47 v1(129.83,155.03) 130.34,154.52 131.35,154.52 131.83,155 132.18,155 132.85,154.33 138.69,154.33 143.8,159.44 v1(143.8,159.73) 144.24,160.17 150.84,160.17 v1(151.29,159.73) 151.8,160.24 158.66,160.24 v1(159.16,159.73) 159.67,160.24 166.78,160.24 v1(167.29,159.73)
  BOTTOM w0.114: PR19011.2 130.5,154.58 130.28,154.58 v1(129.83,155.03)
  BOTTOM w0.203: v1(121.16,116.47) 121.29,116.6 PR21007.1 ; PR21002.1 v1(121.06,127.85) ; v1(180.05,150.05) PR21012.1
VR_SVID_ALERT#: length 61.8
  TOP w0.114: PR19002.2 127.02,155.03 v1(127.41,155.03) ; v1(121.77,117.92) 121.98,118.12 125.43,118.12 126.47,117.08 128.28,117.08 128.63,117.44 129.7,117.44 130.21,116.93 C9002.1 R9318.1 130.97,117.95 131.1,118.07 v1(131.22,118.07) R9030.2
  IN1 w0.076: v1(121.77,117.92) 121.02,117.92 120.56,118.38 119.23,118.38 117.89,119.72 117.89,132.33 119.02,133.46 119.02,138.92 120.19,140.09 120.19,143.42 121.2,144.44 121.2,152.65 122.84,154.29 122.84,155.13 123.25,155.54 125.51,155.54 125.89,155.16 125.89,154.9 126.27,154.52 126.91,154.52 v1(127.41,155.03)
  BOTTOM w0.114: PR19023.2 v1(127.41,155.03)
VR_SVID_CLK: length 56
  TOP w0.114: v1(121.24,118.45) 121.33,118.54 124.68,118.54 125.74,119.6 v1(128.3,119.6) 129.72,119.6 130.22,119.11 R9311.2 131.6,118.96 131.73,119.09 R9314.2 ; v1(125.38,155.03) 124.99,155.03 PR19003.2
  IN1 w0.076: v1(121.24,118.45) 120.94,118.76 119.39,118.76 118.27,119.88 118.27,132.17 119.4,133.3 119.4,138.76 120.57,139.93 120.57,143.26 121.58,144.28 121.58,152.49 123.61,154.52 124.49,154.52 125,155.03 v1(125.38,155.03)
  BOTTOM w0.114: PR19028.1 v1(125.38,155.03)
VR_SVID_CLK_R: length 15.5
  TOP w0.114: R9314.1 132.88,119.72 132.88,119.73 132.88,120.16 134.26,121.54 134.26,122.38 134.65,122.77 v1(135.16,122.77) 135.45,122.77 135.76,123.09 137.26,123.09 137.95,123.79 138.34,123.79 139.03,123.09 141.11,123.09 141.69,123.67 143.18,123.67 143.42,123.43 v1(144.11,123.43)
  BOTTOM w0.114: v1(144.11,123.43) 143.79,123.11 U9001.BH32
VR_SVID_DATA: length 58.2
  TOP w0.114: v1(126.4,155.03) 126.01,155.03 PR19001.2 ; R9036.2 129.17,115.91 129.01,115.76 128.54,115.76 128.25,116.04 126.89,116.04 v1(126.46,116.47) 125.23,117.71 122.22,117.71 121.95,117.44 v1(121.29,117.44)
  IN1 w0.076: v1(126.4,155.03) 126.4,155.28 125.76,155.92 123.1,155.92 122.46,155.28 122.46,154.45 120.82,152.81 120.82,144.6 119.81,143.58 119.81,140.25 118.64,139.08 118.64,133.62 117.51,132.49 117.51,119.57 119.08,118 120.4,118 120.96,117.44 v1(121.29,117.44)
  BOTTOM w0.114: PR19025.1 v1(126.4,155.03)
VR_TEMP: length 126.1
  TOP w0.254: v1(152.81,159.73) 153.22,159.32 PR20021.1 ; v1(160.69,159.73) 160.69,158.36 161.22,157.82 PR20036.1 ; PR20051.1 169.25,157.29 168.84,157.7 v1(168.84,159.73) ; PR20006.1 v1(145.32,159.73)
  IN1 w0.203: v1(168.84,159.73) 169.09,159.48 175.01,159.48 178.21,156.28 178.21,151.98 179.69,150.51 180.25,150.51 180.5,150.26 180.5,149.73 v1(180.05,149.28)
  IN2 w0.203: v1(133.44,144.74) 133.44,146.08 131.23,148.3 130.59,148.3 129.56,149.32 129.56,152.62 130.39,153.45 135.36,153.45 135.95,154.04 138.84,154.04 144.02,159.22 144.81,159.22 v1(145.32,159.73)
  IN3 w0.203: v1(168.84,159.73) 168.21,160.36 161.32,160.36 v1(160.69,159.73) 160.18,159.22 155.86,159.22 155.35,159.73 v1(152.81,159.73) 152.31,159.22 150.27,159.22 149.13,160.36 145.96,160.36 v1(145.32,159.73) ; v1(133.44,144.74) 133.22,144.74 130.94,142.47 130.94,140.91 125.89,135.85 125.89,134.71 122.08,130.9 v1(122.08,128.87) 121.62,128.41 119.7,128.41 118.29,127.01 118.29,119.45 120.78,116.96 122.51,116.96 122.61,117.06 v1(122.61,117.08)
  BOTTOM w0.203: PR21001.1 121.7,128.49 v1(122.08,128.87) ; v1(133.44,144.74) 133.16,145.03 PR19052.1 ; v1(180.05,149.28) PR21011.1 ; v1(122.61,117.08) 122.61,117.06 122.46,116.91 PR21006.1
VRAVDDQ_FB: length 19.3
  TOP w0.254: PC14019.1 PR14011.1 101.22,64.71 101.22,64.49 100.47,63.74 v1(100.47,63.72) 100.09,63.34 PU14000.13 ; PR14013.2 PR14012.2 93.89,71.99 v1(94.06,72.16)
  BOTTOM w0.254: v1(100.47,63.72) 100.47,69.44 PR14014.2 96.16,70.06 v1(94.06,72.16)
VRAVR_ON: length 73.1
  IN3 w0.127: v1(188.37,157.7) 189.52,157.7 190.02,158.21 190.02,158.97 189.14,159.86 180.5,159.86 180.12,159.48 169.45,159.48 169.07,159.09 164.29,159.09 163.57,159.81 161.41,159.81 160.46,158.85 158.81,158.85 157.96,158 157.58,158 156.73,158.85 155.71,158.85 155.2,159.36 153.46,159.36 152.95,158.85 150.12,158.85 148.99,159.98 146.21,159.98 145.45,159.22 142.78,159.22 141.7,160.3 140.18,160.3 139.63,159.76 139.63,156.96 134.91,152.24 134.91,151.52 v1(134.09,150.71)
  BOTTOM w0.127: v1(188.37,157.7) 188.32,157.65 188.32,155.84 189.02,155.15 R9284.2 ; PR19010.2 133.3,150.71 v1(134.09,150.71)
VREFP: length 2.8
  TOP w0.203: C3607.2 340.01,4.76 v1(340.14,4.89) 340.43,5.18 U3600.40
VRM_LPM#: length 232.1
  TOP w0.114: PQ14000.2 89.06,69.18 88.68,69.56 88.68,70.83 91.47,73.62 95.66,73.62 96.3,72.99 v1(97.44,72.99)
  TOP w0.254: v1(202.33,42.77) 202.13,42.98 PR13005.1
  IN1 w0.076: v1(202.33,42.77) 201.34,42.77 200.72,43.4 200.72,43.91 200.59,44.03 199.68,44.03 198.15,45.56 192.69,45.56 191.93,46.32 190.86,46.32 190.68,46.14 190.68,44.34 191.05,43.97 191.05,42.01 190.33,41.29 190.33,31.26 189.8,30.72 187.13,30.72 186.75,31.1 186.75,33.14 187.03,33.42 v1(187.38,33.42)
  IN2 w0.089: v1(119.56,95.98) 118.78,95.98 115.73,92.93 115.73,92.04 116.11,91.66 116.11,89.24 113.32,86.45 111.53,86.45 104.81,79.73 104.81,76.19 101.22,72.6 97.83,72.6 v1(97.44,72.99) 97.44,71.34 101.12,67.65 101.63,67.65 104.59,64.69 104.61,64.69 107.12,62.18 107.12,62.17 107.47,61.81 107.47,49.47 108.29,48.66 108.29,39.41 109.56,38.14 109.56,35.35 113.75,31.16 143.47,31.16 143.64,30.98 143.64,30.45 143.8,30.3 149.77,30.3 150.81,31.33 182.02,31.33 182.36,31 183.78,31 184.26,30.52 184.89,30.52 186.16,31.79 186.16,33.19 186.39,33.42 v1(187.38,33.42)
  IN3 w0.089: v1(215.68,39.46) 215.17,38.95 214.54,38.95 214.03,39.46 214.03,42.76 213.54,43.25 206.98,43.25 206.68,43.54 203.11,43.54 v1(202.33,42.77)
  BOTTOM w0.114: v1(119.56,95.98) 119.95,95.98 PR26001.2 PR26000.2
  BOTTOM w0.254: PR13013.1 v1(215.68,39.46)
VRM_LPM_GND#: length 369.6
  TOP w0.114: v1(348.39,5.83) 348.48,5.74 Q3606.3 ; v1(109.38,34.63) 109.3,34.56 109.3,13.3 111.54,11.06 v1(111.54,5.81)
  IN2 w0.089: v1(115.63,96.1) 115.63,95.24 113.95,93.56 113.95,91.28 111.92,89.24 108.49,89.24 107.97,88.73 107.97,83.99 103.67,79.69 103.67,77.62 99.6,73.55 97.45,73.55 97.05,73.15 97.05,72.74 97.26,72.53 97.26,71.01 101,67.27 101.76,67.27 104.52,64.51 104.53,64.51 106.94,62.11 106.94,62.09 107.3,61.74 107.3,49.4 108.11,48.59 108.11,39.33 109.38,38.06 109.38,35.03 109.38,35.02 109.38,34.98 v1(109.38,34.63)
  IN4 w0.076: v1(111.54,5.81) 112.68,4.66 180.5,4.66 185.68,9.84 185.68,12.36 187.99,14.67 197.4,14.67 198.22,13.86 198.22,13.22 206.79,4.65 215.89,4.65 216.31,4.23 233.16,4.23 234.3,3.09 296.75,3.09 297.69,2.15 335.9,2.15 336.51,2.76 336.51,7.2 337.27,7.96 341.1,7.96 342.6,9.46 344.99,9.46 346.44,8.02 347.68,8.02 348.06,7.63 348.06,6.16 v1(348.39,5.83)
  BOTTOM w0.114: PQ26002.1 118.49,97.34 117.51,96.36 116.87,96.36 116.49,95.98 115.75,95.98 v1(115.63,96.1)
VRPPM_SLP_S0#: length 456.1
  TOP w0.114: v1(109.38,99.9) 109.88,99.4 PR23021.2
  IN2 w0.089: v1(131.34,155.59) 131.06,155.87 127.59,155.87 126.85,155.13 126.85,154.52 126.14,153.81 122.79,153.81 121.47,152.49 121.47,144.69 120.1,143.32 120.1,140.73 119.21,139.84 119.21,138.32 118.57,137.69 118.57,132.26 116.95,130.63 116.95,104.89 111.96,99.9 v1(109.38,99.9) 109.38,99.53 108.12,98.27 108.12,93.76 105.06,90.71 105.06,84.37 98.5,77.81 v1(98.5,75.28)
  IN2 w0.127: v1(131.34,155.59) 131.64,155.88 133.19,155.88 133.76,155.31 138.23,155.31 141.79,158.87 141.79,160.21 142.65,161.07 174.09,161.07 176.18,158.99 182.4,158.99 183.75,157.64 186.3,157.64 189.16,154.78 189.16,152.69 v1(189.87,151.98)
  IN3 w0.089: v1(252.41,93.56) 252.66,93.31 254.99,93.31 256.6,91.7 259.22,91.7 261.78,89.13 261.78,88.1 263.89,85.99 263.89,85.1 263.74,84.95 263.74,84.37 266.42,81.7 266.42,81.41 267.15,80.68 v3(267.69,80.68) ; v1(98.5,75.28) 103.19,75.28 104.18,76.27 164.95,76.27 177.22,88.53 186.65,88.53 187.15,89.04 188.2,89.04 189.01,88.23 189.01,82.03 188.35,81.37 185.58,81.37 184.19,82.76 182.8,82.76 182.4,82.36 182.4,80.28 182.41,80.28 183.14,79.55 191.66,79.55 192.08,79.97 193.61,79.97 194.29,80.66 195.26,80.66 196.42,81.83 196.42,83.66 197.57,84.81 199.19,84.81 200.46,83.53 200.46,82.23 202.72,79.97 210.36,79.97 211.54,78.79 219.08,78.79 219.8,78.08 223.51,78.08 225.78,75.81 v1(227.87,75.81)
  IN4 w0.076: v1(234.59,60.16) 234.59,59.79 235.24,59.15 235.24,55.34 237.45,53.13 239.74,53.13 242.68,50.19 242.68,50.1 250.58,42.2 v1(250.6,42.2)
  BOTTOM w0.102: 261.31,76.06 260.81,75.55 260.81,75.4 260.24,74.83 260.24,74.58 259.88,74.22 259.88,74.19 259.62,73.93 259.62,73.78 259.27,73.43 259.27,73.36
  BOTTOM w0.114: PR19012.1 131.43,153.49 131.43,155.51 v1(131.34,155.59) ; v1(252.41,93.56) 252.41,93.81 251.84,94.37 250.04,94.37 249.63,93.96 249.63,92.69 248.66,91.71 248.66,90.66 246.26,88.27 244.59,88.27 242.64,86.32 242.34,86.32 241.29,85.26 239.26,85.26 238.82,85.71 238.46,85.71 238.13,85.37 236.65,85.37 235.44,84.17 234.82,84.17 232.51,81.86 230.91,81.86 230.51,81.46 230.51,80.46 228.52,78.47 228.52,76.36 227.97,75.81 v1(227.87,75.81) 227.68,75.61 227.48,75.61 227.21,75.34 227.21,71.06 228.12,70.14 228.12,69.26 229.34,68.04 230.14,68.04 233.53,64.65 234.45,64.65 234.7,64.4 234.7,63.91 234.17,63.39 234.17,60.58 v1(234.59,60.16) ; 261.31,76.06 263.68,78.43 R9338.1 265.26,78.43 267.34,80.5 267.51,80.5 v3(267.69,80.68) ; CON401.15 250.9,41.91 v1(250.6,42.2) ; v1(189.87,151.98) 189.88,151.97 PR24004.1
VRPVDDQ_PG: length 250.5
  TOP w0.127: PR14010.1 102.19,63.72 102.72,63.18 103.13,63.18 v1(103.28,63.03)
  IN3 w0.127: v1(103.79,23.17) 104.21,23.59 104.78,23.59 109.79,18.58 178.54,18.58 181.79,21.83 190.04,21.83 190.68,22.47 194,22.47 194.64,21.83 196.38,21.83 197.02,22.47 205.63,22.47 206.42,23.26 212.68,23.26 215.19,25.76 233.23,25.76 239.03,31.57 243.85,31.57 245.65,33.36 246.79,33.36 247.19,32.97 250.39,32.97 251.63,34.22 254.24,34.22 254.73,33.72 258.09,33.72 258.68,34.31 261.53,34.31 261.85,34.63 263.75,34.63 264.24,34.15 265.5,34.15 265.74,33.91 269.78,33.91 271.11,32.58 275.77,32.58 276.4,31.96 279.39,31.96 280.6,30.75 282.67,30.75 283.08,31.16 286.32,31.16 286.46,31.02 287.39,31.02 289.34,32.97 294.94,32.97 295.4,32.51 296.03,32.51 v1(296.32,32.22)
  BOTTOM w0.127: v1(296.32,32.22) 295.94,32.6 PR25008.2 ; v1(103.28,63.03) 104.15,62.17 104.15,50.88 101.82,48.55 101.82,46.39 103.28,44.92 103.28,37.81 102.85,37.38 102.85,24.4 103.79,23.46 v1(103.79,23.17)
VSEL2_P2_P3.1: length 1.7
  BOTTOM w0.114: TP8519.1 340.27,91.92 U8500.L10
WIFI_3V: length 5.9
  IN3 w0.381: v1(338.11,64.61) 336.63,63.13 v1(334.98,63.13)
  BOTTOM w0.254: U4100.A48 338.39,65.14 338.11,64.86 v1(338.11,64.61) 337.89,64.82 U4100.A49
  vias: v1(333.53,62.7) v1(334.3,63.08) v1(335.21,76.27) v1(335.85,76.27)
WIFI_32KHZ: length 5
  BOTTOM w0.114: U4100.A25 U4100.27 346.39,75.76 346.37,75.78 R4124.2 ; v1(346.23,77.23) 346.37,77.09 R4124.2 ; R4124.2 R4113.2
WIFI_PCEI_WL: length 2.8
  BOTTOM w0.114: R4106.1 349.91,74 v1(349.36,74) 349.28,74 349.03,73.75 348.52,73.75 348.09,74.18 U4100.29
WIFI_PCIE_REST: length 6.8
  IN2 w0.089: v1(348.77,74.26) v1(348.77,72.4)
  BOTTOM w0.114: v1(348.77,74.26) 349.28,74.77 R4122.2 ; U4100.31 348.07,73.18 348.77,72.48 v1(348.77,72.4) 348.85,72.48 349.13,72.48 350.16,71.45 R4117.2
WIRELESS_ON: length 165.1
  TOP w0.114: v1(339.14,63.15) 339.14,59.94 337.68,58.48 337.68,57.92 334.32,54.56 334.32,51.5 333.86,51.04 333.86,50.41 334.4,49.87 335.46,49.87 336.13,49.21 336.13,47.63 336.48,47.28 336.48,35.6 334.65,33.77 333.25,33.77 v1(332.62,33.14) 332.62,33.09 333.15,32.55 334.32,32.55 335.29,31.59 335.29,31.03 335.19,30.93 335.19,29.94 335.48,29.64 335.48,27.12 334.94,26.59 334.94,24.23 334.68,23.97 334.68,23.51 v1(335.21,22.98) ; v1(245.72,45.36) 245.57,45.51 245.57,46.4 243.11,48.86 242.22,48.86 242.09,48.99 242.09,49.99 R6825.1 241.07,51.4 240.97,51.5 Q6804.2
  IN3 w0.089: v1(245.72,45.36) 245.64,45.29 245.64,44.04 249.33,40.35 251.51,40.35 251.86,40 257.56,40 258.34,40.78 261.86,40.78 262.39,40.25 268.51,40.25 270.59,38.17 276.29,38.17 277.48,36.97 283.37,36.97 283.78,36.56 286.52,36.56 286.98,36.11 295.13,36.11 295.46,36.44 296.78,36.44 298.73,34.49 300.63,34.49 302.97,32.15 304.73,32.15 305.54,31.33 307.89,31.33 310.26,28.97 321.41,28.97 322.18,28.21 328.15,28.21 328.68,28.74 329.92,28.74 331.58,30.4 331.58,32.04 332.34,32.8 332.34,32.86 v1(332.62,33.14)
  BOTTOM w0.114: v1(339.14,63.15) 339.39,63.4 U4100.64 ; v1(339.14,63.15) 338.89,63.4 U4100.65 ; v1(339.14,63.15) 339.15,63.13 339.15,62.56 339.38,62.34 339.38,60.8 339.76,60.42 Q4104.3 ; R4215.2 336.71,23.2 Q4201.3 335.44,23.2 v1(335.21,22.98)
WL_HOST_WAKE: length 10.1
  BOTTOM w0.114: Q4101.1 354.5,69.8 354.74,69.56 355.37,69.56 R4125.2 356.39,70.58 356.39,72.23 355.3,73.32 352.25,73.32 v1(351.82,73.75) R4106.2
WL_LED_ALL#_Q: length 3.6
  TOP w0.114: R6814.1 R6807.2 239.07,52.54 239.2,52.67 Q6804.3 239.67,53.67 v1(239.94,53.94)
WLAN_CLK_REQ3#: length 156.4
  TOP w0.102: 262.03,74.82 262.03,75.05 262.49,75.5
  TOP w0.114: v1(350.81,63.97) 350.3,64.48 350.3,65.58 351.44,66.72 351.44,67.58 349.79,69.23 349.79,72.68 v1(349.41,73.07) ; 262.49,75.5 263.96,75.5 265.99,77.54 R9172.1 ; 262.03,74.82 261.81,74.59 261.81,74.22 261.23,73.64 261.19,73.64 259.79,72.23 v1(259.79,71.83)
  IN1 w0.076: v1(259.79,71.83) 259.79,71.3 258.3,69.81 258.3,69.52 259.93,67.88 261.55,67.88 262.07,67.36 262.07,67.09 262.52,66.64 262.8,66.64 263.66,65.78 263.66,63.88 265.44,62.1 265.44,59.63 266.43,58.64 267.88,58.64 268.89,57.63 268.89,55.97 269.54,55.32 270.36,55.32 274.54,51.14 276.06,51.14 277.92,49.29 278.56,49.29 279.65,48.2 282.1,48.2 284.17,46.14 284.17,46.14 284.83,45.48 287.89,45.48 289.21,44.16 295.69,44.16 296.41,43.44 300.45,43.44 300.87,43.02 306.36,43.02 306.92,43.59 307.18,43.59 307.74,44.15 307.74,44.86 308.11,45.23 309.61,45.23 314.12,40.72 322.75,40.72 323.5,39.97 332.54,39.97 333.05,40.48 333.79,40.48 335.57,42.25 335.57,45.39 338.63,48.45 338.63,49.34 339.68,50.4 341.37,50.4 341.64,50.67 341.8,50.67 344.73,53.6 346.51,53.6 348.1,55.19 348.1,56.87 348.47,57.24 348.47,57.87 349,58.4 349,61.8 350.81,63.6 v1(350.81,63.97)
  BOTTOM w0.114: U9002.BB30 259.64,71.98 v1(259.79,71.83) ; Q4101.3 353.2,70.59 352.85,70.95 R4103.2 352.2,71 351.36,71.85 350.11,71.85 349.41,72.54 v1(349.41,73.07)
WLAN_CLK_REQ3#_R: length 3.9
  BOTTOM w0.114: R4116.2 351.21,72.48 351.97,71.73 R4103.1 R4101.1 353.05,72.51 353.2,72.36 Q4101.4
WLAN_DISABLE: length 127.3
  TOP w0.076: v3(266.94,25.97) 266.62,25.64 265.84,25.64
  TOP w0.114: R6234.2 260.06,25.97 260.26,26.17 261.74,26.17 262.13,25.78 263.9,25.78 264.15,26.02 264.54,26.02 264.92,25.64 v1(265.13,25.64) 265.84,25.64 ; v1(327.82,29.3) 326.72,30.4 326.04,30.4 324.57,31.87 324.57,39.11 323.7,39.98 323.7,45.56 324.97,46.83 326.25,46.83 326.85,47.43 326.85,48.4 325.58,49.67 325.58,50.99 324.74,51.82 324.74,59.07 325.25,59.58 325.25,62.74 326.84,64.33 327.58,64.33 328.07,64.82 328.07,67.53 v1(330.36,69.81)
  IN4 w0.076: v3(266.94,25.97) 267.26,26.29 268.47,26.29 269.15,26.96 274.53,26.96 275.24,26.25 279.43,26.25 280.59,27.41 284.46,27.41 285.47,28.42 290.15,28.42 290.45,28.72 294.38,28.72 294.87,29.21 308.64,29.21 309.32,28.54 327.06,28.54 v1(327.82,29.3)
  BOTTOM w0.114: U6001.E4 v3(266.94,25.97) ; R4100.1 330.44,71.85 331.02,71.26 331.02,70.12 330.71,69.81 v1(330.36,69.81) 329.47,68.92 329.22,68.92 328.71,68.42 Q4106.5
WLAN_DISABLE#: length 8.8
  TOP w0.114: v1(330.44,71.08) 330.64,71.29 331.81,71.29 332.01,71.08 U12005.2
  BOTTOM w0.114: R4102.1 329.12,71.36 v1(329.83,71.36) 330.31,71.36 330.44,71.24 v1(330.44,71.08) 330.44,70.6 329.71,69.87 Q4106.3 329.36,69.57 329.09,69.31 328.2,69.31 328.06,69.45 Q4106.1
WLAN_LED_EN: length 118.3
  TOP w0.114: v1(258,61.66) 258,60.9 258.48,60.42 258.48,59.35 R9221.1 ; v1(338.13,45.73) 338.11,45.73 338.08,45.76 338.08,46.17 336.53,47.72 336.53,47.76 336.36,47.93 336.36,49.48 335.71,50.14 334.49,50.14 334.09,50.54 334.09,50.92 334.55,51.37 334.55,54.47 338.11,58.02 v1(338.11,58.31)
  IN4 w0.076: v1(258,61.66) 258,61.36 258.99,60.37 258.99,57.34 258.76,57.11 258.76,55.77 259.44,55.08 261.5,55.08 262.58,54 262.62,54 263.06,53.56 263.6,53.56 263.86,53.3 267.27,53.3 267.52,53.05 271.18,53.05 271.35,52.87 275.65,52.87 276.97,51.55 277.39,51.55 277.58,51.36 278.87,51.36 279.26,50.97 280.4,50.97 280.4,50.97 283.13,50.97 284.11,49.99 288.71,49.99 289.63,49.06 291.56,49.06 291.94,48.68 292.8,48.68 293.17,49.05 294.48,49.05 295.41,49.98 298.71,49.98 299.06,50.33 300.72,50.33 302.11,48.94 306.14,48.94 307.79,47.28 308.9,47.28 309.33,47.72 313.47,47.72 314.65,48.9 316.07,48.9 316.26,48.71 316.26,48.17 316.06,47.97 316.06,45.79 317.13,44.72 318.72,44.72 319.33,44.11 324.64,44.11 325.23,44.69 334.52,44.69 335.26,45.43 337.78,45.43 338.11,45.76 v1(338.13,45.73)
  BOTTOM w0.114: Q4104.2 339.81,58.23 338.18,58.23 v1(338.11,58.31) ; 258.56,61.66 v1(258,61.66)
WLAN_TRANSMIT_OFF#_R: length 3.8
  BOTTOM w0.114: R4114.2 349.15,75.9 v1(348.77,75.53) 348.39,75.91 347.12,75.91 346.89,75.67 U4100.28
WLAN_XMIT_OFF#: length 222.1
  TOP w0.114: v1(252.89,74.33) 255.35,76.8 255.35,79.92 255.22,80.06 255.22,80.77 R9324.2
  IN2 w0.089: v1(350.04,83.12) 350.24,83.12 352.03,81.33 352.03,80.64 350.81,79.42 350.81,66.12 351.19,65.74 351.19,60.39 351.9,59.68 351.9,52.28 352.69,51.49 354.08,51.49 354.98,50.6 354.98,48.75 356.01,47.72 358.27,45.46 358.27,37.28 357.4,36.41 352.71,36.41 350.85,38.27 349.11,38.27 348.9,38.06 346.23,38.06 340.67,32.5 340.67,27.68 340.27,27.27 339.95,27.27 338.42,25.74 335.39,25.74 334.35,26.79 330.59,26.79 329.86,26.06 327.25,26.06 326.07,27.24 326.07,27.59 325.86,27.8 323.75,27.8 321.69,29.87 316.11,29.87 314.79,31.19 314.79,41.51 310.88,45.43 310.88,46.51 308.82,48.56 306.63,48.56 304.55,50.64 299.5,50.64 297.7,52.44 293.47,52.44 293.37,52.54 289.98,52.54 287.03,55.48 284.06,55.48 284.01,55.53 283.74,55.53 283.6,55.67 283.49,55.78 283.17,55.91 283.06,55.96 282.86,56.09 282.85,56.1 282.47,56.35 281.96,56.86 281.57,57.45 281.38,57.73 281.38,57.89 280.6,58.67 280.6,60.73 277.68,63.64 277.68,66.13 276.83,66.99 275.06,66.99 274.81,66.73 274.41,66.73 273.79,67.35 272.83,67.35 271.81,68.37 271.81,68.59 268.43,71.97 268.16,71.97 267.86,71.97 265.91,73.93 265.57,73.93 265.28,74.22 264.92,74.22 262.82,76.32 261.86,76.32 260.38,77.79 260.38,79.25 260.53,79.39 260.53,79.67 260.33,79.87 260.19,79.87 259.48,80.57 259.25,80.57 259,80.83 257.6,80.83 256.91,81.51 256.91,83.17 256.62,83.46 255.92,83.46 255.63,83.18 255.63,82.25 254.5,81.11 254.5,79.26 254.77,78.98 254.77,77.32 253.94,76.48 253.2,76.48 252.41,75.68 252.41,74.82 v1(252.89,74.33)
  BOTTOM w0.114: v1(350.04,83.12) v1(350.04,83.91) 350.04,84.29 349.8,84.54 R4112.1 ; U9002.AR18 252.86,74.31 v1(252.89,74.33)
WW_LED#: length 12.3
  BOTTOM w0.114: Q4201.1 337.73,24.63 337.47,24.37 337.47,22.11 337.14,21.78 337.14,21.28 R4201.2 336.71,20.54 336.58,20.41 335.62,20.41 335.06,19.85 335.06,19.09 335.24,18.91 335.24,17.97 334.5,17.24 v1(334.14,17.24) 333.45,17.24 333,16.78 CON4201.10
WWAN_ASPM_EXIT: length 49.6
  IN2 w0.089: v1(307.35,37.38) 307.35,37.19 311.06,33.47 312.52,33.47 313.11,32.88 313.11,30.26 315.36,28.02 318.43,28.02 322.42,24.03 322.42,19.59 v1(322.82,19.19)
  IN3 w0.089: v1(338.23,21.71) 337.84,21.32 333.12,21.32 332.54,20.74 325.36,20.74 324.9,20.28 323.86,20.28 322.82,19.24 v1(322.82,19.19)
  BOTTOM w0.114: R9622.1 307.72,37.75 v1(307.35,37.38) ; v1(338.23,21.71) 338.17,21.65 R4227.1 338.26,21 338.84,20.42 338.84,20.32 339.2,19.95 339.73,19.95 340,19.69 R4209.2 340.14,19.79 340.14,20.52 340.63,21.01 U4200.6
WWAN_CLK_REQ8#: length 156.8
  TOP w0.114: v1(256.96,62.73) 257.59,62.73 258.42,61.9 258.42,60.81 258.98,60.25 258.98,58.16 259.77,57.37 259.77,56.89 260.87,55.79 R9186.1 ; v1(348.08,28.92) 348.51,29.35 348.51,30.33 348.95,30.76 348.95,34.3 348.5,34.75 348.5,39.1 348.32,39.29 348.32,45.89 v1(347.89,46.32)
  IN4 w0.076: v1(256.96,62.73) 257.83,62.73 258.57,62 258.57,61.29 259.61,60.25 259.61,59.88 261.34,58.16 262.29,58.16 265.67,54.78 266.15,54.78 266.33,54.95 269.17,54.95 269.98,54.14 271.6,54.14 271.73,54.02 276.16,54.02 277.51,52.66 277.86,52.66 278.04,52.48 279.54,52.48 279.93,52.08 284.45,52.08 285.21,51.32 290.46,51.32 291.51,50.28 292.56,50.28 292.77,50.08 293.86,50.08 295.49,51.7 298.74,51.7 299.22,51.22 301.35,51.22 302.04,50.54 303.24,50.54 303.88,50.54 304.1,50.75 305.56,50.75 306.91,49.39 306.91,49.24 307.35,48.81 308.68,48.81 309.48,49.61 309.96,49.61 309.98,49.62 316.95,49.62 317.43,49.14 319.01,49.14 319.31,48.83 319.31,48.43 319.06,48.17 317.1,48.17 316.49,47.56 316.49,45.89 317.25,45.13 318.82,45.13 319.48,44.46 323.91,44.46 324.77,45.33 331.91,45.33 333.11,46.53 333.84,46.53 334.49,45.89 337.46,45.89 337.96,46.38 338.77,46.38 339.42,45.73 347.3,45.73 v1(347.89,46.32)
  BOTTOM w0.114: v1(348.08,28.92) 346.93,27.78 342.68,27.78 342.3,27.4 342.3,24.91 343.01,24.2 343.01,23.46 342.55,23 342.55,21.99 343.57,20.97 343.57,18.03 343.31,17.78 343.31,17.29 343.5,17.11 CON4201.52 ; U9002.AE41 v1(256.96,62.73)
WWAN_CONFIG_0: length 158.5
  TOP w0.114: v1(323.5,63.13) 323.5,60.64 322.28,59.42 322.28,53.97 321.24,52.94 321.24,50.12 319.52,48.4 319.52,47.98 319.81,47.68 320.58,47.68 322.07,46.2 322.07,44.73 v1(321.85,44.52) 321.85,40.68 320.94,39.77 320.41,39.77 320,39.35 320,38.78 322.23,36.54 322.23,26.51 v1(320.45,24.73)
  IN1 w0.076: v1(282.84,70.68) 281.69,70.68 280.85,71.52 279.15,71.52 276.58,74.08 275.62,74.08 273.82,75.88 273.51,75.88 262.18,87.21 v3(261.68,87.21)
  IN4 w0.076: v1(282.84,70.68) 283.42,70.09 283.42,69.53 285.63,67.32 287.28,67.32 291.6,63.01 303.78,63.01 304.34,62.45 304.79,62.45 304.81,62.46 311.86,62.46 312.05,62.27 313.8,62.27 314.61,63.08 314.61,64.35 315.25,64.99 321.65,64.99 v1(323.5,63.13)
  BOTTOM w0.114: R9357.1 259.87,88.74 260.26,88.74 260.99,88 261.43,88 261.68,87.75 v3(261.68,87.21) ; R4207.2 333.43,3.8 332.14,2.5 329.85,2.5 328.26,4.1 328.26,15.78 326.68,17.36 326.3,17.36 325.13,18.53 322.61,18.53 322.43,18.35 322.43,18.15 322.05,17.77 321.7,17.77 320.96,18.51 320.96,22.44 320.45,22.95 v1(320.45,24.73)
WWAN_CONFIG_0_R: length 9.7
  BOTTOM w0.102: 256.46,81.04 256.46,80.78 255.71,80.03 255.71,80.02 255.13,79.44 U9002.BF14
  BOTTOM w0.114: R9357.2 258.71,86.91 257.95,86.15 257.95,85.39 R9237.2 257.18,84.62 v1(257.18,83.66) 257.18,83.63 257.02,83.47 257.02,82.67 256.97,82.63 256.97,82.62 256.46,82.11 256.46,81.04
WWAN_CONFIG_2: length 38.5
  IN4 w0.076: v1(349.25,9.9) 348.46,9.11 346.31,9.11 344.35,11.06 344.35,18.06 343.21,19.2 343.21,19.46 339.72,22.95 338.74,22.95 338.36,23.33 338.36,26 339.38,27.01 339.38,28.21 339.17,28.41 v1(339.17,28.54)
  BOTTOM w0.114: CON4201.75 v1(349.25,9.9) ; v1(339.17,28.54) 338.79,28.16 337.98,28.16 336.93,27.11 331.41,27.11 331.01,27.51 R9106.2 331.01,28.68 R9624.1
WWAN_CONFIG_3: length 115
  IN2 w0.089: v1(330.61,7.44) 331.68,8.5 341.03,8.5 342.26,9.74 344.96,9.74 346.2,8.5 350.16,8.5 350.78,7.89 v1(350.78,6.72)
  IN4 w0.076: v1(287.56,25.11) 287.94,24.73 288.83,24.73 288.96,24.86 289.47,24.86 289.85,25.24 290.99,25.24 291.88,26.13 300.64,26.13 301.28,25.49 301.28,22.7 300.26,21.68 300.26,20.66 300.51,20.41 301.78,20.41 304.45,23.08 312.33,23.08 316.52,18.89 316.52,16.98 319.34,14.16 324.92,14.16 330.61,8.47 v1(330.61,7.44)
  BOTTOM w0.114: v1(330.61,7.44) 330.75,7.58 CON4201.1 ; Q4200.2 353.52,5.98 352.89,6.62 350.88,6.62 v1(350.78,6.72) ; v1(287.56,25.11) 287.56,25.56 287.97,25.97 287.97,26.15 288.28,26.46 288.75,26.46 289,26.71 289,27.07 290.6,28.67 290.6,34.98 290.21,35.37 290.21,37.7 288.07,39.84 288.07,45.56 288.31,45.79 288.31,47.83 R9105.1 287.55,49.52 R9619.1 R9623.1
WWAN_DET#: length 101.1
  IN3 w0.089: v1(333.66,22.06) 334.04,21.68 337.37,21.68 338.44,22.75 339.45,22.75 340.29,21.91 345.52,21.91 349.5,17.93 349.5,16.8 353.02,13.29 353.02,12.16 v1(353.65,11.53)
  IN4 w0.076: v3(268.24,25.97) 268.67,25.97 269.02,25.62 269.02,24.47 269.4,24.09 272.32,24.09 272.83,24.6 274.73,24.6 275.09,24.96 277.93,24.96 278.86,25.88 283.22,25.88 283.98,26.65 284.78,26.65 285.78,27.65 290.46,27.65 290.77,27.95 294.7,27.95 295.19,28.45 303.83,28.45 304.71,27.57 306.32,27.57 307.19,28.45 308.22,28.45 308.9,27.78 318.68,27.78 319.95,26.51 325.32,26.51 326.07,27.26 326.07,27.7 326.27,27.9 326.93,27.9 332.77,22.06 v1(333.66,22.06)
  BOTTOM w0.114: R4222.2 v1(353.65,11.53) ; U6001.E6 v3(268.24,25.97)
WWAN_DET#_R: length 10.9
  BOTTOM w0.114: Q9010.2 352.63,14.49 352.24,14.1 R4203.1 R4200.1 R4222.1 352.24,10.7 v1(352.18,10.64) 351.39,10.64 350.85,11.17 349.16,11.17 348.08,10.09 348.08,9.85 347.75,9.52 CON4201.69
WWAN_FWUPD#: length 137.7
  IN2 w0.089: v1(338.26,27.57) 338.06,27.37 336.2,27.37 334.37,29.2 330.33,29.2 329.65,28.52 327.35,28.52 326.99,28.88 325.57,28.88 322.52,31.92 322.52,48.36 323.86,49.7 323.86,51.36 324.09,51.6 324.09,53.5 323.59,54 322.9,54 322.6,54.3 321.79,54.3 317.84,58.26 315.63,58.26 313.98,59.91 307.42,59.91 306.4,58.89 303.26,58.89 303.11,59.04 297.95,59.04 296.54,60.46 293.77,60.46 293.69,60.54 292.43,61.79 291.01,61.79 286.1,66.7 283.73,66.7 282.73,67.7 282.73,68.44 278.31,72.86 277.81,72.86 276.39,74.28 275.39,74.28 273.66,76.01 273.31,76.01 272.09,77.23 v3(271.56,77.23)
  IN4 w0.076: v1(350.48,5.2) 350.45,5.22 350.45,5.53 350.15,5.83 350.15,6.9 348.32,8.73 346.36,8.73 344.2,10.89 344.2,18 343.06,19.14 343.06,19.4 339.73,22.72 338.46,22.72 337.47,23.71 337.47,26.78 v1(338.26,27.57)
  BOTTOM w0.114: Q4200.1 350.93,5.55 350.69,5.8 R4221.2 350.07,5.6 v1(350.48,5.2) ; R9343.2 271.33,77 v3(271.56,77.23)
WWAN_FWUPD#_R: length 10.1
  BOTTOM w0.102: 266.33,73.01 266.24,73.01 265.98,73.27 265.29,73.27 264.73,72.71 263.95,72.71 263.14,71.91 263.14,71.6 U9002.BF36
  BOTTOM w0.114: R9343.1 270.39,75.46 270.11,75.18 270.1,75.18 269.63,74.71 R9079.1 269.38,74.11 v1(268.89,73.62) 268.66,73.39 268.2,73.39 267.82,73.01 266.33,73.01
WWAN_OFF#: length 89.6
  TOP w0.114: v1(263.87,30.93) 263.22,31.58 262.69,31.58 262.47,31.8 261.72,31.8 261.47,32.05 261.47,32.48 261.82,32.83 261.82,33.41 261.7,33.53 261.7,33.8 R6066.1
  IN4 w0.076: v1(333.92,20.82) 334.04,20.95 334.04,22.32 333.79,22.57 332.95,22.57 330.36,25.16 330.36,27.35 327.87,29.83 323.53,29.83 322.84,29.15 309.59,29.15 307.66,31.08 290.99,31.08 290.6,31.46 283.18,31.46 282.63,30.91 280.31,30.91 279.56,31.66 275.42,31.66 274.78,32.3 268.98,32.3 267.96,33.31 266.08,33.31 263.87,31.1 v1(263.87,30.93)
  BOTTOM w0.114: v1(333.92,20.82) 333.95,20.79 333.95,20.57 333.42,20.04 R4219.2 R4206.1 ; v1(263.87,30.93) 263.93,30.93 264.99,29.86 265.65,29.86 U6001.K2
WWAN_POWER_OFF#: length 3.2
  BOTTOM w0.114: CON4201.6 332,17.45 332.17,17.62 R4210.2 332.78,18.16 332.89,18.27 R4206.2
WWAN_RESET#: length 4.9
  BOTTOM w0.114: Q4200.3 351.26,7.58 350.86,7.18 350.32,7.18 350.07,6.92 R4221.1 349.66,6.58 349.54,6.7 R4211.2 349.01,6.77 v1(348.27,6.77)
WWAN_TRANSMIT_OFF#_R: length 5.1
  BOTTOM w0.114: CON4201.8 332.5,17.5 332.82,17.83 333.52,17.83 333.71,18.02 333.71,18.48 334.04,18.81 R4223.1 334.23,19.11 334.46,19.34 D4200.2
WWAN_WAKE#: length 118.9
  TOP w0.114: R18022.1 262.2,55.84 262.92,55.84 263.15,55.61 R18023.2 263.15,53.99 263.9,53.24 264.87,53.24 v1(265.61,52.49)
  IN2 w0.089: v1(340.27,28.67) 339.63,28.03 339.63,27.78 338.74,26.89 336.15,26.89 334.2,28.84 330.48,28.84 329.8,28.16 327.2,28.16 326.84,28.52 324.15,28.52 323.63,29.05 323.63,30.2 322.11,31.71 322.11,35.02 321.91,35.22 319.9,35.22 319.61,35.51 319.61,35.6 318.73,36.49 318.73,37.63 317.95,38.4 317.95,41.96 315.09,44.82 v1(315.09,48.53)
  IN4 w0.076: v1(340.27,28.67) 339.54,27.94 339.54,26.42 339.38,26.25 339.38,23.46 339.63,23.2 339.68,23.2 343.87,19.01 v1(344.13,19.01) ; v1(265.61,52.49) 266.12,53 266.88,53 267.04,52.85 271.05,52.85 271.23,52.67 275.59,52.67 276.86,51.39 277.33,51.39 277.51,51.21 278.8,51.21 279.25,50.76 283.04,50.76 284.02,49.79 288.7,49.79 289.57,48.91 291.45,48.91 291.88,48.48 292.88,48.48 293.25,48.85 294.79,48.85 295.71,49.77 298.72,49.77 299.08,50.13 300.62,50.13 301.96,48.78 306.07,48.78 307.73,47.13 308.96,47.13 309.39,47.56 314.13,47.56 v1(315.09,48.53)
  BOTTOM w0.114: v1(344.13,19.01) 344.13,18.58 344.46,18.24 R4226.2 344.84,18 344,17.17 CON4201.54
WWAN_WAKE#_R: length 10.3
  TOP w0.114: R18022.2 260.95,56.37 260.53,56.79 v1(260.53,57.37) 260.21,57.69 260.12,57.69 259.49,58.32 259.49,60.41 258.89,61.01 258.89,62.1 257.56,63.43 v1(257.56,64.01)
  BOTTOM w0.114: v1(257.56,64.01) 257.77,64.22 U9002.AH40
WWAN_XMIT_OFF#: length 127.7
  IN2 w0.089: v1(255.15,75.64) 254.92,75.87 254.92,76.28 255.6,76.96 255.6,79.42 255.4,79.62 255.4,80.85 255.62,81.07 256.06,81.07 260.33,76.8 260.62,76.8 261.68,75.74 262.65,75.74 264.7,73.69 264.91,73.69 265.2,73.4 265.69,73.4 267.64,71.44 268.21,71.44 271.27,68.37 271.27,68.15 273.46,65.96 274.96,65.96 275.45,66.45 276.61,66.45 277.11,65.96 277.11,63.45 279.89,60.66 279.89,58.62 280.81,57.7 280.81,57.62 281.09,57.2 281.13,57.14 281.55,56.52 282.13,55.94 282.38,55.77 282.81,55.48 283.06,55.38 283.06,55.38 283.19,55.33 283.36,55.16 283.44,55.08 283.51,55 283.79,55 283.84,54.95 286.8,54.95 290.38,51.37 290.89,51.37 292.13,50.13 292.77,50.13 293,49.9 298.46,49.9 299.32,49.04 299.32,48.27 299.45,48.15 303.87,48.15 313.29,38.72 313.29,30.34 315.32,28.31 319.08,28.31 322.84,24.54 v1(322.84,20.11)
  IN3 w0.089: v1(333.53,23.05) 333.1,23.05 331.17,21.12 325.23,21.12 324.75,20.64 323.35,20.64 322.84,20.13 v1(322.84,20.11)
  BOTTOM w0.114: R4202.1 334.17,22.54 334.46,22.25 D4200.1 ; R4202.1 334.63,23.56 334.63,24.78 334.58,24.83 v1(334.58,24.86) 334.96,25.24 Q4201.2 ; R4202.1 333.58,23.1 v1(333.53,23.05) ; U9002.BA20 255.45,75.34 v1(255.15,75.64)
XCLK_RBIAS: length 8.9
  BOTTOM w0.114: v1(234.37,75.12) 234.34,75.12 R9167.2 234.52,74.57 235.6,73.5 236.25,73.5 236.38,73.62 239.64,73.62 240.64,72.62 U9002.T3
XDP_BPM0: length 92.7
  IN1 w0.076: v1(138,118.42) 137.37,117.79 136.97,117.79 136.18,116.99 136.18,116.55 135.42,115.79 134.79,115.79 134.43,116.16 131.09,116.16 128.67,113.73 127.78,113.73 126.35,112.3 126.35,107.8 125.19,106.64 122.99,106.64 112.44,96.09 112.44,95.54 110.56,93.66 110.56,92.38 109.24,91.06 109.24,89.91 107.79,88.46 107.79,85.01 105.06,82.27 105.06,80.51 99.3,74.75 96.74,74.75 96.48,74.49 94.09,74.49 92.61,73.01 91.88,73.01 90.14,71.28 90.14,69.56 88.45,67.87 88.45,63.02 87.2,61.78 87.2,61.08 86.8,60.67 v1(85.76,60.67)
  BOTTOM w0.114: CON400.21 86.23,61.52 86.18,61.47 86.18,61.09 v1(85.76,60.67) ; v1(138,118.42) 138.64,119.06 139.04,119.06 U9001.BR27
XDP_BPM1: length 91.4
  IN1 w0.076: v1(85.73,61.33) 86.14,60.92 86.82,60.92 87.05,61.15 87.05,61.84 88.3,63.08 88.3,67.94 89.99,69.62 89.99,71.34 91.81,73.17 92.55,73.17 94.03,74.65 96.42,74.65 96.68,74.9 99.24,74.9 104.91,80.58 104.91,82.34 107.64,85.07 107.64,88.53 109.09,89.97 109.09,91.12 110.41,92.44 110.41,93.73 112.29,95.6 112.29,96.15 122.93,106.8 125.13,106.8 126.19,107.86 126.19,112.36 127.72,113.88 128.6,113.88 131.03,116.31 134.49,116.31 134.86,115.95 135.36,115.95 136.02,116.61 136.02,117.05 136.91,117.94 137.22,117.94 137.37,118.08 v1(137.37,118.42)
  BOTTOM w0.114: CON400.23 v1(85.73,61.33) ; v1(137.37,118.42) 138.38,119.44 U9001.BT27
XDP_BPM2: length 9.8
  TOP w0.114: TP9034.1 134.53,118.6 135.98,120.06 137.04,120.06 138.29,121.3 138.29,121.65 138.77,122.14 v1(141.75,122.14)
  BOTTOM w0.114: v1(141.75,122.14) 141.37,122.52 U9001.BM31
XDP_BPM3: length 5.5
  TOP w0.114: TP9035.1 134.78,119.55 135.59,120.36 136.94,120.36 137.78,121.2 v1(137.78,121.75)
  BOTTOM w0.114: v1(137.78,121.75) 137.82,121.8 U9001.BT30
XDP_DBRESET#: length 331.2
  TOP w0.114: v1(229.22,33.24) 229.46,33 229.46,32.16 225.78,28.48 220.31,28.48 220.31,28.48 220.12,28.48 211.5,19.86 205.23,19.86 200.76,15.4 v1(200.76,14.9) ; R9101.1 253.56,84.98 250.04,84.98 249.67,85.35 249.05,85.35 248.53,85.87 248.21,85.87 247.1,86.98 246.18,86.98 245.47,86.27 244.46,86.27 243.87,85.69 243.87,84.67 v1(243.72,84.52) 243.28,84.96 242.74,84.96 242.52,84.73 233.23,84.73 230.04,81.54 230.04,78.79 229.5,78.25 229.5,75.07 v1(229.93,74.64)
  IN1 w0.076: v1(102.99,18.03) 103.51,18.55 104.92,18.55 112.6,10.86 177.06,10.86 182.87,16.66 197.57,16.66 198.57,15.66 200.39,15.66 200.76,15.29 v1(200.76,14.9)
  IN2 w0.089: v1(229.22,33.24) 229.51,32.94 230.83,32.94 231.91,34.02 231.91,35.74 233.86,37.7 233.86,58.79 233.18,59.48 233.18,60.01 233.93,60.76 233.93,62.99 233.22,63.71 233.22,67.49 232.15,68.56 232.15,70.35 230.34,72.16 230.34,74.22 v1(229.93,74.64)
  IN4 w0.076: v1(229.22,33.24) 229.83,33.24 232.44,30.62 247.67,30.62 250.65,33.59 v1(252.56,33.59)
  BOTTOM w0.102: 246.69,81.7 246.91,81.47 247.34,81.47 247.58,81.23 247.58,80.84 247.95,80.47 U9002.AU2
  BOTTOM w0.114: v1(102.99,18.03) 101.68,18.03 99.73,19.98 99.73,25.1 98.15,26.67 98.15,37.19 91.71,43.63 91.71,46 88.79,48.92 83.41,48.92 78.45,53.88 78.45,56.98 77.4,58.03 76.04,58.03 71.14,62.93 R401.1 ; CON401.13 251.93,40.71 251.93,36.94 251.32,36.33 251.32,35.39 252.56,34.15 v1(252.56,33.59) ; v1(243.72,84.52) 244.18,84.98 245.47,84.98 245.88,84.56 245.88,84.01 246.16,83.73 246.16,82.22 246.69,81.7
XDP_SPI_IO2: length 331.6
  IN1 w0.076: v1(289.34,25.31) 288.61,24.59 286.54,24.59 284.77,22.82 284.77,21.6 284.23,21.07 283.65,21.07 280.58,18 280.58,16.63 271.91,7.96 265.84,7.96 264.2,6.32 257.98,6.32 257.14,5.49 255.49,5.49 254.41,6.57 249.62,6.57 249.32,6.26 246.91,6.26 246.13,5.49 243.93,5.49 242.24,7.18 239.69,7.18 239.46,6.95 238.28,6.95 238.04,6.71 214.61,6.71 213.1,8.22 209.71,8.22 209.2,8.73 209.2,9.74 208.95,10 207.55,10 v1(206.92,10.63)
  IN3 w0.089: v1(206.92,10.63) 206.2,11.34 206.2,14.13 203.23,17.11 183.99,17.11 180.08,13.2 137.21,13.2 136.43,12.41 105.94,12.41 103.89,14.47 v1(103.89,15.83)
  BOTTOM w0.114: v1(103.89,15.83) 102.58,15.83 100.26,18.15 100.26,19.12 99.47,19.91 99.47,24.94 97.92,26.49 97.92,37.1 91.48,43.53 91.48,45.91 88.7,48.69 83.31,48.69 78.22,53.79 78.22,56.88 77.31,57.8 75.95,57.8 70.39,63.36 70.39,66.26 70.77,66.64 R406.1 ; v1(289.34,25.31) 289.34,25.93 290.12,26.71 290.12,27.03 292.27,29.18 292.27,30.44 291.29,31.42 291.29,35.27 290.91,35.64 290.91,38.26 288.78,40.39 288.78,45.19 289.76,46.18 289.76,47.63 289.97,47.84 289.97,49.04 289.4,49.62 289.4,50.13 290.08,50.82 290.08,51.54 291.55,53.01 291.55,55.96 292.39,56.79 292.39,57.89 292.39,57.89 292.39,58.16 292.39,58.38 292.81,58.81 292.81,59.05 293.71,59.95 295.09,59.95 295.16,60.02 296.11,60.02 297.52,61.43 299.27,61.43 299.88,60.82 299.88,60.54 300.13,60.29 300.64,60.29 300.94,60.59 300.94,60.79 301.46,61.31 301.96,61.31 302.17,61.1 302.17,59.05 301.25,58.14 R6214.1
XTAL24_IN: length 10.3
  IN1 w0.076: v1(238.87,76.24) 238.92,75.59 241.34,73.17 242.51,73.17 243.87,71.81 v1(243.87,71.78)
  BOTTOM w0.114: U9002.U10 243.87,70.92 v1(243.87,71.78) ; v1(238.87,76.24) 238.58,76.29 R9169.2 237.98,76.69 L9000.3
XTAL24_IN_L: length 2.4
  BOTTOM w0.114: L9000.4 236.48,78.19 C9212.2 235.7,79.34 Y9000.1
XTAL24_OUT: length 10.4
  IN1 w0.076: v1(238.41,75.78) 238.41,75.45 238.7,75.16 238.7,74.95 238.52,74.77 238.52,74.58 238.66,74.45 238.85,74.45 239.03,74.63 239.24,74.63 241.15,72.71 242.31,72.71 v1(243.23,71.78)
  BOTTOM w0.114: v1(238.41,75.78) 237.99,75.78 R9169.1 237.63,76.34 L9000.2 ; U9002.U9 243.62,71.16 243.62,71.4 v1(243.23,71.78)
XTAL24_OUT_L: length 2.2
  BOTTOM w0.114: R9587.2 235.77,77.52 C9213.2 236.06,76.78 L9000.1
XTAL24_OUT_L_L: length 2.7
  BOTTOM w0.114: R9587.1 235.87,78.26 235.87,78.45 234.96,79.36 Y9000.3
XTAL_25_IN: length 3.7
  BOTTOM w0.114: L8000.4 337.47,120.19 C8050.2 337.89,120.69 339.26,122.05 Y8000.1
XTAL_25_OUT: length 5.6
  BOTTOM w0.114: L8000.1 336.97,120.59 C8051.2 337.12,120.61 338.11,121.6 338.11,122.95 Y8000.3
XTAL_IN: length 6.8
  BOTTOM w0.114: U7300.27 287.96,19.84 C7315.1 288.07,20.99 288.07,22.4 Y7300.1 286.1,23.37 v1(285.88,23.15)
XTAL_OUT: length 4.4
  BOTTOM w0.114: v1(290.46,21.67) Y7300.3 288.57,20.94 C7314.1 288.57,19.92 288.61,19.88 U7300.28
XTALOUTBUFF: length 10.4
  BOTTOM w0.102: 222.53,97.19 222.53,98.58 222.22,98.9 221.9,98.9 221.65,99.15 221.65,100.55 221.29,100.9 U2000.J4
  BOTTOM w0.114: 222.53,97.19 222.53,96.8 223.94,95.39 224.31,95.39 224.87,94.83 v1(224.87,94.32) 224.54,93.99 224.54,93.26 R2084.1
XTALSSIN: length 4.5
  BOTTOM w0.114: U2000.H1 222.08,96.73 223.84,94.97 R2083.1
N473130: length 3.3
  TOP w0.102: TP1001.1 156.37,46.72 156.6,46.95 JDIM1000.165
N484850: length 22.3
  TOP w0.102: JDIM1000.162 155.85,57.97
  TOP w0.114: 155.85,57.97 155.85,58.24 158.12,60.5 v1(158.33,60.5)
  IN3 w0.089: v1(159.42,45.43) 160.18,46.19 160.18,59.27 158.95,60.5 v1(158.33,60.5)
  BOTTOM w0.102: TP1000.1 v1(159.42,45.43)
N561500: length 2.5
  TOP w0.102: TP1007.1 156.17,41.8 155.85,41.49 JDIM1003.162
N562420: length 4.6
  TOP w0.102: JDIM1003.165 156.6,31.21
  TOP w0.114: v1(156.6,30.67) 156.6,30.68 156.6,31.21
  BOTTOM w0.102: v1(156.6,30.67) 156.37,30.44 156.37,30.41
  BOTTOM w0.114: TP1006.1 155.61,28.41 156.37,29.17 156.37,30.41
N4140647: length 6.2
  TOP w0.203: PR9820.1 201.81,53.62 201.81,52.52 v1(201.71,52.41) 201.2,52.41 201.05,52.57 200.45,52.57 PC9805.1 199.41,52.54 v1(199.3,52.54)
  BOTTOM w0.203: PU9802.2 199.24,52.49 v1(199.3,52.54) 199.41,52.54 PC9805.1
N5284227: length 2.9
  BOTTOM w0.102: JDIM1001.162 155.85,46.06 TP1002.1
N5284228: length 14.8
  TOP w0.102: v1(155.48,44.9) 154.97,45.4 TP1003.1
  IN3 w0.089: v1(155.48,44.9) 155.48,46.83 157.95,49.29 v1(157.95,50.59)
  BOTTOM w0.102: JDIM1001.165 156.6,55.51 157,55.12 157.64,55.12 158.4,54.35 158.4,51.04 v1(157.95,50.59)
N6172027: length 5
  BOTTOM w0.102: JDIM1002.162 155.85,31.08 155.66,30.88 155.66,30.41
  BOTTOM w0.114: 155.66,30.41 155.61,30.36 155.61,29.78 154.08,28.25 TP1004.1
N6172028: length 3.1
  BOTTOM w0.102: TP1005.1 156.6,43.29 JDIM1002.165
N16771972: length 19.5
  TOP w0.114: v1(199.22,100.55) 201.32,102.65 201.32,103.2 200.67,103.85 200.67,105.96 201.22,106.51 203,106.51 203.69,107.2 v1(204.11,107.2)
  BOTTOM w0.114: Q2012.1 196.1,94.56 v1(196.25,94.71) R2080.1 197.77,96.23 197.77,97.63 199.68,99.53 199.68,100.09 v1(199.22,100.55)
  BOTTOM w0.127: v1(204.11,107.2) 204.08,107.2 U2000.AK12
N16948284: length 4.6
  TOP w0.114: R7022.2 R7019.2 v1(25.61,97.37) 25.31,97.37 25.19,97.25 R7016.2 24.28,97.77 U7005.4
N16948310: length 3.7
  TOP w0.114: U7005.15 19.98,100.3 R7013.2 v1(19.34,101.77)
N16948312: length 3
  TOP w0.114: U7005.5 26.7,99.8 R7008.2 27.46,99.54 v1(27.85,99.15)
N16948334: length 2.6
  TOP w0.114: U7005.16 21.11,99.8 21.05,99.86 v1(20.23,99.86) 19.4,99.86 R7011.1
N17042326: length 11.5
  BOTTOM w0.114: Q2014.3 216.41,89.7 216.59,89.88 217.58,89.88 217.91,89.55 v1(217.91,89.12) 217.91,89.04 218.75,88.2 218.75,86.86 219.51,86.1 219.51,82.95 218.98,82.41 R2143.1 R2142.1
N17267000: length 4.6
  BOTTOM w0.114: v1(134.77,148.56) PR19000.1
  BOTTOM w0.203: PU19000.44 132.15,148.33 132.37,148.56 PC19000.1
  BOTTOM w0.508: PC19000.1 PR19000.1
N17269856:
  vias: v1(201.68,157.27)
N17269865:
  vias: v1(201.96,153.63)
N17269924:
  vias: v1(224.19,156.05)
N17269933:
  vias: v1(223.3,154.9)
N17327231: length 2.5
  TOP w0.114: Q9000.2 169.07,138.9 168.55,139.42 R9018.2 168.31,140.04 v1(168.13,140.22)
N17654321: length 3.7
  TOP w0.102: 255.86,85.1 255.31,84.55 R9123.1
  TOP w0.114: v1(257.97,86.32) 257.69,86.04 Q9006.1 256.8,86.04 255.86,85.1
N17654323: length 3.9
  TOP w0.114: Q9007.1 253.17,86.86 254.49,88.18 v1(254.84,88.18) 254.95,88.08 Q9006.3
N17980871: length 445.9
  IN1 w0.076: v1(288.58,25.11) 288.21,24.74 286.48,24.74 284.37,22.64 284.37,21.66 284.16,21.44 283.18,21.44 280.27,18.53 280.27,16.54 271.95,8.22 265.84,8.22 264.7,7.08 255.75,7.08 254.25,8.57 251.05,8.57 249.6,7.13 249.6,6.76 249.29,6.45 249.17,6.45 247.28,6.45 246.4,7.33 244.5,7.33 243.75,8.08 240.95,8.08 240.22,8.81 238.55,8.81 237.92,9.44 237.28,9.44 236.77,8.93 234.49,8.93 233.72,8.17 226.17,8.17 225.58,7.58 214.66,7.58 211.97,10.28 207.91,10.28 v1(207.55,10.63) ; v1(19.84,99.28) 22.89,96.23 22.89,95.65 23.88,94.66 24.8,94.66 25.43,94.02 25.43,91.2 26.56,90.07 26.56,88.67 28.68,86.55 28.68,84.06 33.46,79.29 33.46,77.65 35.06,76.05 35.06,72.66 36.87,70.84 36.87,68.51 38.21,67.17 38.21,63.39 39.54,62.05 39.54,60.64 39.76,60.43 40.44,60.43 41.74,59.13 41.74,56.78 44.3,54.22 44.3,48.02 47.28,45.05 51.09,45.05 v1(51.47,44.67)
  IN3 w0.089: v1(207.55,10.63) 206.46,11.72 206.46,14.13 203.3,17.29 183.92,17.29 180.01,13.38 137.14,13.38 136.35,12.59 106.02,12.59 104.73,13.88 104.73,15.56 103.9,16.39 103.9,17.03 103.31,17.62 102.65,17.62 101.49,18.78 100.69,18.78 98.23,21.23 98.23,38.84 93.06,44.02 93.06,45.74 89.9,48.9 89.12,48.9 89.01,49.01 74.94,49.01 72.38,46.45 70.01,46.45 68.75,45.18 51.98,45.18 v1(51.47,44.67)
  IN4 w0.076: v1(322.21,78.32) 322.49,78.04 322.49,76.18 316.58,70.28 316.58,69.25 312.58,65.24 312.58,62.83 v1(312.45,62.7)
  BOTTOM w0.114: v1(312.45,62.7) 311.33,62.7 310.83,62.19 300.39,62.19 300.01,61.81 297.57,61.81 296.01,60.25 295.07,60.25 295,60.18 293.62,60.18 292.58,59.15 292.58,58.9 292.16,58.48 292.16,58.25 292.16,58.25 292.16,57.79 292.16,57.79 292.16,56.89 291.33,56.05 291.33,53.11 289.8,51.58 289.8,51.01 289.17,50.38 289.17,49.37 289.59,48.94 289.59,47.84 289.47,47.72 289.47,47.21 288.76,46.51 288.76,45.56 288.55,45.35 288.55,40.67 288.55,40.15 290.67,38.03 290.67,35.56 291.06,35.17 291.06,28.3 289.74,26.98 289.74,26.66 288.83,25.74 288.83,25.36 v1(288.58,25.11) ; v1(322.21,78.32) R6304.2 322.86,77.68 323.23,77.31 Q6301.3 322.72,76.28 R6300.1 322.74,75.77 322.74,74.77 322.99,74.51 U6300.2 ; v1(19.84,99.28) 20.23,98.89 R6301.1 20.61,98.52 20.73,98.39 U6301.2
N17988049: length 1.9
  BOTTOM w0.114: v1(132.24,26.76) 132.15,26.68 C1000.2
  BOTTOM w0.508: R1015.2 C1000.2
N17989426: length 2
  BOTTOM w0.114: R1041.1 v1(147.87,23.21)
  BOTTOM w0.508: C1088.2 R1041.1
N18005245:
  vias: v1(33.31,49.37)
N18039182: length 3.8
  TOP w0.114: CON6800.1 234.96,58.49 236,59.53 v1(236.25,59.53) 236.62,59.53 R6809.2
N18039210: length 2.9
  TOP w0.114: R6812.2 235.86,57.88 v1(235.36,57.88) 235.25,57.99 CON6800.2
N18039226: length 3.8
  TOP w0.114: R6813.2 236.9,56.61 v1(235.62,56.61) 234.73,57.49 CON6800.3
N18039254: length 5.8
  TOP w0.114: CON6800.4 234.6,56.99 236.63,54.95 237.52,54.95 v1(237.9,54.57) 237.89,54.57 R6814.2
N18039268: length 3.6
  TOP w0.114: v1(232.19,56.06) 232.61,56.49 CON6800.5
  BOTTOM w0.114: v1(232.19,56.06) 232.15,56.1 R6815.1 v1(231.43,56.95)
N18039296: length 3
  TOP w0.114: CON6800.6 232.9,55.99 v1(232.82,56.06)
  BOTTOM w0.114: R6816.1 231.84,55.08 v1(232.82,56.06)
N18039311: length 3.4
  TOP w0.114: CON6800.7 235.46,55.49 v1(235.62,55.34) 235.88,55.34 R6817.2
N18039329: length 5
  TOP w0.114: CON6800.8 234.69,54.99 v1(235.62,54.07) 235.62,51.91 236,51.53 R6811.2
N18039352: length 5.5
  TOP w0.114: R6818.2 235.87,50.51 235.26,51.12 235.26,53.79 234.56,54.49 CON6800.9
N18039370: length 5.9
  TOP w0.114: CON6800.10 234.55,53.99 235.01,53.53 235.01,50.48 236,49.49 R6819.2
N18039389: length 6.5
  TOP w0.114: CON6800.11 234.67,53.49 234.78,53.38 234.78,50.39 235.2,49.97 235.79,49.38 235.79,48.71 236.02,48.48 R6820.2
N18039414: length 3.1
  TOP w0.114: v1(232.92,52.94) 232.98,52.99 CON6800.12
  BOTTOM w0.114: R6821.2 231.84,52.52 232.5,52.52 v1(232.92,52.94)
N18039420: length 3.3
  TOP w0.114: CON6800.13 232.77,52.49 232.32,52.03 v1(232.32,51.58)
  BOTTOM w0.114: R6822.1 231.86,52.03 v1(232.32,51.58)
N18113226: length 2.5
  TOP w0.114: R2111.1 235.75,63.35 235.23,62.82 C2215.2 R2110.2
N18140305: length 2.9
  TOP w0.114: R2060.2 C2167.2 218.21,86.64 218.01,86.83 v1(218.01,87.21) 218.14,87.34 R2059.1

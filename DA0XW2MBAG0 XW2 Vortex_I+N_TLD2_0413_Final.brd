# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_PECI: length 360.3
  TOP w0.127: R9166.2 245.12,76.86 v1(244.01,76.86) 243.56,77.31 243.24,77.31 238.77,81.78 234.68,81.78 232.35,79.45 232.35,74.36 231.76,73.76 231.76,73.44 230.77,72.45 230.77,71.4 229.77,70.4 229.77,62.68 229.23,62.14 229.23,59.88 230.6,58.51 230.6,37.58 231.71,36.48 231.71,32.64 226.46,27.4 220.51,27.4 211.97,18.86 205.98,18.86 203.05,15.93 203.05,15.09 v1(202.43,14.47)
  IN1 w0.127: v1(202.43,14.47) 201.96,14.94 201.96,15.42 199.73,17.65 182.53,17.65 176.67,11.8 113.57,11.8 104.48,20.89 103.21,20.89 102.14,19.82 v1(102.14,19.78) ; v1(82.46,58.26) 82.94,58.74 82.94,59.09 81.62,60.42 81.62,64.79 83.73,66.89 83.73,67.65 85.99,69.92 85.99,70.43 90.91,75.35 91.64,75.35 93.38,77.09 93.96,77.09 96.03,79.16 99.42,79.16 101.56,81.3 101.56,85.18 102.7,86.33 102.7,87.21 103.71,88.23 103.71,89 105.49,90.78 105.49,91.26 106.99,92.76 106.99,94.05 108.13,95.19 108.13,98.24 108.87,98.97 109.56,98.97 117.28,106.7 117.28,110.65 122.23,115.6 122.23,116.25 121.91,116.56 121.91,116.99 123.89,118.97 131.88,118.97 134.68,121.76 134.9,121.76 135.32,122.18 135.32,123.88 134.69,124.51 v1(134.69,125.53)
  BOTTOM w0.114: v1(244.01,76.86) 244.22,76.86 U9002.AF2
  BOTTOM w0.127: v1(102.14,19.78) 101.33,20.59 101.33,31.88 100.55,32.65 100.55,37.61 95.65,42.51 95.65,49.48 93.11,52.02 90.61,52.02 87.41,55.21 87.21,55.42 85.16,55.42 82.46,58.13 v1(82.46,58.26) ; R9017.1 v1(134.69,125.53)
PCH_PWROK: length 19.6
  TOP w0.127: U9000.4 276.1,67.53 275.12,67.53 274.61,68.04 274.1,68.04 273.51,68.62 273.51,69.72 R9128.2 R9132.1 272.17,70.68 271.54,70.05 R9134.1 v1(270.92,68.04) 270.64,67.75 269.96,67.75 269.1,68.61 268.63,68.61 268.55,68.54 266.2,68.54 265.89,68.85 264.39,68.85 263.83,68.29 263.29,68.29 v1(262.95,67.95)
  BOTTOM w0.114: U9002.AY42 262.95,67.62 v1(262.95,67.95)
PCH_SLP_S0IX#: length 10.5
  TOP w0.114: v1(257.19,73.47) 257.08,73.58 257.08,74.06 257.51,74.49 257.51,75.09 257.12,75.48 257.12,75.77 258.09,76.75
  TOP w0.127: R9239.2 262.14,79.51 v1(261.65,79.02) 261.31,79.02 259.04,76.75 258.09,76.75
  BOTTOM w0.114: v1(257.19,73.47) 256.32,73.47 U9002.AW24
PCH_SLP_SUS#: length 63.1
  TOP w0.114: v1(263.56,49.53) 263.42,49.4 R9597.1
  IN1 w0.076: v1(273.19,44.24) 272.93,43.98 271.55,43.98 270.87,44.66 268.17,44.66 267.61,45.21 266.93,45.21 263.56,48.59 v1(263.56,49.53)
  IN2 w0.076: 267.91,30.44 267.91,29.55 v3(268.24,29.22)
  IN2 w0.089: v1(273.19,44.24) 273.19,38.9 270.61,36.32 270.61,33.28 267.91,30.57 267.91,30.44 ; v1(266.66,71.37) 268.09,69.94 268.41,69.94 268.98,69.37 268.98,68.61 270.47,67.13 270.47,63 269.98,62.52 269.98,61.62 270.24,61.36 270.24,59.22 268.7,57.69 268.7,56.21 268.03,55.54 267.33,55.54 263.51,51.72 263.51,50.56 263.56,50.51 v1(263.56,49.53)
  BOTTOM w0.102: U9002.BD39 263.5,69.95 263.77,70.22 263.77,70.37 264,70.6 264.36,70.6 264.93,71.17 266.45,71.17 v1(266.66,71.37)
  BOTTOM w0.114: U6001.J6 v3(268.24,29.22)
PCH_SMBCLK: length 438.7
  TOP w0.102: 178.97,49.84 178.97,50.1 180.12,51.24
  TOP w0.114: v1(182.79,36.29) 182.79,36.16 181.77,35.14 180.35,35.14 178.6,33.4 JDIM1003.253 ; Q9008.1 264.19,81.98 264.19,81.96 R9126.2 265.4,81.48 265.76,81.84 265.76,82.13 265.69,82.2 265.69,82.89 265.82,83.02 v3(265.82,83.1) ; 180.12,51.24 180.12,52.69 181.33,53.91 v1(181.39,53.91) ; JDIM1000.253 178.6,49.47 178.97,49.84
  IN1 w0.076: v1(90.46,64.78) 90.99,64.25 94.24,64.25 94.55,63.95 98.94,63.95 100.36,62.52 104.51,62.52 105.91,61.13 105.91,50.77 108.26,48.42 108.26,38.9 109.77,37.38 109.77,36.53 114.54,31.76 167.55,31.76 167.96,32.18 174.82,32.18 175.94,33.3 179.55,33.3 181.13,34.89 181.9,34.89 182.89,35.88 182.89,36.18 v1(182.79,36.29) ; v1(164.01,17.64) 165.64,19.27 172.37,19.27 173.02,19.92 179.37,19.92 180.77,21.31 191.14,21.31 191.56,21.73 201.71,21.73 205.26,18.18 214.3,18.18 219.94,23.81 229.43,23.81 233.4,27.79 249.26,27.79 253.12,23.93 253.12,20.47 260.82,12.77 272,12.77 280.87,21.63 281.78,21.63 284.03,23.88 284.03,24.88 285.58,26.43 285.96,26.43 286.42,26.89 v1(287.94,26.89)
  IN4 w0.076: v3(265.82,83.1) 266.32,83.1 266.73,82.68 266.73,82.11 270.9,77.94 271.37,77.94 275.74,73.58 276.45,73.58 276.69,73.33 278.58,73.33 280.39,71.52 280.88,71.52 280.96,71.44 v1(282.4,71.44) ; v1(164.01,17.64) 162.85,18.81 162.85,25.55 163.76,26.47 165.56,26.47 167.27,28.17 167.27,29.27 166.99,29.56 166.99,31.71 168.52,33.25 179.76,33.25 182.79,36.28 v1(182.79,36.29) 181.9,37.17 181.9,42.08 182.53,42.71 182.53,46.52 181.64,47.41 181.64,50.26 182.53,51.14 182.53,53.01 181.63,53.91 v1(181.39,53.91)
  BOTTOM w0.102: v1(182.79,36.29) 181.52,37.56 179.74,37.56 178.6,38.69 JDIM1002.253
  BOTTOM w0.114: v1(287.94,26.89) 287.94,27.05 289.87,28.97 289.87,34.68 289.47,35.08 289.47,37.17 287.3,39.34 287.3,47.33 286.42,48.21 286.42,50.51 287.67,51.76 287.67,54.14 289.55,56.03 289.55,56.39 290.73,57.57 290.73,58.26 290.22,58.76 290.22,62.86 286.27,66.82 285.46,66.82 283.29,68.99 283.29,70.84 282.68,71.44 v1(282.4,71.44) ; CON400.53 78.23,64 78.81,64.58 80.5,64.58 81.37,65.45 89.8,65.45 v1(90.46,64.78) ; v1(181.39,53.91) 180.95,54.35 179.57,54.35 178.6,55.31 JDIM1001.253
PCH_SMBDATA: length 444.7
  TOP w0.102: v1(182.79,36.92) 182.28,37.43 179.99,37.43 178.85,38.57 JDIM1003.254
  TOP w0.114: JDIM1000.254 178.85,55.3 180.24,53.91 v1(180.75,53.91) ; Q9008.4 262.44,85.56 262.2,85.56 R9125.2 262.92,85.96 v3(263.15,85.74)
  IN1 w0.076: v1(288.58,26.89) 288.14,26.46 286.45,26.46 286.1,26.1 285.73,26.1 284.36,24.73 284.36,23.74 281.92,21.3 281,21.3 276.64,16.93 276.64,16.08 272.89,12.33 260.79,12.33 252.79,20.33 252.79,23.79 249.12,27.46 233.54,27.46 229.57,23.48 220.08,23.48 214.34,17.74 205.08,17.74 201.43,21.4 191.69,21.4 191.28,20.98 180.91,20.98 178.68,18.76 165.79,18.76 v1(164.7,17.67) ; v1(89.82,64.78) 89.82,64.76 90.66,63.92 94.1,63.92 94.41,63.62 98.74,63.62 100.16,62.19 104.18,62.19 105.48,60.9 105.48,50.74 107.93,48.29 107.93,38.76 109.44,37.25 109.44,36.39 114.5,31.33 167.72,31.33 168.14,31.75 175,31.75 176.12,32.87 179.73,32.87 181.31,34.46 182.1,34.46 183.32,35.68 183.32,36.51 182.91,36.92 v1(182.79,36.92)
  IN4 w0.076: v1(180.75,53.91) 181.26,54.41 181.73,54.41 183.07,53.08 183.07,51.07 182.07,50.08 182.07,47.59 183.04,46.63 183.04,42.51 182.33,41.8 182.33,37.38 v1(182.79,36.92) 183.22,36.49 183.22,36.1 179.94,32.82 168.8,32.82 167.2,31.22 167.2,30.05 167.7,29.55 167.7,28.14 165.7,26.14 163.9,26.14 163.28,25.51 163.28,20.23 164.7,18.81 v1(164.7,17.67) ; v3(263.15,85.74) 264.02,85.74 267.06,82.69 267.06,82.24 271.03,78.27 271.51,78.27 275.88,73.91 276.58,73.91 276.83,73.66 278.71,73.66 280.5,71.87 v1(281.85,71.87)
  BOTTOM w0.102: JDIM1002.254 178.85,34.01 179.86,35.02 182.15,35.02 183.22,36.08 183.22,36.49 v1(182.79,36.92)
  BOTTOM w0.114: CON400.51 78.73,63.98 78.95,64.2 80.79,64.2 81.56,64.98 89.44,64.98 89.63,64.78 v1(89.82,64.78) ; v1(281.85,71.87) 282.77,71.87 283.65,70.99 283.65,69.15 285.52,67.29 286.32,67.29 288.89,64.71 288.96,64.71 290.59,63.08 290.59,58.91 291.1,58.41 291.1,57.42 289.92,56.24 289.92,55.87 288.04,53.99 288.04,51.6 286.8,50.36 286.8,48.35 287.67,47.48 287.67,39.71 289.85,37.53 289.85,35.22 290.23,34.83 290.23,28.82 288.58,27.16 v1(288.58,26.89) ; v1(180.75,53.91) 180.37,53.53 180.37,51.11 178.85,49.6 JDIM1001.254
PCH_SPI1_CLK_L: length 11.4
  BOTTOM w0.102: 266.32,63.29 265.9,63.29 265.34,63.85 265.34,64.46 264.24,65.56 U9002.AW47
  BOTTOM w0.114: R9200.2 R9599.1 270.14,58.66 v1(270.14,59.93) 269.56,60.5 269.56,60.89 269.02,61.43 268.17,61.43 266.32,63.29
PCH_SPI1_SI_L: length 12.3
  TOP w0.114: v1(261.78,66.26) 261.93,66.41 262.8,66.41 263.43,65.78 263.43,64.43 v1(265.12,62.74) 265.56,62.3 265.56,61.58 266.13,61.02 R9207.2 266.02,60.81 266.02,60.31 267.01,59.32 267.27,59.32 R9203.1 267.53,59.06 R9197.2
  BOTTOM w0.114: U9002.AU41 261.65,66.57 261.78,66.45 v1(261.78,66.26)
PCH_SPI1_SO_L: length 11
  TOP w0.114: v1(264.6,67.16) 264.6,66.87 265.54,65.92 R9194.2 265.77,65.87 265.77,65.16 266.17,64.77 267.15,64.77 267.75,65.37 267.93,65.37 268.83,64.47 268.83,63.14 v1(268.77,63.08) 268.77,63.03 268.46,62.71 268.46,61.94 R9192.1 268.92,61.48 268.92,61.25 269.23,60.95
  BOTTOM w0.114: v1(264.6,67.16) 264.28,66.85 U9002.BA45
PCH_SPI_CS0#_L: length 4.9
  BOTTOM w0.102: 266.69,63.43 266.58,63.54 266.58,63.74 266.36,63.96 266.36,64.05 266.17,64.25 265.73,64.68 265.44,64.68 265.03,65.09 264.99,65.09 264.58,65.5 U9002.AY47
  BOTTOM w0.114: R9199.2 267.37,62.83 267.29,62.83 266.69,63.43
PCH_SPI_IO2_ROM: length 5
  BOTTOM w0.114: U6204.3 305.58,53.84 305.57,53.84 U6202.3 301.77,53.84 R6152.2 v1(301.68,52.82)
PCH_SPI_IO3_ROM: length 12.9
  BOTTOM w0.114: R6218.1 R6210.2 315.75,51.92 315.09,52.57 U6202.7 313.51,52.57 U6204.7 312.76,52.57 312.5,52.31 312.5,50.81 310.7,49.01 309.94,49.01 308.18,47.26 v1(308.18,46.85)
PCH_TBT_PERST#: length 32.4
  TOP w0.102: 263.4,73.77 v3(263.63,74)
  TOP w0.114: U12001.2 276.13,52.8 275.88,53.05 275.88,53.54 276.07,53.73 R17977.2 276.07,56.74 275.73,57.09 275.73,57.09 274.96,57.86 274.95,57.87 274.51,58.3 274.51,61.78 v1(274.23,62.07) ; R9588.1 263.4,73.77
  IN2 w0.089: v1(274.23,62.07) 274.48,62.32 274.48,62.38 275.11,63.01 275.11,63.9 273.41,65.6 273.16,65.6 270.92,67.85 270.92,68.22 268.16,70.98 267.59,70.98 265.59,72.99 265.21,72.99 264.95,72.73 264.43,72.73 263.63,73.53 v3(263.63,74)
  BOTTOM w0.102: U9002.BF33 262.24,72.65 262.57,72.98 262.78,72.98 263.31,73.51 263.31,73.68 v3(263.63,74)
PCH_TBT_WAKE#: length 149.1
  TOP w0.114: Q9043.1 348.33,102.62 348.09,102.62 347.6,103.12 341.66,103.12 340.86,103.93 340.86,105.22 339.36,106.72 v1(339.33,106.72) ; v1(274.56,50.43) 275.52,51.4 277.58,51.4 277.73,51.25 277.73,50.71 277.53,50.51 277.53,49.93 277.76,49.7 279.1,49.7 279.69,50.28 286.98,50.28 288.32,51.62 288.32,55.77 289.72,57.17 289.72,58.36 289.87,58.51 291.67,58.51 292.18,59.02 292.18,59.03 293.96,60.81 296.59,60.81 297.44,61.66 299.65,61.66 300.46,60.85 v1(300.46,60.8)
  IN1 w0.076: v1(339.33,106.72) 339.24,106.72 338.72,106.2 338.72,102.29 337.53,101.11 337.53,91.43 336.1,89.99 336.1,85.17 332.56,81.62 328.71,81.62 327.18,80.1 327.18,77.46 327.57,77.08 327.57,71.08 326.02,69.53 326.02,66.82 325.79,66.59 322.38,66.59 320.83,68.14 320.15,68.14 317.66,65.65 317.66,65.42 314.94,62.7 v1(313.12,62.7)
  BOTTOM w0.102: U9002.AL48 261.94,62.25 261.94,61.39 262.41,60.92
  BOTTOM w0.114: v1(300.46,60.8) 301.61,61.94 311.05,61.94 311.32,62.22 312.63,62.22 v1(313.12,62.7) ; 262.41,60.92 262.72,60.61 262.72,59.6 263.1,59.22 263.1,58.46 265.59,55.97 265.93,55.97 266.76,55.14 266.76,54.89 267.76,53.89 268.4,53.89 269.65,55.14 269.65,55.34 270.03,55.72 270.29,55.72 R9241.1 271.47,55.23 273.26,53.44 273.26,51.99 274.56,50.69 v1(274.56,50.43)
PCH_TCK: length 268.1
  TOP w0.114: v1(202.42,13.17) 201.91,13.68 201.91,15.82 205.5,19.41 211.74,19.41 220.29,27.96 226.22,27.96 229.99,31.73 229.99,33.91 229.31,34.59 229.31,37.24 230.05,37.98 230.05,58.28 228.68,59.65 228.68,62.36 229.22,62.9 229.22,70.62 230.2,71.6 230.2,72.69 231.18,73.67 231.18,75.87 231.78,76.47 231.78,79.66 234.45,82.33 239.89,82.33 241.63,80.59 R9117.2 243.26,80.1 243.36,80 v1(243.36,79.29)
  IN1 w0.076: v1(100.53,19.9) 101.05,19.38 104.54,19.38 112.76,11.17 176.94,11.17 182.74,16.97 197.85,16.97 198.81,16 200.48,16 201.32,15.16 201.32,14.51 201.99,13.84 201.99,13.6 v1(202.42,13.17)
  BOTTOM w0.089: U9002.AJ3 245.51,77.23 245.51,77.41 245.14,77.78 245.14,77.81
  BOTTOM w0.102: 245.14,77.81 243.67,79.29 v1(243.36,79.29)
  BOTTOM w0.114: v1(100.53,19.9) 100.74,20.11 100.74,24.73 99.06,26.41 99.06,36.95 92.62,43.38 92.62,46.59 89.33,49.89 83.53,49.89 79.36,54.07 79.36,58.7 R403.2
PCH_TDI: length 4.4
  BOTTOM w0.102: U9002.AH2 244.84,77.25 243.79,78.3 243.42,78.3
  BOTTOM w0.114: R9115.1 241.29,78.62 242.36,78.62 242.68,78.3 243.42,78.3
PCH_TDO: length 8.3
  BOTTOM w0.089: U9002.AH3 245.11,76.98 245.11,77.27 244.6,77.78
  BOTTOM w0.102: 244.6,77.78 243.83,78.56 243.65,78.56
  BOTTOM w0.114: 243.65,78.56 242.88,78.56 R9124.2 241.08,79.57 240.28,80.37 240.28,81.04 R9114.1 240.7,81.45 v1(240.7,81.9)
PCH_TMS: length 10.8
  BOTTOM w0.089: U9002.AJ4 245.79,76.62 245.31,77.1 245.31,77.34 244.87,77.78 244.87,77.8 244.73,77.94
  BOTTOM w0.102: 244.73,77.94 243.83,78.83 243.75,78.83
  BOTTOM w0.114: 243.75,78.83 243.21,78.83 241.12,80.93 241.12,82.17 240.85,82.44 239.6,82.44 v1(239.4,82.64) 239.4,82.67 R9112.1
PCH_VCCA_SRC_1P05: length 3.2
  TOP w0.508: R17901.1 248.44,67.34 v1(248.23,67.34) 247.48,66.58 C12024.2
  BOTTOM w0.254: v1(248.23,67.34) U9002.W20 U9002.W19
PCH_VCCPRIM_1P05_AD31: length 1.8
  TOP w0.381: v1(253.14,65.68) 252.95,65.5 252.17,65.5 R17909.1
  BOTTOM w0.254: U9002.AD31 v1(253.14,65.68)
PCH_WAKE#_L: length 11.7
  BOTTOM w0.114: R9093.1 275.5,67.38 v1(274.89,66.77) 274.89,66.65 R9094.1 273.57,66.04 272.27,67.34 271.44,67.34 270.62,66.51 269.65,66.51 269.17,66.02 267.32,66.02 267.2,65.91 266.44,65.91 266.26,66.09 266.26,66.31 U9002.BB47
PCI_PLTRST#: length 717.7
  TOP w0.127: v1(227.17,85.22) 226.9,85.49 U2001.2 ; 278.29,52.77 277.61,53.45 U12001.1 ; 278.29,52.77 277.98,52.47 275.95,52.47 275.37,53.05 v1(275.37,53.68) ; 278.29,52.77 278.57,52.49 279.55,52.49 279.88,52.16 280.2,52.16 R9586.1 280.79,51.58 285.17,51.58 v1(285.32,51.73) ; v1(317.07,41.75) 316.87,41.54 316.87,37.4 315.98,36.51 315.98,22.06 317.86,20.18 v1(317.86,19.83) ; Q6501.2 293,44.69 292.89,44.79 292.39,44.79 291.75,45.43 291.75,46.06 292.13,46.45 R6507.2 289.47,47.07 289.07,47.48 286.54,47.48 v1(286.51,47.51) ; R9213.2 260.19,76.82 R9215.2 261.65,77.18 261.65,77.34 U9003.4 262.8,78.48 262.8,79.21 263.84,80.25 264.7,80.25 266.2,81.75 v3(266.2,82.72) 266.27,82.79 266.27,83.3 262.39,87.19 262.39,87.82 261.91,88.31 261.91,89.17 260.97,90.11 260.38,90.11 259.92,89.64 256.02,89.64 255.02,90.64 v1(254.62,90.64) 254.41,90.44 253.41,90.44 253.33,90.51 252.38,90.51 251.3,89.43 250.71,89.43 250.35,89.07 250.35,88.86 249.97,88.48 249.97,87.26 250.22,87.01 250.22,86.58 250.55,86.25 Q9007.2 ; v1(280.88,23.69) 280.19,23.69 279.91,23.97 277.68,23.97 Q6001.2
  IN1 w0.127: v1(317.07,41.75) 314.87,41.75 310.42,46.19 307.7,46.19 306.48,44.97 v1(305.92,44.97)
  IN2 w0.127: v1(254.62,90.64) 254.62,90.82 253.98,91.45 253.63,91.45 252.88,90.71 250.9,90.71 250.66,90.46 249.17,90.46 246.37,87.66 235.08,87.66 234.66,87.24 233.14,87.24 233.04,87.33 231.05,87.33 230.74,87.02 228.66,87.02 227.48,85.84 227.48,85.53 v1(227.17,85.22) 227.17,84.71 228.45,83.43 228.45,82.36 230.33,80.48 230.33,76.73 231.79,75.27 232.2,75.27 233.48,73.99 233.89,73.99 235.02,72.86 235.02,69.56 235.89,68.69 235.89,66.84 236.46,66.28 237.07,66.28 237.57,65.77 237.57,65.22 237.12,64.77 236.55,64.77 236.14,64.36 236.14,63.99 235.92,63.78 235.92,61.07 236.5,60.49 236.5,58.56 235.82,57.88 235.82,38.39 235.14,37.71 235.14,34.98 234.19,34.03 233.71,34.03 233.25,33.57 232.67,33.57 230.05,30.95 220.93,30.95 217.98,28 206.41,28 205.09,26.68 182.11,26.68 181.61,26.18 179.87,26.18 179.12,26.93 169.69,26.93 168.95,26.19 115.76,26.19 115.29,25.72 106.16,25.72 104.99,26.89 104.99,29.3 103.06,31.23 103.06,41.08 96.64,47.5 96.64,49.42 93.9,52.15 91.03,52.15 88.79,54.39 87.35,54.39 86.52,55.23 84.79,55.23 83.82,56.2 80.8,56.2 78.41,58.59 73.75,58.59 72.86,59.48 71.16,59.48 70.06,60.58 68.78,60.58 67.09,58.89 58.02,58.89 57.16,58.03 55.31,58.03 54.8,58.54 53.94,59.4 52.36,59.4 51.09,58.13 46.9,58.13 46.39,58.64 42.63,58.64 40.93,60.34 40.93,60.95 38.28,63.59 38.28,64.96 36.18,67.07 35.24,67.07 33.26,69.05 33.26,70.6 v1(32.57,71.29) 32.14,71.72 32.14,75.81 22.23,85.71 22.23,92.47 21.58,93.12 21.58,102.57 21.27,102.88 21.27,106.9 20.99,107.18 20.99,108.85 21.83,109.69 22.71,109.69 24.57,111.55 v1(24.57,111.85) ; v1(285.32,51.73) 286.64,50.42 286.64,47.65 286.51,47.53 v1(286.51,47.51) ; v1(340.1,26.07) 340.96,26.93 340.96,27.52 340.98,27.55 340.98,32.37 346.36,37.75 349.03,37.75 349.24,37.96 350.72,37.96 352.58,36.1 357.53,36.1 358.58,37.15 358.58,45.59 355.29,48.88 355.29,50.73 354.21,51.81 352.82,51.81 352.31,52.31 352.31,59.71 351.5,60.52 351.5,65.87 351.12,66.25 351.12,70.59 v1(351.54,71.01)
  IN3 w0.127: v1(280.88,23.69) 282.45,23.69 284.28,25.52 286.39,25.52 v1(286.8,25.11) 287.26,25.57 289.01,25.57 290.33,26.89 302.74,26.89 307.92,21.71 309.63,21.71 311.56,19.78 317.81,19.78 v1(317.86,19.83) 318.24,19.45 320.38,19.45 323.96,23.03 325.5,23.03 325.7,22.82 328.92,22.82 330.57,24.47 333,24.47 333.62,25.1 335.97,25.1 336.58,25.71 339.74,25.71 v1(340.1,26.07)
  BOTTOM w0.127: v1(351.54,71.01) 351.21,71.34 R4117.1 ; v1(286.8,25.11) 286.8,25.62 287.43,26.25 287.43,27.31 288.45,28.33 289.49,29.36 289.49,34.44 288.96,34.97 288.96,37.05 286.93,39.08 286.93,47.09 v1(286.51,47.51) ; CON5100.50 316.55,39.4 316.92,39.78 316.92,41.59 v1(317.07,41.75) ; v1(32.57,71.29) 32.04,70.76 U7301.1 ; CON5101.50 317.31,16.4 317.53,16.63 317.53,19.5 v1(317.86,19.83) ; v3(266.2,82.72) 266.66,82.25 267.28,82.25 268.74,80.79 268.94,80.79 269.6,80.13 270.05,80.13 274.94,75.24 276.11,75.24 279.63,71.72 281.25,71.72 282.2,70.77 282.2,68.29 284.49,66 286.04,66 289.85,62.19 289.85,57.74 289.69,57.59 289.69,57.07 289.18,56.55 289.18,56.18 287.86,54.86 287.27,54.28 287.27,53.63 285.99,52.35 285.94,52.35 v1(285.32,51.73) ; R4208.1 343.19,19.98 343.19,20.82 342.17,21.84 340.9,21.84 340.63,22.11 U4200.1 340.32,23.08 340.32,25.85 v1(340.1,26.07) ; Q6500.5 302.8,43.65 302.93,43.78 302.93,44.41 303.27,44.76 304.79,44.76 304.96,44.92 305.8,44.92 305.85,44.97 v1(305.92,44.97) ; R4000.2 29.88,118.07 29.88,116.74 29.18,116.04 29.18,113.44 27.59,111.85 v1(24.57,111.85)
PCI_PLTRST#_R: length 6.1
  BOTTOM w0.114: CON4201.50 343,16.95 342.16,17.78 R4213.2 R4208.2 342.68,20.25 v1(342.68,20.54) 342.25,20.54 341.93,20.85 U4200.4
PCIE_CLKREQ9#: length 10.7
  TOP w0.114: v1(260.38,60.06) 260.38,59.15 261.7,57.83 261.7,57.29 261.32,56.91 v1(261.02,56.91)
  BOTTOM w0.089: U9002.AF48 260.28,60.22 260.38,60.12
  BOTTOM w0.102: 260.38,60.12 v1(260.38,60.06)
  BOTTOM w0.114: v1(261.02,56.91) 261.14,56.78 261.14,55.96 264.04,53.06 R9176.1
PCIE_CLKREQ10#: length 4.1
  TOP w0.114: R9173.1 v1(255.81,59.78) 255.81,61.58 v1(256.14,61.92)
  BOTTOM w0.114: U9002.AC41 v1(256.14,61.92)
PCIE_CLKREQ11#: length 1.8
  TOP w0.114: v1(255.53,62.19) 255.06,61.72 R9177.1
  BOTTOM w0.114: U9002.AC39 255.79,62.45 v1(255.53,62.19)
PCIE_CLKREQ12#: length 13
  TOP w0.114: R9179.1 262.39,54.85 261.14,56.1 260.9,56.1 260.03,56.98 260.03,57.46 259.24,58.25 259.24,60.34 258.66,60.91 258.66,62 257.27,63.4 v1(257.08,63.4) 256.54,63.4 v1(256.42,63.27)
  BOTTOM w0.114: U9002.AE39 v1(256.42,63.27)
PCIE_CLKREQ13#: length 6.5
  BOTTOM w0.102: 259.02,58.68 258.59,59.11 U9002.AB48
  BOTTOM w0.114: 259.02,58.68 259.18,58.52 259.18,57.5 258.22,56.55 258.22,53.81 R9181.1
PCIE_CLKREQ14#: length 8.6
  TOP w0.114: v1(257.19,60.84) 256.7,60.34 256.7,59.32 257.46,58.56 257.46,57.24 v1(257.84,56.86) 258.1,56.61 258.1,55.34 R9183.1
  BOTTOM w0.114: U9002.AC44 v1(257.19,60.84)
PCIE_CLKREQ15#: length 3.6
  TOP w0.114: R9185.1 256.47,58.88 256.47,61.17 v1(256.68,61.38)
  BOTTOM w0.114: U9002.AC43 v1(256.68,61.38)
PCIE_CLKREQ_L: length 3.2
  BOTTOM w0.114: U4100.30 348.21,73.68 348.39,73.5 349.66,73.5 349.92,73.24 349.92,72.73 R4116.1
PCIE_RBIAS: length 1
  TOP w0.114: R8001.1 342.88,113.25 v3(342.91,113.28)
  BOTTOM w0.114: U8001.N16 343.21,113.57 v3(342.91,113.28)
PCIE_RXN3_CARD: length 267.6
  IN3 w0.089: v1(35.49,67.68) 35.57,67.68 35.73,67.52 35.73,67.12 36.04,66.81 36.04,64.4 37.58,62.85 39.31,62.85 43.34,58.83 45.69,58.83 48.91,55.6 50.35,55.6 52.84,53.11 59.01,53.11 60.65,51.48 78.93,51.48 79.34,51.07 89.76,51.07 89.95,50.88 94.34,50.88 100.59,44.63 100.59,38.9 104.74,34.76 104.74,33.34 106.73,31.34 107.77,31.34 117.3,21.81 158.92,21.81 159.83,22.73 170.62,22.73 171.27,23.37 179.51,23.37 180.45,24.31 186.91,24.31 187.5,24.89 190.24,24.89 190.78,25.43 203.06,25.43 203.59,25.96 211.34,25.96 213.04,27.66 229.74,27.66 236.56,34.48 236.56,37.41 237.48,38.34 237.48,50.17 238.51,51.2 238.51,52.37 240.13,53.99 240.13,56.03 241.71,57.62 241.71,59.65 243.31,61.25 243.31,62.52 245.14,64.35 v1(245.14,65.32)
  BOTTOM w0.102: C7319.1 34.66,67.63 34.78,67.75 35.42,67.75 v1(35.49,67.68) ; v1(245.14,65.32) 245,65.46 U9002.K18
PCIE_RXN4_WWAN: length 127.6
  IN1 w0.076: v1(245.02,66.66) 245.12,66.66 246.96,64.82 247.97,64.82 250.13,62.66 252.03,62.66 256.32,58.38 256.32,55.97 258.72,53.57 258.72,52.52 260.03,51.21 260.58,51.21 261.72,50.08 261.72,49.07 262.69,48.1 263.28,48.1 266.71,44.67 267.39,44.67 268.02,44.03 270.4,44.03 272.62,41.82 278.35,41.82 280.04,40.12 285.5,40.12 287.28,38.34 293.45,38.34 294.1,37.7 301.28,37.7 301.72,37.26 304.71,37.26 306.49,35.49 309.84,35.49 315.27,30.06 317.81,30.06 323.81,24.06 325.32,24.06 328.29,21.08 328.29,19.33 331.02,16.6 331.02,13.55 v1(331.4,13.17)
  BOTTOM w0.102: CON4201.41 340.75,9.53 340.9,9.68 340.9,10.54 340.54,10.89 336.49,10.89 333.62,13.76 332.17,13.76 331.88,13.48 331.71,13.48 v1(331.4,13.17) ; v1(245.02,66.66) 245.44,66.66 U9002.N18
PCIE_RXN5_TBT: length 209.6
  IN4 w0.076: v1(336.46,108.29) 336.19,108.03 336.02,108.03 335.82,107.83 335.82,102.91 335.32,102.41 335.32,87.86 336.46,86.73 336.46,82.28 340.17,78.56 346.7,78.56 349.25,76.01 349.86,76.01 351.35,74.51 351.35,72.83 352.53,71.65 352.53,63.02 354.86,60.7 354.86,57.78 356.04,56.6 356.04,50.71 357.37,49.37 357.37,46.18 355.81,44.62 354.08,44.62 353.4,43.94 352.06,43.94 351.29,43.17 351.29,42.6 350.78,42.09 343.42,42.09 342.56,41.23 338.75,41.23 337.95,42.03 332.16,42.03 331.78,41.65 317.96,41.65 317.27,42.34 313.89,42.34 313.44,42.79 306.38,42.79 305.2,41.61 299.38,41.61 298.65,42.34 295.52,42.34 295.23,42.05 288.4,42.05 287.94,42.51 287.4,42.51 285.9,44.01 284.21,44.01 283.86,44.35 276.19,44.35 274.07,46.47 270.97,46.47 270.37,45.87 259.21,45.87 258.37,46.71 257.58,46.71 255.07,49.21 254.51,49.21 253.4,50.33 251.64,50.33 249.09,52.88 249.09,55.05 245.07,59.07 245.07,60.34 243.73,61.68 243.73,62.46 244.35,63.07 244.52,63.07 244.63,62.96 v1(244.63,62.83)
  BOTTOM w0.102: C8001.2 v1(336.46,108.29) ; v1(244.63,62.83) 244.74,62.93 244.74,63.33 244.47,63.6 244.3,63.6 244.15,63.44 244.15,63.28 244,63.13 243.69,63.13 U9002.F20
PCIE_RXN5_TBT_C: length 6.1
  BOTTOM w0.076: C8001.1 337.7,108.04 337.91,108.04 338.2,108.32 338.84,108.97 v5(338.84,110.07) 338.84,111.15 339.28,111.59 339.82,111.59 339.96,111.72 340.32,111.72 U8001.V22
PCIE_RXN6_TBT: length 223.4
  IN4 w0.076: v1(246.06,64.12) 245.74,64.12 245.57,64.3 244.73,64.3 244.27,63.84 243.75,63.84 242.89,62.99 242.28,62.99 238.63,59.34 238.63,58.54 248.72,48.46 249.98,48.46 253.33,45.1 255.91,45.1 256.94,44.07 266.46,44.07 267.39,43.14 272.7,43.14 273.65,42.19 279.75,42.19 279.85,42.09 285.21,42.09 286.73,40.57 287.21,40.57 287.68,40.1 289.49,40.1 289.89,39.69 306.08,39.69 306.7,40.31 315.3,40.31 316.35,39.27 319.81,39.27 320.13,39.59 321.92,39.59 322.63,38.88 331.94,38.88 332.73,39.68 336.89,39.68 337.87,38.7 344.53,38.7 345.24,37.99 349.66,37.99 350.19,38.52 350.35,38.52 351.16,39.33 351.16,40.07 352.2,41.11 353.73,41.11 354.87,42.25 356.27,42.25 359.89,45.87 359.89,56.42 359.71,56.59 359.71,58.48 357.66,60.52 357.66,61.36 355.8,63.23 355.8,65.58 354.36,67.02 354.36,72.37 353.73,73.01 353.73,75.33 352.5,76.56 351.92,76.56 341.86,86.62 341.18,86.62 338.61,89.18 338.61,89.87 337.53,90.95 337.53,102.03 338.27,102.77 338.27,108.87 337.64,109.51 337.64,110.54 337.06,111.11 336.68,111.11 v1(336.46,111.34)
  BOTTOM w0.102: C8003.2 v1(336.46,111.34) ; U9002.K21 245.83,64.12 v1(246.06,64.12)
PCIE_RXN6_TBT_C: length 5.2
  BOTTOM w0.076: C8003.1 337.44,111.14 337.55,111.04 337.71,111.04 337.85,111.18 337.85,111.75 338.08,111.98 338.08,112.68 338.46,113.05 338.95,113.54 340.25,113.54 340.46,113.33 U8001.P22
PCIE_RXN7_TBT: length 212.4
  IN4 w0.076: v1(336.46,113.63) 336.2,113.88 335.62,113.88 335.35,113.61 335.35,103.02 334.94,102.61 334.94,87.56 335.95,86.56 335.95,82.13 339.9,78.18 346.51,78.18 350.96,73.74 350.96,72.69 352.15,71.49 352.15,66.25 351.89,65.99 351.89,60.97 353.38,59.47 353.38,58.72 355.66,56.44 355.66,50.48 356.9,49.24 356.9,46.47 355.43,45 353.93,45 353.46,44.54 352.1,44.54 350.45,42.89 349.45,42.89 349.35,42.99 344.18,42.99 343.82,42.64 338.61,42.64 338.11,43.14 336.65,43.14 335.93,42.42 331.95,42.42 331.76,42.23 317.92,42.23 317.42,42.72 315.3,42.72 314.8,43.23 306.04,43.23 304.82,42.01 301.03,42.01 300.17,42.88 295.27,42.88 294.87,42.47 288.63,42.47 288.13,42.98 287.47,42.98 286.06,44.39 284.38,44.39 284.04,44.73 276.95,44.73 274.79,46.89 270.67,46.89 270.05,46.27 265.7,46.27 265.23,46.74 258.92,46.74 258.55,47.11 257.84,47.11 254.81,50.13 254.52,50.13 254.02,50.63 254.02,50.82 252.3,52.54 250.8,52.54 249.47,53.87 249.47,55.27 245.45,59.29 245.45,60.62 244.63,61.43 244.63,62.07 245.89,63.32 246.35,63.32 246.53,63.15 v1(246.79,63.15)
  BOTTOM w0.102: C8005.2 v1(336.46,113.63) ; U9002.L24 246.45,63.48 v1(246.79,63.15)
PCIE_RXN7_TBT_C: length 4.2
  BOTTOM w0.076: C8005.1 338.23,114.42 338.23,114.64 338.91,115.32 339.46,115.32 339.86,114.92 340.29,114.92 340.54,115.17 U8001.K22
PCIE_RXN8_TBT: length 209.9
  IN4 w0.076: v1(336.46,116.68) 336.12,117.01 335.52,117.01 334.72,116.21 334.72,103.25 334.4,102.94 334.4,87.24 335.31,86.32 335.31,82 339.67,77.64 345.57,77.64 346.75,76.46 347.47,76.46 350.06,73.87 350.06,72.81 351.05,71.82 351.05,68.07 351.34,67.78 351.34,60.74 352.2,59.88 352.2,59.12 354.65,56.67 354.65,49.62 355.81,48.47 355.81,46.29 355.14,45.62 353.77,45.62 353.57,45.42 352.17,45.42 350.67,43.92 342.31,43.92 342.17,43.78 336.05,43.78 335.71,43.44 332.15,43.44 331.55,42.83 318.09,42.83 317.65,43.27 315.56,43.27 314.97,43.87 305.72,43.87 304.71,42.86 300.97,42.86 300.41,43.42 294.93,43.42 294.52,43.02 288.98,43.02 288.47,43.52 287.71,43.52 286.3,44.93 284.78,44.93 284.44,45.28 277.18,45.28 274.98,47.47 269.26,47.47 268.64,48.1 268.11,48.1 267.85,47.84 266.71,47.84 266.15,47.28 260.25,47.28 259.6,47.93 259.04,47.93 258.77,47.67 258.17,47.67 255.52,50.31 255.52,50.93 252.94,53.51 252.94,54.4 252.75,54.59 252.23,54.59 251.89,54.93 250.6,54.93 249.79,55.74 249.79,55.74 245.99,59.53 245.99,61.34 245.54,61.8 v1(245.41,61.8)
  BOTTOM w0.102: v1(245.41,61.8) 245.05,61.8 U9002.F24 ; C8007.2 v1(336.46,116.68)
PCIE_RXN8_TBT_C: length 3.5
  BOTTOM w0.076: C8007.1 337.7,116.93 338.97,116.93 339.12,117.09 339.6,117.09 339.88,116.8 340.26,116.8 340.47,117.01 U8001.F22
PCIE_RXN9_SSD: length 96
  IN3 w0.089: v1(317.41,32.98) 317.65,33.23 317.65,33.47 317.52,33.59 310.8,33.59 308.85,35.54 305.82,35.54 304.5,36.86 302.57,36.86 301.37,38.05 300.64,38.05 299.42,39.27 298.28,39.27 297.77,39.78 296.15,39.78 295.89,39.52 289.64,39.52 288.89,40.27 278.04,40.27 277.02,41.29 276.57,41.75 276.18,42.14 273.43,42.14 272.3,43.27 270.42,43.27 270.06,43.64 266.68,43.64 266.2,44.12 261.48,44.12 261.03,43.66 257.47,43.66 255.94,45.19 253.38,45.19 250.03,48.53 250.03,48.78 248.08,50.74 248.08,58.52 248.33,58.78 248.95,58.78 v1(249.15,58.98)
  BOTTOM w0.102: U9002.G36 249.47,58.66 v1(249.15,58.98) ; CON5100.5 322.16,28.15 322.01,28.3 321.17,28.3 319.82,29.65 319.82,30.32 317.68,32.45 317.68,32.7 v1(317.41,32.98)
PCIE_RXN10_SSD: length 93.5
  IN3 w0.089: v1(316.85,35.8) 316.85,35.57 316.73,35.46 310.94,35.46 309.51,36.9 306.76,36.9 305.21,38.44 305.21,38.7 303.83,40.08 301.42,40.08 300.26,41.24 298.9,41.24 298.31,41.84 295,41.84 294.19,41.02 290.57,41.02 289.77,41.82 285.78,41.82 285.4,42.2 284.84,42.2 284.27,41.63 279.44,41.63 276.12,44.96 274.85,44.96 274.33,45.47 259.61,45.47 255.39,49.7 253.35,49.7 252.67,50.38 251.65,50.38 249.79,52.25 249.79,56.19 250.58,56.98 250.58,58.5 250.47,58.6 250.47,59.47 v1(250.45,59.5)
  BOTTOM w0.102: U9002.K37 250.68,59.03 250.45,59.26 v1(250.45,59.5) ; v1(316.85,35.8) 317.02,35.63 317.02,35.41 316.69,35.08 316.69,33.92 317.12,33.49 318.77,33.49 321.11,31.15 CON5100.17
PCIE_RXN11_SSD: length 90.5
  IN3 w0.089: v1(320.45,34.76) 320.24,34.98 319.41,34.98 319.11,34.67 310.56,34.67 309.11,36.12 306.25,36.12 304.82,37.56 304.32,37.56 302.66,39.22 300.5,39.22 299.31,40.41 295.37,40.41 295.08,40.12 290.2,40.12 289.47,40.86 279.12,40.86 276.7,43.27 273.34,43.27 272.74,43.87 270.79,43.87 269.96,44.7 258.32,44.7 256.95,46.06 256.95,46.45 255.43,47.97 251.57,47.97 250.91,48.63 250.91,48.77 248.83,50.86 248.83,57.04 249.05,57.27 249.37,57.58 249.58,57.58 v1(249.94,57.95)
  BOTTOM w0.102: U9002.G38 v1(249.94,57.95) ; v1(320.45,34.76) 320.65,34.56 320.65,34.31 320.94,34.03 321.88,34.03 322.01,34.15 CON5100.29
PCIE_RXN12_SSD: length 88.6
  IN3 w0.089: v1(320.76,35.7) 320.76,36.04 320.68,36.12 318.56,36.12 318.47,36.22 310.75,36.22 309.1,37.87 307.17,37.87 304.23,40.81 301.31,40.81 300.44,41.68 299.12,41.68 298.56,42.24 285.93,42.24 285.58,42.6 284.63,42.6 284.05,42.03 279.6,42.03 276.19,45.44 274.81,45.44 274.38,45.87 266.44,45.87 265.66,46.65 259.06,46.65 257.22,48.48 257.22,49.12 254.04,52.3 251.01,52.3 250.29,53.02 250.29,54.24 251.93,55.89 251.93,56.45 251.63,56.75 251.4,56.75 251.24,56.58 251.24,56.35 251.33,56.26 v1(251.44,56.26)
  BOTTOM w0.102: CON5100.43 321.31,37.65 320.99,37.33 320.99,35.93 v1(320.76,35.7) ; U9002.H42 v1(251.44,56.26)
PCIE_RXN13_LAN: length 325.9
  IN1 w0.076: v1(28.23,116.17) 27.95,116.45 27.74,116.45 27.58,116.28 27.58,113.26 28.48,112.36 28.48,97.58 29.25,96.81 29.25,93.8 30.61,92.45 30.61,85.21 37.56,78.26 37.56,75.1 37.26,74.8 37.26,73.74 42.71,68.29 45.08,68.29 46.18,67.19 52.42,67.19 57.06,62.55 57.06,61.64 60.05,58.64 60.05,54.73 60.53,54.25 63.66,54.25 63.8,54.11 67.51,54.11 71.28,57.88 73.69,57.88 77.63,53.94 89.98,53.94 90.99,52.92 93.64,52.92 101.89,44.67 102.78,44.67 103.82,43.63 103.82,36.62 105.02,35.41 105.02,32.21 110.89,26.34 136.85,26.34 138.21,24.98 176.56,24.98 177.29,24.26 185.95,24.26 186.79,25.1 189.38,25.1 189.7,25.41 205.52,25.41 207.48,23.46 213.67,23.46 217.61,27.4 227.24,27.4 232.4,32.56 232.4,36.85 231.64,37.61 231.64,51.67 232.53,52.55 234.69,52.55 237.77,49.48 240.07,49.48 240.8,48.76 241.74,48.76 242.35,49.37 243.89,49.37 245.54,51.02 247.56,51.02 250.26,53.72 250.73,53.72 v1(251.13,54.13)
  BOTTOM w0.102: C4001.1 27.31,117.46 27.31,117.11 28.23,116.19 v1(28.23,116.17) ; U9002.C45 251.35,53.92
  BOTTOM w0.114: 251.35,53.92 v1(251.13,54.13)
PCIE_RXN13_LAN_C: length 3.3
  BOTTOM w0.102: U4000.39 27.34,120.31 27.44,120.21 27.44,119.88 v1(26.91,119.34) 27.29,119.34 27.44,119.19 27.44,118.82 C4001.2
PCIE_RXN14_WLAN: length 142.3
  IN3 w0.089: v1(251.87,54) 252.07,53.81 252.07,53.52 252.44,53.14 254.94,53.14 258.79,49.29 258.79,48.65 260.22,47.23 265.95,47.23 266.69,46.48 270.95,46.48 271.14,46.67 275.16,46.67 275.76,46.06 276.39,46.06 279.84,42.61 283.79,42.61 284.39,43.21 285.8,43.21 286.11,42.9 300.23,42.9 301.74,41.39 304.79,41.39 307.04,39.14 308.65,39.14 310.59,37.21 321.35,37.21 324.04,34.51 330.87,34.51 332.96,36.6 335.71,36.6 339.44,40.34 342.05,40.34 343,41.29 343,43.45 346.38,46.83 351.33,46.83 352.2,47.7 352.2,59.78 352.63,60.21 352.63,68.37 352.19,68.81 351.79,68.81 v1(351.57,69.03)
  BOTTOM w0.102: TP4100.1 352.33,68.87 352.23,68.77 351.83,68.77 v1(351.57,69.03) 351.43,68.9 351.09,68.9 C4111.1
  BOTTOM w0.114: U9002.D46 252.04,53.24 252.09,53.24 252.21,53.36 252.21,53.86 252.07,54 v1(251.87,54)
PCIE_RXN14_WLAN_C: length 3.6
  BOTTOM w0.102: C4111.2 349.91,69.04 349.76,68.9 349.54,68.9 349.46,68.98 349.46,69.67 348.59,70.53 348.28,70.53 348.13,70.68 U4100.36
PCIE_RXN17_SSD: length 95.6
  IN1 w0.076: v1(252.29,57.02) 252.29,56.74 251.91,56.36 251.91,55.43 252.87,54.46 252.87,51.82 259.55,45.14 260.67,45.14 264.13,41.68 266.16,41.68 266.77,41.07 268.47,41.07 269.65,39.9 270.9,39.9 271.33,39.47 276.63,39.47 278.78,37.31 281.78,37.31 282.61,36.49 285.8,36.49 286.21,36.08 288.8,36.08 289.38,35.51 295.58,35.51 295.94,35.14 298.63,35.14 299.05,34.72 303.47,34.72 307.12,31.08 308.39,31.08 313.09,26.37 313.09,25.26 317.21,21.13 317.8,21.13 320.03,18.9 320.03,17.99 319.94,17.9 319.79,17.9 v1(319.56,18.12)
  BOTTOM w0.102: v1(319.56,18.12) 321.47,16.22 321.47,14.7 321.66,14.5 322.41,14.5 322.56,14.65 CON5101.43 ; U9002.K43 252.82,57.02 v1(252.29,57.02)
PCIE_RXN18_SSD: length 108.3
  IN1 w0.076: v1(325.15,11.04) 325.34,11.23 325.34,11.56 325.81,12.03 327.46,12.03 328.21,12.78 328.21,15.92 326,18.12 325.81,18.12 322.57,21.36 322.57,23.14 317.81,27.9 314.63,27.9 308.32,34.22 305.91,34.22 304.09,36.03 301.31,36.03 300.74,36.6 289.93,36.6 289.31,37.23 286.72,37.23 285.54,38.41 279.24,38.41 276.98,40.66 271.8,40.66 271.42,41.05 271.09,41.05 269.96,42.18 267.36,42.18 265.34,44.2 263.41,44.2 259.11,48.5 259.11,49.11 258.36,49.86 257.85,49.86 254.67,53.05 254.67,58.14 253.56,59.24 253.06,59.24 252.96,59.14 252.86,59.14 252.74,59.01 252.74,58.87 252.84,58.77 v1(253.08,58.77)
  BOTTOM w0.102: CON5101.29 324.32,11.15 324.47,11.3 324.47,11.34 324.57,11.45 325.09,11.45 325.23,11.31 325.23,11.11 v1(325.15,11.04) ; U9002.P41 v1(253.08,58.77)
PCIE_RXN19_SSD: length 105.7
  IN1 w0.076: v1(253.57,57.3) 253.37,57.5 253.16,57.5 253.01,57.36 253.01,56.7 253.78,55.93 253.78,52.8 256.61,49.96 256.61,49.31 259.18,46.74 260.2,46.74 263.11,43.82 265.09,43.82 267.13,41.79 268.78,41.79 269.96,40.61 271.28,40.61 271.7,40.19 276.92,40.19 279.08,38.03 285.29,38.03 286.49,36.83 289.07,36.83 289.68,36.22 300.58,36.22 301.28,35.52 303.94,35.52 307.25,32.22 309.75,32.22 316.95,25.02 319.38,25.02 320.96,23.44 320.96,16.75 320.31,16.09 319.77,16.09 v1(319.56,15.89)
  BOTTOM w0.102: v1(319.56,15.89) 319.77,16.09 320.03,16.09 320.33,15.8 320.33,14.52 320.88,13.96 320.88,11.75 320.33,11.19 320.33,10.17 320.76,9.73 320.76,9.02 321.48,8.3 322.41,8.3 322.56,8.15 CON5101.17 ; U9002.M44 v1(253.57,57.3)
PCIE_RXN20_SSD: length 115.9
  IN1 w0.076: v1(252.45,61.32) 252.93,60.84 253.09,60.84 255.47,58.47 255.47,55.02 255.81,54.68 256.62,54.68 258.25,53.05 258.25,51.43 258.62,51.06 259.02,51.06 261.27,48.8 261.27,48.08 264.43,44.91 265.7,44.91 267.73,42.89 270.26,42.89 271.27,41.87 271.67,41.87 272.17,41.38 277.27,41.38 278.91,39.74 285.23,39.74 287.03,37.94 289.62,37.94 290.24,37.31 301.03,37.31 301.52,36.83 304.54,36.83 306.32,35.05 308.58,35.05 314.68,28.96 317.98,28.96 323.5,23.44 323.5,21.83 325.01,20.32 326.51,20.32 328.92,17.91 328.92,9.96 328.45,9.49 328.45,7.82 326.2,5.56 325.42,5.56 v1(325.03,5.17)
  BOTTOM w0.102: U9002.R35 v1(252.45,61.32) ; CON5101.5 324.25,5.15 324.47,5.37 324.83,5.37 v1(325.03,5.17)
PCIE_RXP3_CARD: length 267.6
  IN3 w0.089: v1(244.45,64.87) 244.62,65.04 244.81,65.04 244.95,64.9 244.95,64.43 243.12,62.6 243.12,61.33 241.52,59.73 241.52,57.7 239.94,56.11 239.94,54.07 238.32,52.45 238.32,51.27 237.29,50.25 237.29,38.42 236.37,37.49 236.37,34.56 229.66,27.85 212.96,27.85 211.26,26.15 203.51,26.15 202.98,25.62 190.7,25.62 190.16,25.08 187.42,25.08 186.84,24.5 180.37,24.5 179.43,23.56 171.19,23.56 170.55,22.92 159.75,22.92 158.84,22 117.38,22 107.85,31.53 106.81,31.53 104.93,33.42 104.93,34.83 100.78,38.98 100.78,44.71 94.42,51.07 90.03,51.07 89.84,51.26 79.42,51.26 79.01,51.67 60.73,51.67 59.09,53.3 52.91,53.3 50.43,55.79 48.99,55.79 45.77,59.02 43.42,59.02 39.39,63.04 37.66,63.04 36.23,64.48 36.23,66.89 35.92,67.2 35.92,67.88 v1(35.49,68.32)
  BOTTOM w0.102: C7321.1 34.92,67.95 35.13,67.95 v1(35.49,68.32) ; v1(244.45,64.87) 244.4,64.87 244.17,65.11 U9002.J18
PCIE_RXP4_WWAN: length 127.6
  IN1 w0.076: v1(331.4,13.81) 331.18,14.02 331.18,16.66 328.45,19.39 328.45,21.15 325.39,24.22 323.88,24.22 317.87,30.23 315.33,30.23 309.91,35.65 306.56,35.65 304.78,37.43 301.78,37.43 301.35,37.86 294.16,37.86 293.52,38.51 287.35,38.51 285.57,40.29 280.11,40.29 278.42,41.98 272.69,41.98 270.47,44.2 268.09,44.2 267.46,44.83 266.78,44.83 263.35,48.26 262.76,48.26 261.88,49.14 261.88,50.14 260.65,51.37 260.1,51.37 258.88,52.59 258.88,53.64 256.48,56.04 256.48,58.45 252.1,62.83 250.2,62.83 248.04,64.99 247.03,64.99 245.47,66.54 245.47,67.04 v1(245.51,67.07)
  BOTTOM w0.102: v1(331.4,13.81) 331.53,13.68 331.8,13.68 332.08,13.96 333.71,13.96 336.58,11.1 340.63,11.1 341.1,10.62 341.1,9.68 341.25,9.53 CON4201.43 ; v1(245.51,67.07) 245.74,66.84 245.88,66.84 246.11,67.07
PCIE_RXP5_TBT: length 209.5
  IN4 w0.076: v1(336.46,107.53) 336.46,107.75 336.34,107.86 336.09,107.86 335.99,107.76 335.99,102.84 335.49,102.35 335.49,87.92 336.62,86.79 336.62,82.35 340.24,78.73 346.77,78.73 349.32,76.17 349.92,76.17 351.52,74.58 351.52,72.9 352.7,71.72 352.7,63.09 355.02,60.76 355.02,57.85 356.2,56.67 356.2,50.78 357.54,49.44 357.54,46.11 355.88,44.45 354.15,44.45 353.47,43.78 352.12,43.78 351.45,43.11 351.45,42.53 350.85,41.93 343.49,41.93 342.63,41.06 338.69,41.06 337.89,41.86 332.23,41.86 331.85,41.48 317.9,41.48 317.2,42.18 313.82,42.18 313.37,42.62 306.45,42.62 305.27,41.44 299.32,41.44 298.58,42.18 295.59,42.18 295.3,41.89 288.33,41.89 287.87,42.34 287.33,42.34 285.83,43.84 284.14,43.84 283.8,44.19 276.12,44.19 274,46.31 271.04,46.31 270.44,45.71 259.14,45.71 258.3,46.55 257.51,46.55 255,49.05 254.45,49.05 253.33,50.17 251.58,50.17 248.93,52.82 248.93,54.98 244.9,59.01 244.9,60.28 243.57,61.61 243.57,62.53 244.28,63.24 245.12,63.24 v1(245.14,63.21)
  BOTTOM w0.102: C8000.2 v1(336.46,107.53) ; v1(245.14,63.21) 244.55,63.8 U9002.G20
PCIE_RXP5_TBT_C: length 6.1
  BOTTOM w0.076: C8000.1 337.8,107.89 337.98,107.89 v5(338.56,108.47) 338.95,108.86 338.96,108.87 339,108.91 339,111.09 339.34,111.43 339.63,111.43 339.8,111.27 340.2,111.27 340.27,111.33 340.27,111.42 340.2,111.49 U8001.V23
PCIE_RXP6_TBT: length 223.4
  IN4 w0.076: v1(336.46,110.58) 336.46,110.8 336.61,110.95 337,110.95 337.47,110.47 337.47,109.44 338.11,108.8 338.11,102.83 337.37,102.1 337.37,90.88 338.45,89.8 338.45,89.11 341.11,86.45 341.79,86.45 351.85,76.39 352.43,76.39 353.56,75.26 353.56,72.94 354.2,72.3 354.2,66.95 355.63,65.52 355.63,63.16 357.5,61.3 357.5,60.45 359.54,58.41 359.54,56.52 359.72,56.35 359.72,45.94 356.2,42.42 354.8,42.42 353.66,41.28 352.13,41.28 351,40.14 351,39.4 350.28,38.69 350.12,38.69 349.59,38.15 345.31,38.15 344.6,38.86 337.94,38.86 336.96,39.84 332.67,39.84 331.87,39.04 322.7,39.04 321.99,39.75 320.06,39.75 319.74,39.44 316.41,39.44 315.37,40.48 306.63,40.48 306.01,39.85 289.96,39.85 289.55,40.26 287.75,40.26 287.28,40.73 286.8,40.73 285.27,42.25 279.92,42.25 279.82,42.36 273.72,42.36 272.77,43.31 267.46,43.31 266.53,44.24 257.01,44.24 255.98,45.26 253.4,45.26 250.04,48.62 248.78,48.62 238.79,58.61 238.79,59.27 242.35,62.83 242.96,62.83 243.81,63.68 244.34,63.68 244.8,64.14 245.5,64.14 245.62,64.01 245.62,63.79 v1(245.55,63.72)
  BOTTOM w0.102: v1(336.46,110.58) 336.46,110.78 336.63,110.96 336.86,110.96 336.99,110.83 C8002.2 ; v1(245.55,63.72) 245.55,64.1 245.4,64.25 244.78,64.25 U9002.J21
PCIE_RXP6_TBT_C: length 5.2
  BOTTOM w0.076: C8002.1 337.44,110.81 337.52,110.89 337.78,110.89 338,111.11 338,111.69 338.23,111.91 338.23,112.61 339.01,113.39 339.56,113.39 339.86,113.1 340.16,113.1 340.24,113.17 340.24,113.25 340.16,113.33 U8001.P23
PCIE_RXP7_TBT: length 212.4
  IN4 w0.076: v1(246.29,62.7) 246.44,62.85 246.44,63.01 246.29,63.16 245.96,63.16 244.8,62 244.8,61.5 245.61,60.69 245.61,59.36 249.64,55.34 249.64,53.94 250.87,52.71 252.37,52.71 254.18,50.89 254.18,50.7 254.59,50.29 254.88,50.29 257.91,47.27 258.62,47.27 258.99,46.9 265.3,46.9 265.77,46.43 269.98,46.43 270.6,47.06 274.86,47.06 277.02,44.9 284.11,44.9 284.45,44.55 286.12,44.55 287.53,43.14 288.2,43.14 288.7,42.64 294.8,42.64 295.21,43.04 300.23,43.04 301.1,42.18 304.76,42.18 305.98,43.4 314.87,43.4 315.37,42.89 317.49,42.89 317.99,42.39 331.69,42.39 331.88,42.59 335.86,42.59 336.58,43.31 338.17,43.31 338.68,42.8 343.75,42.8 344.11,43.16 349.42,43.16 349.52,43.06 350.38,43.06 352.03,44.7 353.4,44.7 353.86,45.17 355.36,45.17 356.74,46.54 356.74,49.17 355.49,50.42 355.49,56.37 353.22,58.65 353.22,59.4 351.72,60.9 351.72,66.05 351.99,66.32 351.99,71.42 350.79,72.62 350.79,73.67 346.45,78.02 339.83,78.02 335.78,82.06 335.78,86.49 334.78,87.49 334.78,102.68 335.19,103.09 335.19,113.68 335.55,114.05 336.33,114.05 336.46,114.18 v1(336.46,114.39)
  BOTTOM w0.102: v1(336.46,114.39) C8004.2 ; U9002.J24 246.02,63.19 246.2,63.19 246.41,62.98 246.41,62.83 v1(246.29,62.7)
PCIE_RXP7_TBT_C: length 4.2
  BOTTOM w0.076: U8001.K23 340.22,115.17 340.29,115.24 340.29,115.33 340.22,115.4 339.6,115.4 339.52,115.47 338.85,115.47 338.08,114.71 338.08,114.48 337.66,114.06 337.55,114.06 337.44,114.17 C8004.1
PCIE_RXP8_TBT: length 209.9
  IN4 w0.076: v1(245.84,62.26) 245.84,61.73 246.16,61.41 246.16,59.6 249.95,55.81 249.95,55.81 250.66,55.09 251.96,55.09 252.3,54.75 252.82,54.75 253.1,54.46 253.1,53.58 255.68,51 255.68,50.38 258.24,47.83 258.71,47.83 258.97,48.1 259.67,48.1 260.32,47.45 266.08,47.45 266.64,48.01 267.79,48.01 268.04,48.26 268.71,48.26 269.33,47.64 275.05,47.64 277.25,45.44 284.5,45.44 284.85,45.1 286.37,45.1 287.78,43.69 288.54,43.69 289.05,43.18 294.46,43.18 294.86,43.59 300.48,43.59 301.03,43.03 304.65,43.03 305.65,44.03 315.04,44.03 315.63,43.44 317.72,43.44 318.16,42.99 331.48,42.99 332.09,43.6 335.64,43.6 335.99,43.94 342.1,43.94 342.24,44.08 350.6,44.08 352.11,45.59 353.5,45.59 353.7,45.79 355.07,45.79 355.64,46.36 355.64,48.4 354.49,49.55 354.49,56.6 352.04,59.06 352.04,59.81 351.17,60.67 351.17,67.71 350.88,68.01 350.88,71.76 349.89,72.75 349.89,73.8 347.4,76.29 346.69,76.29 345.51,77.47 339.6,77.47 335.15,81.93 335.15,86.26 334.23,87.17 334.23,103 334.55,103.32 334.55,116.28 335.45,117.17 336.33,117.17 336.46,117.3 v1(336.46,117.44)
  BOTTOM w0.102: U9002.G24 245.67,62.26 v1(245.84,62.26) ; C8006.2 v1(336.46,117.44)
PCIE_RXP8_TBT_C: length 3.5
  BOTTOM w0.076: U8001.F23 340.22,117.01 340.29,117.08 340.29,117.18 340.24,117.24 339.06,117.24 338.91,117.09 337.65,117.09 337.44,117.29 C8006.1
PCIE_RXP9_SSD: length 95.9
  IN3 w0.089: v1(318.04,32.98) 317.84,33.19 317.84,33.55 317.6,33.78 310.87,33.78 308.93,35.73 305.9,35.73 304.58,37.05 302.65,37.05 301.45,38.24 300.72,38.24 299.5,39.46 298.36,39.46 297.85,39.97 296.07,39.97 295.82,39.71 289.72,39.71 288.97,40.46 278.12,40.46 277.16,41.43 276.26,42.33 273.51,42.33 272.38,43.46 270.5,43.46 270.14,43.83 266.76,43.83 266.28,44.31 261.4,44.31 260.95,43.86 257.55,43.86 256.02,45.38 253.46,45.38 250.22,48.61 250.22,48.86 248.27,50.81 248.27,58.44 248.41,58.59 249.23,58.59 249.31,58.51 249.31,58.22 249.23,58.14 v1(248.95,58.14)
  BOTTOM w0.102: CON5100.7 322.16,28.65 322.01,28.5 321.25,28.5 320.02,29.73 320.02,30.4 317.89,32.53 317.89,32.83 v1(318.04,32.98) ; v1(248.95,58.14) 249.28,57.81 U9002.F36
PCIE_RXP10_SSD: length 93.5
  IN3 w0.089: v1(317.48,35.8) 316.95,35.27 310.86,35.27 309.43,36.71 306.68,36.71 305.02,38.37 305.02,38.62 303.75,39.89 301.34,39.89 300.18,41.05 298.82,41.05 298.23,41.65 295.08,41.65 294.27,40.83 290.49,40.83 289.69,41.63 285.7,41.63 285.32,42.01 284.92,42.01 284.35,41.44 279.36,41.44 276.04,44.76 274.77,44.76 274.25,45.28 259.53,45.28 255.31,49.51 253.28,49.51 252.59,50.19 251.57,50.19 249.6,52.17 249.6,56.27 250.39,57.05 250.39,58.42 v1(250.06,58.74)
  BOTTOM w0.102: U9002.J37 v1(250.06,58.74) ; v1(317.48,35.8) 317.23,35.55 317.23,35.32 316.9,34.99 316.9,34 317.2,33.7 318.85,33.7 321.19,31.35 322.05,31.35 322.12,31.43 322.12,31.57 322.21,31.65 CON5100.19
PCIE_RXP11_SSD: length 90.5
  IN3 w0.089: v1(321.09,34.76) 320.68,35.17 319.34,35.17 319.03,34.86 310.64,34.86 309.19,36.31 306.33,36.31 304.9,37.75 304.4,37.75 302.74,39.41 300.58,39.41 299.39,40.6 295.29,40.6 295,40.31 290.28,40.31 289.54,41.05 279.2,41.05 276.78,43.46 273.41,43.46 272.82,44.06 270.87,44.06 270.04,44.89 258.4,44.89 257.14,46.14 257.14,46.52 255.51,48.16 251.64,48.16 251.1,48.71 251.1,48.85 249.02,50.94 249.02,56.96 249.45,57.39 249.57,57.39 v1(249.75,57.21)
  BOTTOM w0.102: v1(321.09,34.76) 320.96,34.76 320.85,34.66 320.85,34.39 321.02,34.23 321.8,34.23 322.22,34.65 CON5100.31 ; U9002.F39 250.26,56.9 250.26,57.11 250.16,57.21 v1(249.75,57.21)
PCIE_RXP12_SSD: length 88.6
  IN3 w0.089: v1(251.08,56.99) 251.13,56.94 251.71,56.94 252.12,56.53 252.12,55.81 250.48,54.16 250.48,53.1 251.09,52.49 254.12,52.49 257.41,49.2 257.41,48.56 259.14,46.84 265.74,46.84 266.52,46.06 274.46,46.06 274.89,45.63 276.26,45.63 279.68,42.22 283.98,42.22 284.55,42.79 285.66,42.79 286.01,42.43 298.64,42.43 299.2,41.87 300.51,41.87 301.39,41 304.31,41 307.25,38.06 309.18,38.06 310.83,36.41 318.55,36.41 318.64,36.31 320.76,36.31 321.37,35.7 v1(321.39,35.7)
  BOTTOM w0.102: v1(251.08,56.99) U9002.J41 ; CON5100.41 322.18,37.15 322.1,37.23 322.1,37.28 321.93,37.45 321.39,37.45 321.19,37.25 321.19,35.9 v1(321.39,35.7)
PCIE_RXP13_LAN: length 326
  IN1 w0.076: v1(28.2,116.83) 27.98,116.61 27.67,116.61 27.41,116.35 27.41,113.19 28.31,112.29 28.31,97.51 29.09,96.74 29.09,93.74 30.45,92.38 30.45,85.14 37.4,78.19 37.4,75.17 37.09,74.87 37.09,73.67 42.64,68.12 45.01,68.12 46.11,67.02 52.36,67.02 56.89,62.49 56.89,61.57 59.89,58.57 59.89,54.66 60.46,54.09 63.59,54.09 63.73,53.94 67.58,53.94 71.35,57.71 73.62,57.71 77.56,53.77 89.91,53.77 90.93,52.76 93.57,52.76 101.82,44.5 102.71,44.5 103.65,43.56 103.65,36.55 104.86,35.35 104.86,32.14 110.82,26.18 136.78,26.18 138.14,24.82 176.49,24.82 177.22,24.09 186.02,24.09 186.86,24.93 189.45,24.93 189.76,25.25 205.45,25.25 207.41,23.29 213.74,23.29 217.68,27.23 227.3,27.23 232.57,32.5 232.57,36.92 231.81,37.68 231.81,51.6 232.59,52.39 234.63,52.39 237.7,49.32 240.01,49.32 240.73,48.59 241.81,48.59 242.42,49.2 243.96,49.2 245.61,50.85 247.62,50.85 250.33,53.56 250.64,53.56 v1(250.96,53.24)
  BOTTOM w0.102: v1(28.2,116.83) 27.9,116.83 27.51,117.21 27.51,117.52 27.68,117.68 C4000.1 ; U9002.C46 251.08,53.11
  BOTTOM w0.114: 251.08,53.11 v1(250.96,53.24)
PCIE_RXP13_LAN_C: length 3.4
  BOTTOM w0.102: C4000.2 27.64,118.92 27.64,119.22 27.77,119.34 v1(28.18,119.34) 27.64,119.88 27.64,120.21 27.74,120.31 U4000.38
PCIE_RXP14_WLAN: length 142.3
  IN3 w0.089: v1(252.5,54.21) 252.26,53.96 252.26,53.6 252.52,53.33 255.02,53.33 258.99,49.37 258.99,48.73 260.3,47.42 266.03,47.42 266.77,46.67 270.88,46.67 271.06,46.86 275.23,46.86 275.84,46.26 276.47,46.26 279.92,42.8 283.71,42.8 284.31,43.4 285.88,43.4 286.19,43.09 300.31,43.09 301.82,41.58 304.87,41.58 307.12,39.33 308.73,39.33 310.67,37.4 321.42,37.4 324.12,34.7 330.79,34.7 332.88,36.79 335.63,36.79 339.36,40.53 341.97,40.53 342.81,41.37 342.81,43.52 346.3,47.02 351.25,47.02 352.01,47.78 352.01,59.86 352.44,60.29 352.44,68.29 352.11,68.62 351.92,68.62 v1(351.57,68.27)
  BOTTOM w0.102: TP4101.1 352.33,68.47 352.23,68.57 351.86,68.57 v1(351.57,68.27) 351.57,68.44 351.34,68.67 350.77,68.67 350.69,68.59 C4112.1
  BOTTOM w0.114: v1(252.5,54.21) 252.43,54.13 252.43,53.27 252.06,52.91 U9002.C47
PCIE_RXP14_WLAN_C: length 3.6
  BOTTOM w0.102: C4112.2 349.91,68.48 349.69,68.7 349.46,68.7 349.26,68.9 349.26,69.59 348.51,70.33 348.28,70.33 348.13,70.18 U4100.37
PCIE_RXP17_SSD: length 95.6
  IN1 w0.076: v1(319.56,17.36) 319.56,17.6 319.69,17.73 320.01,17.73 320.2,17.92 320.2,18.97 317.87,21.3 317.28,21.3 313.25,25.33 313.25,26.44 308.45,31.24 307.19,31.24 303.54,34.89 299.12,34.89 298.7,35.31 296.01,35.31 295.65,35.67 289.44,35.67 288.87,36.25 286.28,36.25 285.87,36.65 282.68,36.65 281.85,37.48 278.85,37.48 276.7,39.63 271.4,39.63 270.97,40.06 269.72,40.06 268.54,41.24 266.84,41.24 266.23,41.85 264.2,41.85 260.74,45.3 259.62,45.3 253.04,51.88 253.04,54.53 252.07,55.5 252.07,56.29 252.21,56.43 252.42,56.43 v1(252.56,56.29)
  BOTTOM w0.102: CON5101.41 322.56,14.15 322.41,14.3 321.58,14.3 321.27,14.61 321.27,16.14 319.96,17.44 319.64,17.44 v1(319.56,17.36) ; U9002.K44 253.08,56.29 v1(252.56,56.29)
PCIE_RXP18_SSD: length 108.3
  IN1 w0.076: v1(325.79,11.04) 325.51,11.32 325.51,11.5 325.88,11.86 327.53,11.86 328.38,12.71 328.38,15.98 326.07,18.29 325.88,18.29 322.74,21.43 322.74,23.2 317.87,28.07 314.7,28.07 308.39,34.38 305.98,34.38 304.16,36.2 301.38,36.2 300.81,36.77 290,36.77 289.38,37.39 286.79,37.39 285.6,38.57 279.31,38.57 277.05,40.83 271.87,40.83 271.48,41.21 271.16,41.21 270.03,42.34 267.43,42.34 265.41,44.37 263.48,44.37 259.28,48.57 259.28,49.18 258.43,50.03 257.92,50.03 254.83,53.12 254.83,58.2 253.63,59.41 252.88,59.41 v1(252.79,59.51)
  BOTTOM w0.102: v1(325.79,11.04) 325.18,11.65 CON5101.31 ; 253.31,59.51 v1(252.79,59.51)
PCIE_RXP19_SSD: length 105.7
  IN1 w0.076: v1(253.15,57.99) 253.15,57.73 252.85,57.43 252.85,56.63 253.61,55.86 253.61,52.73 256.45,49.9 256.45,49.24 259.11,46.57 260.13,46.57 263.04,43.66 265.03,43.66 267.06,41.62 268.71,41.62 269.89,40.44 271.21,40.44 271.63,40.02 276.85,40.02 279.01,37.86 285.22,37.86 286.42,36.67 289,36.67 289.61,36.06 300.51,36.06 301.21,35.36 303.87,35.36 307.18,32.06 309.68,32.06 316.88,24.86 319.31,24.86 320.8,23.37 320.8,16.82 320.24,16.26 319.69,16.26 319.56,16.39 v1(319.56,16.6)
  BOTTOM w0.102: CON5101.19 322.56,8.65 322.41,8.5 321.57,8.5 320.96,9.11 320.96,9.82 320.53,10.25 320.53,11.11 321.09,11.67 321.09,14.04 320.53,14.6 320.53,15.89 320.12,16.3 319.87,16.3 v1(319.56,16.6) ; U9002.N42 v1(253.15,57.99)
PCIE_RXP20_SSD: length 115.9
  IN1 w0.076: v1(251.95,60.68) 252.21,60.94 252.6,60.94 252.86,60.68 253.03,60.68 255.3,58.4 255.3,54.95 255.74,54.52 256.55,54.52 258.08,52.98 258.08,51.36 258.55,50.89 258.95,50.89 261.11,48.73 261.11,48.01 264.36,44.75 265.63,44.75 267.66,42.72 270.19,42.72 271.21,41.71 271.6,41.71 272.1,41.21 277.21,41.21 278.84,39.58 285.16,39.58 286.96,37.77 289.55,37.77 290.17,37.15 300.97,37.15 301.45,36.67 304.47,36.67 306.25,34.89 308.52,34.89 314.61,28.79 317.91,28.79 323.34,23.37 323.34,21.76 324.94,20.16 326.44,20.16 328.76,17.84 328.76,10.03 328.29,9.56 328.29,7.89 326.13,5.73 325.23,5.73 v1(325.03,5.93)
  BOTTOM w0.102: U9002.R37 252.05,60.78 v1(251.95,60.68) ; v1(325.03,5.93) 325.03,5.81 324.79,5.57 324.42,5.57 324.34,5.65 CON5101.7
PCIE_TXN3_CARD: length 5.6
  BOTTOM w0.102: U7301.4 31.96,69.56 32.06,69.66 32.98,69.66 34.11,70.78 34.11,71.07 v1(34.63,71.59) 34.23,71.59 34.16,71.67 34.16,72.13 C9166.2
PCIE_TXN3_CARD_C: length 273
  IN1 w0.076: v1(232.19,56.73) 231.81,57.11 231.57,57.11 229.52,55.06 229.52,53.94 228.76,53.18 228.76,51.76 229.17,51.35 229.17,33.79 228.33,32.95 228.33,31.61 226.71,29.99 215,29.99 211.07,26.06 207.99,26.06 206.03,28.02 143.32,28.02 142.81,28.53 112.33,28.53 107.55,33.31 107.55,36.46 106.04,37.98 106.04,45.74 104.65,47.13 102.54,47.13 96.13,53.55 96.13,58.08 94.09,60.12 91.48,60.12 89.15,57.79 89.15,57.2 88.47,56.53 80.14,56.53 77.56,59.11 75.91,59.11 71.55,63.46 68.71,63.46 67.34,64.83 67.34,66.38 65.7,68.02 58.61,68.02 58.26,68.38 46.32,68.38 45.02,69.68 43.75,70.95 41.93,70.95 39.87,73 39.87,74.5 39.62,74.75 39.35,74.75 39.22,74.63 v1(39.22,74.39)
  BOTTOM w0.102: U9002.B19 241.92,62.31 240.73,61.12 239.62,61.12 237.7,59.2 235.89,59.2 233.55,56.86 232.32,56.86 v1(232.19,56.73) ; v1(39.22,74.39) 39.22,74.44 38.84,74.82 35.21,74.82 33.94,73.55 33.94,73.33 34.07,73.2 C9166.1

# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BGA1440-INTEL-CFL-H
  round 0.406 smd: A3(-20.314,-12.06) A37(-20.314,12.739) B2(-19.654,-12.654) B38(-19.761,13.314) BR1(19.748,-13.314) BR38(19.722,13.314) BT2(20.314,-12.743) BT37(20.314,12.722) C1(-19.047,-13.314)
  round 0.381 smd: A4(-20.314,-11.343) A34(-20.314,11.146) A36(-20.314,11.958) B3(-19.616,-11.933) B37(-19.612,12.595) BN1(18.3,-13.314) BN38(18.285,13.314) BP1(19.024,-13.314) BP38(18.996,13.314) BR2(19.619,-12.596) BR37(19.613,12.59) BT3(20.314,-12.019) BT4(20.314,-11.295) BT35(20.314,11.184) BT36(20.314,11.996) C2(-18.953,-12.616) C38(-18.98,13.314) D1(-18.323,-13.314) D38(-18.218,13.314)
  round 0.356 smd: A5(-20.314,-10.543) A33(-20.314,10.345) B4(-19.344,-11.283) B36(-19.613,11.884) BM1(17.5,-13.314) BM38(17.573,13.314) BN2(18.328,-12.664) BN37(18.35,12.651) BP2(18.965,-12.486) BP37(18.943,12.374) BR3(19.664,-11.927) BR36(19.657,11.879) BT5(20.314,-10.495) BT34(20.314,10.384) C37(-18.912,12.594) D3(-18.492,-12.081) E1(-17.536,-13.314) E2(-17.84,-12.664) E38(-17.418,13.314)
  round 0.33 smd: A6(-20.314,-9.768) A32(-20.314,9.558) B5(-19.664,-10.571) B34(-19.645,11.129) BK1(16.722,-13.314) BL2(17.124,-12.664) BL38(16.862,13.314) BM2(17.738,-12.352) BM37(17.672,12.664) BN3(18.387,-12.014) BN36(18.324,11.999) BP3(19.02,-11.831) BP35(19.014,11.247) BR5(19.67,-11.148) BR34(19.664,10.46) BR35(19.664,11.222) BT6(20.314,-9.721) BT32(20.314,9.609) C36(-18.926,11.831) D4(-18.66,-11.42) D37(-18.329,12.289) E3(-17.84,-12.014) E37(-17.71,12.664) F2(-17.155,-12.664) G1(-16.733,-13.314) G38(-16.643,13.314)
  round 0.305 smd: A8(-20.314,-8.996) A9(-20.314,-8.209) A10(-20.314,-7.421) A11(-20.314,-6.634) A12(-20.314,-5.847) A13(-20.314,-5.059) A14(-20.314,-4.272) A15(-20.314,-3.484) A16(-20.314,-2.697) A17(-20.314,-1.91) A18(-20.314,-1.122) A19(-20.314,-0.335) A20(-20.314,0.453) A21(-20.314,1.24) A22(-20.314,2.027) A23(-20.314,2.815) A24(-20.314,3.602) A25(-20.314,4.39) A26(-20.314,5.177) A27(-20.314,5.964) A28(-20.314,6.752) A29(-20.314,7.539) A30(-20.314,8.53) AA1(-6.295,-13.314) AA2(-6.295,-12.664) AA3(-6.295,-12.014) AA4(-6.295,-11.363) AA5(-6.295,-10.713) AA6(-6.346,-10.063) AA7(-5.766,-9.403) AA8(-5.766,-8.753) AA9(-5.766,-8.103) AA10(-5.766,-7.452) AA11(-5.766,-6.802) AA12(-5.766,-6.152) AA13(-5.766,-5.502) AA14(-5.766,-4.851) AA29(-5.899,7.411) AA30(-5.899,8.061) AA31(-5.899,8.762) AA32(-5.899,9.413) AA33(-5.899,10.063) AA34(-5.899,10.713) AA35(-5.899,11.363) AA36(-5.899,12.014) AA37(-5.899,12.664) AA38(-5.899,13.314) AB1(-5.559,-13.314) AB2(-5.559,-12.664) AB3(-5.559,-12.014) AB4(-5.559,-11.363) AB5(-5.559,-10.713) AB6(-5.508,-10.063) AB29(-5.111,7.411) AB30(-5.111,8.061) AB31(-5.111,8.762) AB32(-5.111,9.413) AB33(-5.111,10.063) AB34(-5.111,10.713) AB35(-5.111,11.363) AB36(-5.111,12.014) AB37(-5.111,12.664) AB38(-5.111,13.314) AC1(-4.67,-13.314) AC2(-4.67,-12.664) AC3(-4.67,-12.014) AC4(-4.67,-11.363) AC5(-4.67,-10.713) AC6(-4.67,-10.063) AC7(-4.852,-9.403) AC8(-4.852,-8.753) AC9(-4.852,-8.103) AC10(-4.852,-7.452) AC11(-4.852,-6.802) AC12(-4.852,-6.152) AC13(-4.852,-5.502) AC14(-4.852,-4.851) AC29(-4.324,7.411) AC30(-4.324,8.061) AC31(-4.324,8.762) AC32(-4.324,9.413) AC33(-4.324,10.063) AC34(-4.324,10.713) AC35(-4.324,11.363) AC36(-4.324,12.014) AC37(-4.324,12.664) AC38(-4.324,13.314) AD1(-3.781,-13.314) AD2(-3.781,-12.664) AD3(-3.781,-12.014) AD4(-3.781,-11.363) AD5(-3.781,-10.713) AD6(-3.831,-10.063) AD7(-3.937,-9.403) AD8(-3.937,-8.753) AD9(-3.937,-8.103) AD10(-3.937,-7.452) AD11(-3.937,-6.802) AD12(-3.937,-6.152) AD13(-3.937,-5.502) AD14(-3.937,-4.851) AD29(-3.537,7.411) AD30(-3.537,8.061) AD31(-3.537,8.762) AD32(-3.537,9.413) AD33(-3.537,10.063) AD34(-3.537,10.713) AD35(-3.537,11.363) AD36(-3.537,12.014) AD37(-3.537,12.664) AD38(-3.537,13.314) AE1(-3.044,-13.314) AE2(-3.044,-12.664) AE3(-3.044,-12.014) AE4(-3.044,-11.363) AE5(-3.044,-10.713) AE6(-2.993,-10.063) AE7(-3.023,-9.403) AE8(-3.023,-8.753) AE9(-3.023,-8.103) AE10(-3.023,-7.452) AE11(-3.023,-6.802) AE12(-3.023,-6.152) AE13(-3.023,-5.502) AE14(-3.023,-4.851) AE29(-2.749,7.411) AE30(-2.749,8.061) AE31(-2.749,8.762) AE32(-2.749,9.413) AE33(-2.749,10.063) AE34(-2.749,10.713) AE35(-2.749,11.363) AE36(-2.749,12.014) AE37(-2.749,12.664) AE38(-2.749,13.314) AF1(-2.155,-13.314) AF2(-2.155,-12.664) AF3(-2.155,-12.014) AF4(-2.155,-11.363) AF5(-2.155,-10.713) AF6(-2.155,-10.063) AF7(-2.108,-9.403) AF8(-2.108,-8.753) AF9(-2.108,-8.103) AF10(-2.108,-7.452) AF11(-2.108,-6.802) AF12(-2.108,-6.152) AF13(-2.108,-5.502) AF14(-2.108,-4.851) AF29(-1.962,7.411) AF30(-1.962,8.061) AF31(-1.962,8.762) AF32(-1.962,9.413) AF33(-1.962,10.063) AF34(-1.962,10.713) AF35(-1.962,11.363) AF36(-1.962,12.014) AF37(-1.962,12.664) AF38(-1.962,13.314) AG1(-1.266,-13.314) AG2(-1.266,-12.664) AG3(-1.266,-12.014) AG4(-1.266,-11.363) AG5(-1.266,-10.713) AG6(-1.317,-10.063) AG7(-1.194,-9.403) AG8(-1.194,-8.753) AG9(-1.194,-8.103) AG10(-1.194,-7.452) AG11(-1.194,-6.802) AG12(-1.194,-6.152) AG13(-1.194,-5.502) AG14(-1.194,-4.851) AG29(-1.174,7.411) AG30(-1.174,8.061) AG31(-1.174,8.762) AG32(-1.174,9.413) AG33(-1.174,10.063) AG34(-1.174,10.713) AG35(-1.174,11.363) AG36(-1.174,12.014) AG37(-1.174,12.664) AG38(-1.174,13.314) AH1(-0.529,-13.314) AH2(-0.529,-12.664) AH3(-0.529,-12.014) AH4(-0.529,-11.363) AH5(-0.529,-10.713) AH6(-0.479,-10.063) AH7(-0.28,-9.403) AH8(-0.28,-8.753) AH9(-0.28,-8.103) AH10(-0.28,-7.452) AH11(-0.28,-6.802) AH12(-0.28,-6.152) AH13(-0.28,-5.502) AH14(-0.28,-4.851) AH29(-0.387,7.411) AH30(-0.387,8.061) AH31(-0.387,8.762) AH32(-0.387,9.413) AH33(-0.387,10.063) AH34(-0.387,10.713) AH35(-0.387,11.363) AH36(-0.387,12.014) AH37(-0.387,12.664) AH38(-0.387,13.314) AJ1(0.36,-13.314) AJ2(0.36,-12.664) AJ3(0.36,-12.014) AJ4(0.36,-11.363) AJ5(0.36,-10.713) AJ6(0.36,-10.063) AJ7(0.635,-9.403) AJ8(0.635,-8.753) AJ9(0.635,-8.103) AJ10(0.635,-7.452) AJ11(0.635,-6.802) AJ12(0.635,-6.152) AJ13(0.635,-5.502) AJ14(0.635,-4.851) AJ29(0.4,7.411) AJ30(0.4,8.061) AJ31(0.4,8.762) AJ32(0.4,9.413) AJ33(0.4,10.063) AJ34(0.4,10.713) AJ35(0.4,11.363) AJ36(0.4,12.014) AJ37(0.4,12.664) AJ38(0.4,13.314) AK1(1.249,-13.314) AK2(1.249,-12.664) AK3(1.249,-12.014) AK4(1.249,-11.363) AK5(1.249,-10.713) AK6(1.198,-10.063) AK29(1.188,7.411) AK30(1.188,8.061) AK31(1.188,8.762) AK32(1.188,9.413) AK33(1.188,10.063) AK34(1.188,10.713) AK35(1.188,11.363) AK36(1.188,12.014) AK37(1.188,12.664) AK38(1.188,13.314) AL1(1.985,-13.314) AL2(1.985,-12.664) AL3(1.985,-12.014) AL4(1.985,-11.363) AL5(1.985,-10.713) AL6(2.036,-10.063) AL7(1.549,-9.403) AL8(1.549,-8.753) AL9(1.549,-8.103) AL10(1.549,-7.452) AL11(1.549,-6.802) AL12(1.549,-6.152) AL13(1.549,-5.502) AL14(1.549,-4.851) AL29(1.975,7.411) AL30(1.975,8.061) AL31(1.975,8.762) AL32(1.975,9.413) AL33(1.975,10.063) AL34(1.975,10.713) AL35(1.975,11.363) AL36(1.975,12.014) AL37(1.975,12.664) AL38(1.975,13.314) AM1(2.874,-13.314) AM2(2.874,-12.664) AM3(2.874,-12.014) AM4(2.874,-11.363) AM5(2.874,-10.713) AM6(2.874,-10.063) AM7(2.464,-9.403) AM8(2.464,-8.753) AM9(2.464,-8.103) AM10(2.464,-7.452) AM11(2.464,-6.802) AM12(2.464,-6.152) AM13(2.464,-5.502) AM14(2.464,-4.851) AM29(2.763,7.411) AM30(2.763,8.061) AM31(2.763,8.762) AM32(2.763,9.413) AM33(2.763,10.063) AM34(2.763,10.713) AM35(2.763,11.363) AM36(2.763,12.014) AM37(2.763,12.664) AM38(2.763,13.314) AN1(3.763,-13.314) AN2(3.763,-12.664) AN3(3.763,-12.014) AN4(3.763,-11.363) AN5(3.763,-10.713) AN6(3.712,-10.063) AN7(3.378,-9.403) AN8(3.378,-8.753) AN9(3.378,-8.103) AN10(3.378,-7.452) AN11(3.378,-6.802) AN12(3.378,-6.152) AN13(3.378,-5.502) AN14(3.378,-4.851) AN29(3.55,7.411) AN30(3.55,8.061) AN31(3.55,8.762) AN32(3.55,9.413) AN33(3.55,10.063) AN34(3.55,10.713) AN35(3.55,11.363) AN36(3.55,12.014) AN37(3.55,12.664) AN38(3.55,13.314) AP1(4.5,-13.314) AP2(4.5,-12.664) AP3(4.5,-12.014) AP4(4.5,-11.363) AP5(4.5,-10.713) AP6(4.551,-10.063) AP7(4.292,-9.403) AP8(4.292,-8.753) AP9(4.292,-8.103) AP10(4.292,-7.452) AP11(4.292,-6.802) AP12(4.292,-6.152) AP13(4.292,-5.502) AP14(4.292,-4.851) AP29(4.337,7.411) AP30(4.337,8.061) AP31(4.337,8.762) AP32(4.337,9.413) AP33(4.337,10.063) AP34(4.337,10.713) AP35(4.337,11.363) AP36(4.337,12.014) AP37(4.337,12.664) AP38(4.337,13.314) AR1(5.389,-13.314) AR2(5.389,-12.664) AR3(5.389,-12.014) AR4(5.389,-11.363) AR5(5.389,-10.713) AR6(5.389,-10.063) AR7(5.207,-9.403) AR8(5.207,-8.753) AR9(5.207,-8.103) AR10(5.207,-7.452) AR11(5.207,-6.802) AR12(5.207,-6.152) AR13(5.207,-5.502) AR14(5.207,-4.851) AR29(5.125,7.411) AR30(5.125,8.061) AR31(5.125,8.762) AR32(5.125,9.413) AR33(5.125,10.063) AR34(5.125,10.713) AR35(5.125,11.363) AR36(5.125,12.014) AR37(5.125,12.664) AR38(5.125,13.314) AT1(6.278,-13.314) AT2(6.278,-12.664) AT3(6.278,-12.014) AT4(6.278,-11.363) AT5(6.278,-10.713) AT6(6.227,-10.063) AT7(6.121,-9.403) AT8(6.121,-8.753) AT9(6.121,-8.103) AT10(6.121,-7.452) AT11(6.121,-6.802) AT12(6.121,-6.152) AT13(6.121,-5.502) AT14(6.121,-4.851) AT29(5.912,7.411) AT30(5.912,8.061) AT31(5.912,8.762) AT32(5.912,9.413) AT33(5.912,10.063) AT34(5.912,10.713) AT35(5.912,11.363) AT36(5.912,12.014) AT37(5.912,12.664) AT38(5.912,13.314) AU1(7.014,-13.314) AU2(7.014,-12.664) AU3(7.014,-12.014) AU4(7.014,-11.363) AU5(7.014,-10.713) AU6(7.065,-10.063) AU7(7.036,-9.403) AU8(7.036,-8.753) AU9(7.036,-8.103) AU10(7.036,-7.452) AU11(7.036,-6.802) AU12(7.036,-6.152) AU13(7.036,-5.502) AU14(7.036,-4.851) AU29(6.7,7.411) AU30(6.7,8.061) AU31(6.7,8.762) AU32(6.7,9.413) AU33(6.7,10.063) AU34(6.7,10.713) AU35(6.7,11.363) AU36(6.7,12.014) AU37(6.7,12.664) AU38(6.7,13.314) AV29(7.487,7.411) AV30(7.487,8.061) AV31(7.487,8.762) AV32(7.487,9.413) AV33(7.487,10.063) AV34(7.487,10.713) AV35(7.487,11.363) AV36(7.487,12.014) AV37(7.487,12.664) AV38(7.487,13.314) AW1(7.903,-13.314) AW2(7.903,-12.664) AW3(7.903,-12.014) AW4(7.903,-11.363) AW5(7.903,-10.713) AW6(7.903,-10.063) AW7(7.95,-9.403) AW8(7.95,-8.753) AW9(7.95,-8.103) AW10(7.95,-7.452) AW11(7.95,-6.802) AW12(7.95,-6.152) AW13(7.95,-5.502) AW14(7.95,-4.851) AW29(8.274,7.411) AW30(8.274,8.061) AW31(8.274,8.762) AW32(8.274,9.413) AW33(8.274,10.063) AW34(8.274,10.713) AW35(8.274,11.363) AW36(8.274,12.014) AW37(8.274,12.664) AW38(8.274,13.314) AY1(8.792,-13.314) AY2(8.792,-12.664) AY3(8.792,-12.014) AY4(8.792,-11.363) AY5(8.792,-10.713) AY6(8.742,-10.063) AY7(8.864,-9.403) AY8(8.864,-8.753) AY9(8.864,-8.103) AY10(8.864,-7.452) AY11(8.864,-6.802) AY12(8.864,-6.152) AY13(8.864,-5.502) AY14(8.864,-4.851) AY29(9.062,7.411) AY30(9.062,8.061) AY31(9.062,8.762) AY32(9.062,9.413) AY33(9.062,10.063) AY34(9.062,10.713) AY35(9.062,11.363) AY36(9.062,12.014) AY37(9.062,12.664) AY38(9.062,13.314) B6(-19.664,-9.784) B8(-19.664,-8.996) B9(-19.664,-8.209) B10(-19.664,-7.421) B11(-19.664,-6.634) B12(-19.664,-5.847) B13(-19.664,-5.059) B14(-19.664,-4.272) B15(-19.664,-3.484) B16(-19.664,-2.697) B17(-19.664,-1.91) B18(-19.664,-1.122) B19(-19.664,-0.335) B20(-19.664,0.453) B21(-19.664,1.24) B22(-19.664,2.027) B23(-19.664,2.815) B24(-19.664,3.602) B25(-19.664,4.39) B26(-19.664,5.177) B27(-19.664,5.964) B28(-19.664,6.752) B29(-19.664,7.539) B30(-19.664,8.327) B31(-19.664,9.114) B33(-19.664,9.901) BA1(9.529,-13.314) BA2(9.529,-12.664) BA3(9.529,-12.014) BA4(9.529,-11.363) BA5(9.529,-10.713) BA6(9.58,-10.063) BA7(9.779,-9.403) BA8(9.779,-8.753) BA9(9.779,-8.103) BA10(9.779,-7.452) BA11(9.779,-6.802) BA12(9.779,-6.152) BA13(9.779,-5.502) BA14(9.779,-4.851) BA29(9.849,7.411) BA30(9.849,8.061) BA31(9.849,8.762) BA32(9.849,9.413) BA33(9.849,10.063) BA34(9.849,10.713) BA35(9.849,11.363) BA36(9.849,12.014) BA37(9.849,12.664) BA38(9.849,13.314) BB1(10.418,-13.314) BB2(10.418,-12.664) BB3(10.418,-12.014) BB4(10.418,-11.363) BB5(10.418,-10.713) BB6(10.418,-10.063) BB7(10.693,-9.403) BB8(10.693,-8.753) BB9(10.693,-8.103) BB10(10.693,-7.452) BB11(10.693,-6.802) BB12(10.693,-6.152) BB13(10.693,-5.502) BB14(10.693,-4.851) BB29(10.637,7.411) BB30(10.637,8.061) BB31(10.637,8.762) BB32(10.637,9.413) BB33(10.637,10.063) BB34(10.637,10.713) BB35(10.637,11.363) BB36(10.637,12.014) BB37(10.637,12.664) BB38(10.637,13.314) BC1(11.307,-13.314) BC2(11.307,-12.664) BC3(11.307,-12.014) BC4(11.307,-11.363) BC5(11.307,-10.713) BC6(11.256,-10.063) BC7(11.608,-9.403) BC8(11.608,-8.753) BC9(11.608,-8.103) BC10(11.608,-7.452) BC11(11.608,-6.802) BC12(11.608,-6.152) BC13(11.608,-5.502) BC14(11.608,-4.851) BC29(11.424,7.411) BC30(11.424,8.061) BC31(11.424,8.762) BC32(11.424,9.413) BC33(11.424,10.063) BC34(11.424,10.713) BC35(11.424,11.363) BC36(11.424,12.014) BC37(11.424,12.664) BC38(11.424,13.314) BD1(12.044,-13.314) BD2(12.044,-12.664) BD3(12.044,-12.014) BD4(12.044,-11.363) BD5(12.044,-10.713) BD6(12.094,-10.063) BD7(12.522,-9.403) BD8(12.522,-8.753) BD9(12.522,-8.103) BD10(12.522,-7.452) BD11(12.522,-6.802) BD12(12.522,-6.152) BD13(12.522,-5.502) BD14(12.522,-4.851) BD29(12.211,7.411) BD30(12.211,8.061) BD31(12.211,8.762) BD32(12.211,9.413) BD33(12.211,10.063) BD34(12.211,10.713) BD35(12.211,11.363) BD36(12.211,12.014) BD37(12.211,12.664) BD38(12.211,13.314) BE1(12.933,-13.314) BE2(12.933,-12.664) BE3(12.933,-12.014) BE4(12.933,-11.363) BE5(12.933,-10.713) BE6(12.933,-10.063) BE29(12.999,7.411) BE30(12.999,8.061) BE31(12.999,8.762) BE32(12.999,9.413) BE33(12.999,10.063) BE34(12.999,10.713) BE35(12.999,11.363) BE36(12.999,12.014) BE37(12.999,12.664) BE38(12.999,13.314) BF1(13.822,-13.314) BF2(13.822,-12.664) BF3(13.822,-12.014) BF4(13.822,-11.363) BF5(13.822,-10.713) BF6(13.771,-10.063) BF7(13.436,-9.403) BF8(13.436,-8.753) BF9(13.436,-8.103) BF10(13.436,-7.452) BF11(13.436,-6.802) BF12(13.436,-6.152) BF13(13.436,-5.502) BF14(13.436,-4.851) BF29(13.786,7.411) BF30(13.786,8.061) BF31(13.786,8.762) BF32(13.786,9.413) BF33(13.786,10.063) BF34(13.786,10.713) BF35(13.786,11.363) BF36(13.786,12.014) BF37(13.786,12.664) BF38(13.786,13.314) BG1(14.558,-13.314) BG2(14.558,-12.664) BG3(14.558,-12.014) BG4(14.558,-11.363) BG5(14.558,-10.713) BG6(14.609,-10.063) BG7(14.351,-9.403) BG8(14.351,-8.753) BG9(14.351,-8.103) BG10(14.351,-7.452) BG11(14.351,-6.802) BG12(14.351,-6.152) BG13(14.351,-5.502) BG14(14.351,-4.851) BG29(14.574,7.411) BG30(14.574,8.061) BG31(14.574,8.762) BG32(14.574,9.413) BG33(14.574,10.063) BG34(14.574,10.713) BG35(14.574,11.363) BG36(14.574,12.014) BG37(14.574,12.664) BG38(14.574,13.314) BH1(15.701,-13.314) BH2(15.447,-12.664) BH3(15.447,-12.014) BH4(15.447,-11.363) BH5(15.447,-10.713) BH6(15.447,-10.063) BH7(15.265,-9.403) BH8(15.265,-8.753) BH9(15.265,-8.103) BH10(15.265,-7.452) BH11(15.265,-6.802) BH12(15.265,-6.152) BH13(15.265,-5.502) BH14(15.227,-4.851) BH29(15.234,7.411) BH30(15.361,8.061) BH31(15.361,8.762) BH32(15.361,9.413) BH33(15.361,10.063) BH34(15.361,10.713) BH35(15.361,11.363) BH36(15.361,12.014) BH37(15.361,12.664) BH38(15.361,13.314) BJ7(16.18,-9.403) BJ8(16.18,-8.753) BJ9(16.18,-8.103) BJ10(16.18,-7.452) BJ11(16.18,-6.802) BJ12(16.091,-6.032) BJ13(15.812,-5.144) BJ14(15.762,-4.463) BJ15(15.762,-3.713) BJ16(15.762,-2.926) BJ17(15.762,-2.139) BJ18(15.762,-1.351) BJ19(15.762,-0.564) BJ20(15.762,0.224) BJ21(15.762,1.011) BJ22(15.762,1.798) BJ23(15.762,2.586) BJ24(15.762,3.373) BJ25(15.762,4.161) BJ26(15.762,4.948) BJ27(15.762,5.735) BJ28(15.762,6.523) BJ29(15.844,7.183) BJ30(16.015,8.039) BJ31(16.148,8.762) BJ32(16.148,9.413) BJ33(16.148,10.063) BJ34(16.148,10.713) BJ35(16.148,11.363) BJ36(16.148,12.014) BJ37(16.148,12.664) BJ38(16.098,13.314) BK2(16.285,-12.664) BK3(16.285,-12.014) BK4(16.285,-11.363) BK5(16.285,-10.713) BK6(16.285,-10.063) BK13(16.413,-5.415) BK14(16.413,-4.501) BK15(16.413,-3.713) BK16(16.413,-2.926) BK17(16.413,-2.139) BK18(16.413,-1.351) BK19(16.413,-0.564) BK20(16.413,0.224) BK21(16.413,1.011) BK22(16.413,1.798) BK23(16.413,2.586) BK24(16.413,3.373) BK25(16.413,4.161) BK26(16.413,4.948) BK27(16.413,5.735) BK28(16.413,6.523) BK29(16.421,7.518) BL3(17.073,-12.014) BL4(17.073,-11.363) BL5(17.073,-10.713) BL6(17.124,-10.063) BL7(17.069,-9.327) BL8(17.063,-8.438) BL9(17.063,-7.65) BL11(17.063,-6.863) BL12(17.063,-6.076) BL13(17.063,-5.288) BL14(17.063,-4.501) BL15(17.063,-3.713) BL16(17.063,-2.926) BL17(17.063,-2.139) BL18(17.063,-1.351) BL19(17.063,-0.564) BL20(17.063,0.224) BL21(17.063,1.011) BL22(17.063,1.798) BL23(17.063,2.586) BL24(17.063,3.373) BL25(17.063,4.161) BL26(17.063,4.948) BL27(17.063,5.735) BL28(17.063,6.523) BL29(17.063,7.31) BL30(16.936,8.112) BL31(16.936,8.762) BL32(16.936,9.413) BL33(16.936,10.063) BL34(16.936,10.713) BL35(16.936,11.363) BL36(16.936,12.014) BL37(16.936,12.664) BM3(17.815,-11.701) BM5(17.815,-10.789) BM6(17.916,-10.145) BM7(17.713,-9.225) BM8(17.713,-8.438) BM9(17.713,-7.65) BM11(17.713,-6.863) BM12(17.713,-6.076) BM13(17.713,-5.288) BM14(17.713,-4.501) BM15(17.713,-3.713) BM16(17.713,-2.926) BM17(17.713,-2.139) BM18(17.713,-1.351) BM19(17.713,-0.564) BM20(17.713,0.224) BM21(17.713,1.011) BM22(17.713,1.798) BM23(17.713,2.586) BM24(17.713,3.373) BM25(17.713,4.161) BM26(17.713,4.948) BM27(17.713,5.735) BM28(17.713,6.523) BM29(17.713,7.31) BM30(17.713,8.098) BM31(17.713,8.885) BM33(17.713,9.672) BM34(17.713,10.46) BM35(17.713,11.247) BM36(17.672,12.014) BN4(18.315,-11.209) BN5(18.479,-10.566) BN7(18.363,-9.225) BN8(18.363,-8.438) BN9(18.363,-7.65) BN11(18.363,-6.863) BN12(18.363,-6.076) BN13(18.363,-5.288) BN14(18.363,-4.501) BN15(18.363,-3.713) BN16(18.363,-2.926) BN17(18.363,-2.139) BN18(18.363,-1.351) BN19(18.363,-0.564) BN20(18.363,0.224) BN21(18.363,1.011) BN22(18.363,1.798) BN23(18.363,2.586) BN24(18.363,3.373) BN25(18.363,4.161) BN26(18.363,4.948) BN27(18.363,5.735) BN28(18.363,6.523) BN29(18.363,7.31) BN30(18.363,8.098) BN31(18.363,8.885) BN33(18.363,9.672) BN34(18.363,10.46) BN35(18.363,11.248) BP5(19.037,-10.94) BP6(18.974,-10.02) BP7(19.014,-9.225) BP8(19.014,-8.438) BP9(19.014,-7.65) BP11(19.014,-6.863) BP12(19.014,-6.076) BP13(19.014,-5.288) BP14(19.014,-4.501) BP15(19.014,-3.713) BP16(19.014,-2.926) BP17(19.014,-2.139) BP18(19.014,-1.351) BP19(19.014,-0.564) BP20(19.014,0.224) BP21(19.014,1.011) BP22(19.014,1.798) BP23(19.014,2.586) BP24(19.014,3.373) BP25(19.014,4.161) BP26(19.014,4.948) BP27(19.014,5.735) BP28(19.014,6.523) BP29(19.014,7.31) BP30(19.014,8.098) BP31(19.014,8.885) BP33(19.014,9.672) BP34(19.014,10.46) BR6(19.647,-10.122) BR7(19.664,-9.225) BR8(19.664,-8.438) BR9(19.664,-7.65) BR11(19.664,-6.863) BR12(19.664,-6.076) BR13(19.664,-5.288) BR14(19.664,-4.501) BR15(19.664,-3.713) BR16(19.664,-2.926) BR17(19.664,-2.139) BR18(19.664,-1.351) BR19(19.664,-0.564) BR20(19.664,0.224) BR21(19.664,1.011) BR22(19.664,1.798) BR23(19.664,2.586) BR24(19.664,3.373) BR25(19.664,4.161) BR26(19.664,4.948) BR27(19.664,5.735) BR28(19.664,6.523) BR29(19.664,7.31) BR30(19.664,8.098) BR31(19.664,8.885) BR33(19.664,9.672) BT8(20.314,-8.666) BT9(20.314,-7.65) BT11(20.314,-6.863) BT12(20.314,-6.076) BT13(20.314,-5.288) BT14(20.314,-4.501) BT15(20.314,-3.713) BT16(20.314,-2.926) BT17(20.314,-2.139) BT18(20.314,-1.351) BT19(20.314,-0.564) BT20(20.314,0.224) BT21(20.314,1.011) BT22(20.314,1.798) BT23(20.314,2.586) BT24(20.314,3.373) BT25(20.314,4.161) BT26(20.314,4.948) BT27(20.314,5.735) BT28(20.314,6.523) BT29(20.314,7.31) BT30(20.314,8.098) BT31(20.314,8.86) C5(-19.014,-10.571) C6(-19.014,-9.784) C8(-19.014,-8.996) C9(-19.014,-8.209) C10(-19.014,-7.421) C11(-19.014,-6.634) C12(-19.014,-5.847) C13(-19.014,-5.059) C14(-19.014,-4.272) C15(-19.014,-3.484) C16(-19.014,-2.697) C17(-19.014,-1.91) C18(-19.014,-1.122) C19(-19.014,-0.335) C20(-19.014,0.453) C21(-19.014,1.24) C22(-19.014,2.027) C23(-19.014,2.815) C24(-19.014,3.602) C25(-19.014,4.39) C26(-19.014,5.177) C27(-19.014,5.964) C28(-19.014,6.752) C29(-19.014,7.539) C30(-19.014,8.327) C31(-19.014,9.114) C33(-19.014,9.901) C34(-19.025,10.697) D5(-18.363,-10.571) D6(-18.363,-9.784) D8(-18.363,-8.996) D9(-18.363,-8.209) D10(-18.363,-7.421) D11(-18.363,-6.634) D12(-18.363,-5.847) D13(-18.363,-5.059) D14(-18.363,-4.272) D15(-18.363,-3.484) D16(-18.363,-2.697) D17(-18.363,-1.91) D18(-18.363,-1.122) D19(-18.363,-0.335) D20(-18.363,0.453) D21(-18.363,1.24) D22(-18.363,2.027) D23(-18.363,2.815) D24(-18.363,3.602) D25(-18.363,4.39) D26(-18.363,5.177) D27(-18.363,5.964) D28(-18.363,6.752) D29(-18.363,7.539) D30(-18.363,8.327) D31(-18.363,9.114) D33(-18.363,9.901) D34(-18.363,10.689) D35(-18.453,11.341) E4(-17.739,-11.363) E5(-17.713,-10.571) E6(-17.713,-9.784) E8(-17.713,-8.996) E9(-17.713,-8.209) E10(-17.713,-7.421) E11(-17.713,-6.634) E12(-17.713,-5.847) E13(-17.713,-5.059) E14(-17.713,-4.272) E15(-17.713,-3.484) E16(-17.713,-2.697) E17(-17.713,-1.91) E18(-17.713,-1.122) E19(-17.713,-0.335) E20(-17.713,0.453) E21(-17.713,1.24) E22(-17.713,2.027) E23(-17.713,2.815) E24(-17.713,3.602) E25(-17.713,4.39) E26(-17.713,5.177) E27(-17.713,5.964) E28(-17.713,6.752) E29(-17.713,7.539) E30(-17.713,8.327) E31(-17.713,9.114) E33(-17.713,9.901) E34(-17.713,10.689) E35(-17.71,11.363) E36(-17.71,12.014) F3(-17.155,-12.014) F4(-17.053,-11.363) F5(-17.041,-10.571) F6(-17.041,-9.784) F8(-17.063,-8.996) F9(-17.063,-8.209) F10(-17.063,-7.421) F11(-17.063,-6.634) F12(-17.063,-5.847) F13(-17.063,-5.059) F14(-17.063,-4.272) F15(-17.063,-3.484) F16(-17.063,-2.697) F17(-17.063,-1.91) F18(-17.063,-1.122) F19(-17.063,-0.335) F20(-17.063,0.453) F21(-17.063,1.24) F22(-17.063,2.027) F23(-17.063,2.815) F24(-17.063,3.602) F25(-17.063,4.39) F26(-17.063,5.177) F27(-17.063,5.964) F28(-17.063,6.752) F29(-17.063,7.539) F30(-17.063,8.327) F31(-17.063,9.114) F33(-17.063,9.901) F34(-16.922,10.713) F35(-16.922,11.363) F36(-16.922,12.014) F37(-16.922,12.664) G2(-16.367,-12.664) G3(-16.367,-12.014) G4(-16.367,-11.363) G5(-16.367,-10.713) G6(-16.367,-10.063) G8(-16.413,-8.996) G9(-16.413,-8.209) G10(-16.413,-7.421) G11(-16.413,-6.634) G12(-16.413,-5.847) G13(-16.413,-5.059) G14(-16.413,-4.272) G15(-16.413,-3.484) G16(-16.413,-2.697) G17(-16.413,-1.91) G18(-16.413,-1.122) G19(-16.413,-0.335) G20(-16.413,0.453) G21(-16.413,1.24) G22(-16.413,2.027) G23(-16.413,2.815) G24(-16.413,3.602) G25(-16.413,4.39) G26(-16.413,5.177) G27(-16.413,5.964) G28(-16.413,6.752) G29(-16.413,7.539) G30(-16.413,8.327) H1(-15.871,-13.314) H11(-15.762,-6.634) H12(-15.762,-5.847) H13(-15.712,-5.059) H14(-15.712,-4.272) H15(-15.712,-3.484) H16(-15.712,-2.697) H17(-15.712,-1.91) H18(-15.712,-1.122) H19(-15.712,-0.335) H20(-15.712,0.453) H21(-15.712,1.24) H22(-15.712,2.027) H23(-15.712,2.815) H24(-15.712,3.602) H25(-15.712,4.39) H26(-15.712,5.177) H27(-15.712,5.964) H28(-15.712,6.752) H29(-15.762,7.539) H30(-15.762,8.289) H32(-16.135,9.413) H33(-16.135,10.063) H34(-16.135,10.713) H35(-16.135,11.363) H36(-16.135,12.014) H37(-16.135,12.664) J2(-15.566,-12.664) J3(-15.566,-12.014) J4(-15.566,-11.363) J5(-15.566,-10.713) J6(-15.566,-10.063) J7(-15.695,-9.421) J8(-15.598,-8.773) J9(-15.621,-8.103) J10(-15.686,-7.421) J14(-15.061,-4.272) J15(-15.061,-3.484) J16(-15.061,-2.697) J17(-15.061,-1.91) J18(-15.061,-1.122) J19(-15.061,-0.335) J20(-15.061,0.453) J21(-15.061,1.24) J22(-15.061,2.027) J23(-15.061,2.815) J24(-15.061,3.602) J25(-15.061,4.39) J26(-15.061,5.177) J27(-15.061,5.964) J28(-15.061,6.752) J30(-15.146,7.747) J31(-15.31,8.762) J32(-15.348,9.413) J33(-15.348,10.063) J34(-15.348,10.713) J35(-15.348,11.363) J36(-15.348,12.014) J37(-15.348,12.664) J38(-15.602,13.314) K1(-14.728,-13.314) K2(-14.728,-12.664) K3(-14.728,-12.014) K4(-14.728,-11.363) K5(-14.728,-10.713) K6(-14.728,-10.063) K7(-14.758,-9.403) K8(-14.834,-8.753) K9(-14.834,-8.103) K10(-14.834,-7.452) K11(-14.834,-6.802) K12(-14.834,-6.152) K13(-15.138,-5.436) K14(-14.656,-4.851) K29(-14.56,7.411) K30(-14.56,8.061) K31(-14.56,8.762) K32(-14.56,9.413) K33(-14.56,10.063) K34(-14.56,10.713) K35(-14.56,11.363) K36(-14.56,12.014) K37(-14.56,12.664) K38(-14.56,13.314) L1(-13.839,-13.314) L2(-13.839,-12.664) L3(-13.839,-12.014) L4(-13.839,-11.363) L5(-13.839,-10.713) L6(-13.89,-10.063) L7(-13.919,-9.403) L8(-13.97,-8.753) L9(-13.996,-8.103) L10(-13.996,-7.452) L11(-13.996,-6.802) L12(-13.996,-6.152) L13(-13.996,-5.502) L14(-13.996,-4.851) L29(-13.773,7.411) L30(-13.773,8.061) L31(-13.773,8.762) L32(-13.773,9.413) L33(-13.773,10.063) L34(-13.773,10.713) L35(-13.773,11.363) L36(-13.773,12.014) L37(-13.773,12.664) L38(-13.773,13.314) M1(-13.102,-13.314) M2(-13.102,-12.664) M3(-13.102,-12.014) M4(-13.102,-11.363) M5(-13.102,-10.713) M6(-13.052,-10.063) M7(-13.081,-9.403) M8(-13.081,-8.753) M9(-13.081,-8.103) M10(-13.081,-7.452) M11(-13.081,-6.802) M12(-13.081,-6.152) M13(-13.081,-5.502) M14(-13.081,-4.851) M29(-12.985,7.411) M30(-12.985,8.061) M31(-12.985,8.762) M32(-12.985,9.413) M33(-12.985,10.063) M34(-12.985,10.713) M35(-12.985,11.363) M36(-12.985,12.014) M37(-12.985,12.664) M38(-12.985,13.314) N1(-12.213,-13.314) N2(-12.213,-12.664) N3(-12.213,-12.014) N4(-12.213,-11.363) N5(-12.213,-10.713) N6(-12.213,-10.063) N7(-12.167,-9.403) N8(-12.167,-8.753) N9(-12.167,-8.103) N10(-12.167,-7.452) N11(-12.167,-6.802) N12(-12.167,-6.152) N13(-12.167,-5.502) N14(-12.167,-4.851) N29(-12.198,7.411) N30(-12.198,8.061) N31(-12.198,8.762) N32(-12.198,9.413) N33(-12.198,10.063) N34(-12.198,10.713) N35(-12.198,11.363) N36(-12.198,12.014) N37(-12.198,12.664) N38(-12.198,13.314) P1(-11.324,-13.314) P2(-11.324,-12.664) P3(-11.324,-12.014) P4(-11.324,-11.363) P5(-11.324,-10.713) P6(-11.375,-10.063) P7(-11.252,-9.403) P8(-11.252,-8.753) P9(-11.252,-8.103) P10(-11.252,-7.452) P11(-11.252,-6.802) P12(-11.252,-6.152) P13(-11.252,-5.502) P14(-11.252,-4.851) P29(-11.411,7.411) P30(-11.411,8.061) P31(-11.411,8.762) P32(-11.411,9.413) P33(-11.411,10.063) P34(-11.411,10.713) P35(-11.411,11.363) P36(-11.411,12.014) P37(-11.411,12.664) P38(-11.411,13.314) R1(-10.588,-13.314) R2(-10.588,-12.664) R3(-10.588,-12.014) R4(-10.588,-11.363) R5(-10.588,-10.713) R6(-10.537,-10.063) R7(-10.338,-9.403) R8(-10.338,-8.753) R9(-10.338,-8.103) R10(-10.338,-7.452) R11(-10.338,-6.802) R12(-10.338,-6.152) R13(-10.338,-5.502) R14(-10.338,-4.851) R29(-10.623,7.411) R30(-10.623,8.061) R31(-10.623,8.762) R32(-10.623,9.413) R33(-10.623,10.063) R34(-10.623,10.713) R35(-10.623,11.363) R36(-10.623,12.014) R37(-10.623,12.664) R38(-10.623,13.314) T1(-9.699,-13.314) T2(-9.699,-12.664) T3(-9.699,-12.014) T4(-9.699,-11.363) T5(-9.699,-10.713) T6(-9.699,-10.063) T7(-9.424,-9.403) T8(-9.424,-8.753) T9(-9.424,-8.103) T10(-9.424,-7.452) T11(-9.424,-6.802) T12(-9.424,-6.152) T13(-9.424,-5.502) T14(-9.424,-4.851) T29(-9.836,7.411) T30(-9.836,8.061) T31(-9.836,8.762) T32(-9.836,9.413) T33(-9.836,10.063) T34(-9.836,10.713) T35(-9.836,11.363) T36(-9.836,12.014) T37(-9.836,12.664) T38(-9.836,13.314) U1(-8.81,-13.314) U2(-8.81,-12.664) U3(-8.81,-12.014) U4(-8.81,-11.363) U5(-8.81,-10.713) U6(-8.861,-10.063) U29(-9.048,7.411) U30(-9.048,8.061) U31(-9.048,8.762) U32(-9.048,9.413) U33(-9.048,10.063) U34(-9.048,10.713) U35(-9.048,11.363) U36(-9.048,12.014) U37(-9.048,12.664) U38(-9.048,13.314) V1(-8.073,-13.314) V2(-8.073,-12.664) V3(-8.073,-12.014) V4(-8.073,-11.363) V5(-8.073,-10.713) V6(-8.022,-10.063) V7(-8.509,-9.403) V8(-8.509,-8.753) V9(-8.509,-8.103) V10(-8.509,-7.452) V11(-8.509,-6.802) V12(-8.509,-6.152) V13(-8.509,-5.502) V14(-8.509,-4.851) V29(-8.261,7.411) V30(-8.261,8.061) V31(-8.261,8.762) V32(-8.261,9.413) V33(-8.261,10.063) V34(-8.261,10.713) V35(-8.261,11.363) V36(-8.261,12.014) V37(-8.261,12.664) V38(-8.261,13.314) W1(-7.184,-13.314) W2(-7.184,-12.664) W3(-7.184,-12.014) W4(-7.184,-11.363) W5(-7.184,-10.713) W6(-7.184,-10.063) W7(-7.595,-9.403) W8(-7.595,-8.753) W9(-7.595,-8.103) W10(-7.595,-7.452) W11(-7.595,-6.802) W12(-7.595,-6.152) W13(-7.595,-5.502) W14(-7.595,-4.851) W29(-7.474,7.411) W30(-7.474,8.061) W31(-7.474,8.762) W32(-7.474,9.413) W33(-7.474,10.063) W34(-7.474,10.713) W35(-7.474,11.363) W36(-7.474,12.014) W37(-7.474,12.664) W38(-7.474,13.314) Y7(-6.68,-9.403) Y8(-6.68,-8.753) Y9(-6.68,-8.103) Y10(-6.68,-7.452) Y11(-6.68,-6.802) Y12(-6.68,-6.152) Y13(-6.68,-5.502) Y14(-6.68,-4.851) Y29(-6.686,7.411) Y30(-6.686,8.061) Y31(-6.686,8.762) Y32(-6.686,9.413) Y33(-6.686,10.063) Y34(-6.686,10.713) Y35(-6.686,11.363) Y36(-6.686,12.014) Y37(-6.686,12.664) Y38(-6.686,13.314)
BSH-030-01-L-D-A-TR-60P-RUV
  round 1.016 hole 1.016 unplated: (-10.063,-2.666) (10.063,-2.666)
  rect 0.279x2.261 smd: 1(7.25,2.864) 2(7.25,-2.864) 3(6.75,2.864) 4(6.75,-2.864) 5(6.25,2.864) 6(6.25,-2.864) 7(5.75,2.864) 8(5.75,-2.864) 9(5.25,2.864) 10(5.25,-2.864) 11(4.75,2.864) 12(4.75,-2.864) 13(4.25,2.864) 14(4.25,-2.864) 15(3.75,2.864) 16(3.75,-2.864) 17(3.25,2.864) 18(3.25,-2.864) 19(2.75,2.864) 20(2.75,-2.864) 21(2.25,2.864) 22(2.25,-2.864) 23(1.75,2.864) 24(1.75,-2.864) 25(1.25,2.864) 26(1.25,-2.864) 27(0.75,2.864) 28(0.75,-2.864) 29(0.25,2.864) 30(0.25,-2.864) 31(-0.25,2.864) 32(-0.25,-2.864) 33(-0.75,2.864) 34(-0.75,-2.864) 35(-1.25,2.864) 36(-1.25,-2.864) 37(-1.75,2.864) 38(-1.75,-2.864) 39(-2.25,2.864) 40(-2.25,-2.864) 41(-2.75,2.864) 42(-2.75,-2.864) 43(-3.25,2.864) 44(-3.25,-2.864) 45(-3.75,2.864) 46(-3.75,-2.864) 47(-4.25,2.864) 48(-4.25,-2.864) 49(-4.75,2.864) 50(-4.75,-2.864) 51(-5.25,2.864) 52(-5.25,-2.864) 53(-5.75,2.864) 54(-5.75,-2.864) 55(-6.25,2.864) 56(-6.25,-2.864) 57(-6.75,2.864) 58(-6.75,-2.864) 59(-7.25,2.864) 60(-7.25,-2.864)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0402_2
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC1808
  rect 2.159x2.286 smd: 1(-2.349,0) 2(2.349,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CC7343-3H
  rect 2.388x2.896 smd: 1(-3.05,0) 2(3.05,0)
CHOKE-DLP0NSN900HL2L
  rect 0.305x0.305 smd: 1(-0.25,-0.3) 2(-0.25,0.3) 3(0.25,0.3) 4(0.25,-0.3)
CHOKE-LQH32PN4R7NN0L
  rect 1.245x2.007 smd: 1(-1.275,0) 2(1.275,0)
CHOKE-PCMB041B-1R0MS
  rect 1.499x2.489 smd: 1(-1.85,0) 2(1.85,0)
CHOKE-PCMC063T-3R3MN-SMT
  rect 1.854x3.505 smd: 1(-3.275,0) 2(3.275,0)
CHOKE-WCM2012-4P
  rect 0.889x0.406 smd: 1(-0.85,0.4) 2(0.85,0.4) 3(0.85,-0.4) 4(-0.85,-0.4)
D-0_6X0_3-0_32H-SMT
  custom 0.051x0.051 smd: 1(-0.242,0) 2(0.242,0)
D-1_2X0_8-0_7H
  rect 0.61x0.787 smd: 1(-0.85,0) 2(0.85,0)
D-1X0_6-D24V0L1B2LPS
  rect 0.457x0.61 smd: 1(-0.375,0) 2(0.375,0)
D-3_8X2_5
  rect 1.6x1.905 smd: 1(-2.15,0) 2(2.15,0)
D-4_3X2_7
  rect 2.057x2.057 smd: 1(-1.865,0) 2(1.865,0)
D-SOT523_213-1_6-1
  rect 0.508x0.406 smd: 1(0.65,0.5) 2(0.65,-0.5) 3(-0.65,0)
DCJK-040003HR005BA19ZL-5P
  round 1.245 hole 1.245 unplated: (0,2.15) (0,-2.15)
  oval 1.245x2.007 hole 0.762x1.499: 1(1.96,5.48) 2(-1.96,5.48) 6(3.575,-2.15) 7(3.575,2.6) 8(-3.575,-2.15) 9(-3.575,2.6)
  oval 1.194x2.007 hole 0.711x1.499: 3(4.04,5.48) 4(-4.04,5.48)
  oval 1.397x2.007 hole 0.889x1.499: 5(0,5.48)
DDR4-ADDR0207-P035A-STD-260P
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
DDR4-D4AR0-26001-1P40-RVS-SMT
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(33.8,12) 262(-33.8,12)
DDR4-D4AS0-26010-1P40-STD-SMT
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
DFN8-1_4X1-35
  rect 0.152x0.711 smd: 1(-0.525,-0.45)
  rect 0.152x0.61 smd: 2(-0.175,-0.5) 3(0.175,-0.5) 4(0.525,-0.5) 5(0.525,0.5) 6(0.175,0.5) 7(-0.175,0.5) 8(-0.525,0.5)
DFN8-2X2-5-9P
  rect 0.305x0.94 smd: 1(-0.75,-1.125) 2(-0.25,-1.125) 3(0.25,-1.125) 4(0.75,-1.125) 5(0.75,1.125) 6(0.25,1.125) 7(-0.25,1.125) 8(-0.75,1.125)
  rect 1.118x0.533 smd: 9(0,0)
DFN1006H4-3-1X0_6-3P
  rect 0.406x0.254 smd: 1(0.35,0.225) 2(0.35,-0.225)
  rect 0.406x0.711 smd: 3(-0.35,0)
DSM
  rect 1.016x0.508 smd: 1(-1.3,0) 2(1.321,0)
EMIPAD47X31-63X24-3P
  rect 1.6x0.61 smd: 1(-1.8,0) 3(1.8,0)
  rect 1.194x0.787 smd: 2(0,0)
F4_55X3_24-5_23-1_8H
  rect 1.778x3.505 smd: 1(-2.615,0) 2(2.615,0)
FILTER-MCM2012B900GBE-4P
  rect 0.762x0.406 smd: 1(-0.925,0.4) 2(0.925,0.4) 3(0.925,-0.4) 4(-0.925,-0.4)
FPC-51619-0060B-001-6P-L
  rect 0.305x1.295 smd: 1(-1.25,2.8) 2(-0.75,2.8) 3(-0.25,2.8) 4(0.25,2.8) 5(0.75,2.8) 6(1.25,2.8)
  rect 1.803x1.397 smd: 7(-2.9,0) 8(2.9,0)
FPC-51625-0120B-V01-12P-L
  rect 0.305x0.838 smd: 1(-2.75,3.18) 2(-2.25,3.18) 3(-1.75,3.18) 4(-1.25,3.18) 5(-0.75,3.18) 6(-0.25,3.18) 7(0.25,3.18) 8(0.75,3.18) 9(1.25,3.18) 10(1.75,3.18) 11(2.25,3.18) 12(2.75,3.18)
  rect 0.787x2.007 smd: 13(-4.45,0) 14(4.45,0)
H-C118D118N
  round 2.997 hole 2.997 unplated: (0,0)
H-C256I118D118P2
  round 6.502 hole 2.997: 1(0,0)
H-C276I118D118P2
  round 7.01 hole 2.997: 1(0,0)
H-C394I118D118P2
  round 10.008 hole 2.997: 1(0,0)
H-TC217BC256I118D118P2
  round 6.502 hole 2.997: 1(0,0)
H-TC217IC102BC256D102P2
  round 6.502 hole 2.591: 1(0,0)
H-TC236BC177I138D138P2
  round 4.496 hole 3.505: 1(0,0)
H-TC236BC256I146D146P2
  round 6.502 hole 3.708: 1(0,0)
H-TC256BC217I118D118P2
  round 5.512 hole 2.997: 1(0,0)
H-TIO256X236BO138X118D138X118PT
  oval 6.502x5.994 hole 3.302x2.997: 1(0,0)
H-TO276X236BIO157X118D157X118PT
  oval 7.01x5.994 hole 3.988x2.997: 1(0,0)
H-XW2A-B1
  custom 1.638x1.638 hole 2.997: 1(0,0)
H-XW2A-B2
  custom 1.5x1.5 hole 2.997: 1(0,0)
H-XW2A-B3
  custom 1.5x1.5 hole 2.997: 1(0,0)
HDD-C166PK-12234-L-22P-R
  round 1.6 hole 1.6 unplated: (-16.595,0) (16.595,0)
  round 1.067 hole 0.711: 1(15.875,1.46) 2(14.605,1.46) 3(13.335,1.46) 4(12.065,1.46) 5(10.795,1.46) 6(9.525,1.46) 7(8.255,1.46) 8(1.905,1.46) 9(0.635,1.46) 10(-0.635,1.46) 11(-1.905,1.46) 12(-3.175,1.46) 13(-4.445,1.46) 14(-5.715,1.46) 15(-6.985,1.46) 16(-8.255,1.46) 17(-9.525,1.46) 18(-10.795,1.46) 19(-12.065,1.46) 20(-13.335,1.46) 21(-14.605,1.46) 22(-15.875,1.46)
  oval 1.6x2.972 hole 0.991x2.388: 23(18.71,0.75) 24(-18.71,0.75)
HDMI-HMRFD-AK520C-19P
  round 0.787 hole 0.559: 1(4.5,6.86) 2(4,5.36) 3(3.5,6.86) 4(3,5.36) 5(2.5,6.86) 6(2,5.36) 7(1.5,6.86) 8(1,5.36) 9(0.5,6.86) 10(0,5.36) 11(-0.5,6.86) 12(-1,5.36) 13(-1.5,6.86) 14(-2,5.36) 15(-2.5,6.86) 16(-3,5.36) 17(-3.5,6.86) 18(-4,5.36) 19(-4.5,6.86)
  oval 1.6x2.794 hole 0.991x2.21: 20(7.25,5.96) 22(-7.25,5.96)
  oval 1.6x2.007 hole 0.991x1.397: 21(7.25,0) 23(-7.25,0)
HG-TC216IC128BC157D61P2
  round 3.988 hole 1.549: 1(0,0)
  round 0.508 hole 0.254: 2(1.372,0) 3(0.97,0.97) 4(0,1.372) 5(-0.97,0.97) 6(-1.372,0) 7(-0.97,-0.97) 8(0,-1.372) 9(0.97,-0.97)
L2_5X2-1_2H
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L3_1X3_1
  rect 1.6x1.194 smd: 1(-1.3,0) 2(1.3,0)
L10X10-3_8
  rect 4.089x4.089 smd: 1(-4.75,0) 2(4.75,0)
LED19-113-T1D-CP2Q2HY-3T
  rect 0.787x0.787 smd: 1(-0.75,0) 2(0.75,0)
LEDLTST-C195KGJRKT-4P
  rect 0.838x0.66 smd: 1(0.725,-0.425) 2(0.725,0.425) 3(-0.725,-0.425) 4(-0.725,0.425)
LEDLTW-326DSKF-5A-3P-SMT
  rect 0.889x1.295 smd: 1(-1.45,-0.1) 3(1.45,-0.1)
  rect 0.889x0.889 smd: 2(0,-0.65)
LEDLTW-C191DS5
  rect 0.787x0.787 smd: 1(-0.75,0) 2(0.75,0)
LGA12-2X2-5-HP2DCTR
  rect 0.305x0.406 smd: 1(-0.75,-0.763) 2(-0.25,-0.763) 3(0.25,-0.763) 4(0.75,-0.763) 7(0.75,0.763) 8(0.25,0.763) 9(-0.25,0.763) 10(-0.75,0.763)
  rect 0.406x0.254 smd: 5(0.763,-0.25) 6(0.763,0.25) 11(-0.763,0.25) 12(-0.763,-0.25)
LVDS-GS12407-10112-7H-40P-R
  round 0.762 hole 0.762 unplated: (-10.5,0) (10.5,0)
  rect 0.254x1.143 smd: 1(9.75,2.125) 2(9.25,2.125) 3(8.75,2.125) 4(8.25,2.125) 5(7.75,2.125) 6(7.25,2.125) 7(6.75,2.125) 8(6.25,2.125) 9(5.75,2.125) 10(5.25,2.125) 11(4.75,2.125) 12(4.25,2.125) 13(3.75,2.125) 14(3.25,2.125) 15(2.75,2.125) 16(2.25,2.125) 17(1.75,2.125) 18(1.25,2.125) 19(0.75,2.125) 20(0.25,2.125) 21(-0.25,2.125) 22(-0.75,2.125) 23(-1.25,2.125) 24(-1.75,2.125) 25(-2.25,2.125) 26(-2.75,2.125) 27(-3.25,2.125) 28(-3.75,2.125) 29(-4.25,2.125) 30(-4.75,2.125) 31(-5.25,2.125) 32(-5.75,2.125) 33(-6.25,2.125) 34(-6.75,2.125) 35(-7.25,2.125) 36(-7.75,2.125) 37(-8.25,2.125) 38(-8.75,2.125) 39(-9.25,2.125) 40(-9.75,2.125)
  rect 1.499x2.997 smd: 41(12.25,0) 42(-12.25,0)
  rect 2.794x1.499 smd: 43(5.7,-2.05) 44(-5.7,-2.05)
LVDS-LVD-A30SFYG-30P-R
  rect 0.254x1.295 smd: 1(7.25,1.95) 2(6.75,1.95) 3(6.25,1.95) 4(5.75,1.95) 5(5.25,1.95) 6(4.75,1.95) 7(4.25,1.95) 8(3.75,1.95) 9(3.25,1.95) 10(2.75,1.95) 11(2.25,1.95) 12(1.75,1.95) 13(1.25,1.95) 14(0.75,1.95) 15(0.25,1.95) 16(-0.25,1.95) 17(-0.75,1.95) 18(-1.25,1.95) 19(-1.75,1.95) 20(-2.25,1.95) 21(-2.75,1.95) 22(-3.25,1.95) 23(-3.75,1.95) 24(-4.25,1.95) 25(-4.75,1.95) 26(-5.25,1.95) 27(-5.75,1.95) 28(-6.25,1.95) 29(-6.75,1.95) 30(-7.25,1.95)
  rect 1.194x2.692 smd: 31(9.65,0) 32(-9.65,0)
  rect 2.311x1.295 smd: 33(6.4,-1.95) 34(0,-1.95) 35(-6.4,-1.95)
MLP8-2X2-5-9P
  rect 0.254x0.889 smd: 1(-0.75,-0.9) 2(-0.25,-0.9) 3(0.25,-0.9) 4(0.75,-0.9) 5(0.75,0.9) 6(0.25,0.9) 7(-0.25,0.9) 8(-0.75,0.9)
  rect 1.346x0.356 smd: 9(0,0)
MODULE-12X16-152P
  rect 0.305x0.508 smd: 1(-6.75,-5.6) 2(-6.25,-5.6) 3(-5.75,-5.6) 4(-5.25,-5.6) 5(-4.75,-5.6) 6(-4.25,-5.6) 7(-3.75,-5.6) 8(-3.25,-5.6) 9(-2.75,-5.6) 10(-2.25,-5.6) 11(-1.75,-5.6) 12(-1.25,-5.6) 13(-0.75,-5.6) 14(-0.25,-5.6) 15(0.25,-5.6) 16(0.75,-5.6) 17(1.25,-5.6) 18(1.75,-5.6) 19(2.25,-5.6) 20(2.75,-5.6) 21(3.25,-5.6) 22(3.75,-5.6) 23(4.25,-5.6) 24(4.75,-5.6) 25(5.25,-5.6) 26(5.75,-5.6) 27(6.25,-5.6) 28(6.75,-5.6) 49(6.75,5.6) 50(6.25,5.6) 51(5.75,5.6) 52(5.25,5.6) 53(4.75,5.6) 54(4.25,5.6) 55(3.75,5.6) 56(3.25,5.6) 57(2.75,5.6) 58(2.25,5.6) 59(1.75,5.6) 60(1.25,5.6) 61(0.75,5.6) 62(0.25,5.6) 63(-0.25,5.6) 64(-0.75,5.6) 65(-1.25,5.6) 66(-1.75,5.6) 67(-2.25,5.6) 68(-2.75,5.6) 69(-3.25,5.6) 70(-3.75,5.6) 71(-4.25,5.6) 72(-4.75,5.6) 73(-5.25,5.6) 74(-5.75,5.6) 75(-6.25,5.6) 76(-6.75,5.6) A7(-2.75,-3.85) A8(-2.25,-3.85) A9(-1.75,-3.85) A10(-1.25,-3.85) A11(-0.75,-3.85) A12(-0.25,-3.85) A13(0.25,-3.85) A14(0.75,-3.85) A15(1.25,-3.85) A16(1.75,-3.85) A17(2.25,-3.85) A18(2.75,-3.85) A19(3.25,-3.85) A20(3.75,-3.85) A21(4.25,-3.85) A22(4.75,-3.85) A23(5.25,-3.85) A24(5.75,-3.85) A25(6.25,-3.85) A26(6.9,-3.6) A27(6.9,-2.8) A28(6.9,-0.4) A29(6.9,0.4) A30(6.9,2.8) A31(6.9,3.6) A32(6.25,3.85) A33(5.75,3.85) A34(5.25,3.85) A35(4.75,3.85) A36(4.25,3.85) A37(3.75,3.85) A38(3.25,3.85) A39(2.75,3.85) A40(2.25,3.85) A41(1.75,3.85) A42(1.25,3.85) A43(0.75,3.85) A44(0.25,3.85) A45(-0.25,3.85) A46(-0.75,3.85) A47(-1.25,3.85) A48(-1.75,3.85) A49(-2.25,3.85) A50(-2.75,3.85)
  rect 0.508x0.305 smd: 29(7.6,-4.75) 30(7.6,-4.25) 31(7.6,-3.75) 32(7.6,-3.25) 33(7.6,-2.75) 34(7.6,-2.25) 35(7.6,-1.75) 36(7.6,-1.25) 37(7.6,-0.75) 38(7.6,-0.25) 39(7.6,0.25) 40(7.6,0.75) 41(7.6,1.25) 42(7.6,1.75) 43(7.6,2.25) 44(7.6,2.75) 45(7.6,3.25) 46(7.6,3.75) 47(7.6,4.25) 48(7.6,4.75) 77(-7.6,4.75) 78(-7.6,4.25) 79(-7.6,3.75) 80(-7.6,3.25) 81(-7.6,2.75) 82(-7.6,2.25) 83(-7.6,1.75) 84(-7.6,1.25) 85(-7.6,0.75) 86(-7.6,0.25) 87(-7.6,-0.25) 88(-7.6,-0.75) 89(-7.6,-1.25) 90(-7.6,-1.75) 91(-7.6,-2.25) 92(-7.6,-2.75) 93(-7.6,-3.25) 94(-7.6,-3.75) 95(-7.6,-4.25) 96(-7.6,-4.75)
  rect 0.711x0.711 smd: 97(-7.5,-5.5) 98(7.5,-5.5) 99(7.5,5.5) 100(-7.5,5.5)
  custom 0.75x0.75 smd: 101(-4.95,-1.65)
  rect 2.997x2.997 smd: 102(-1.65,-1.65) 103(1.65,-1.65) 104(4.95,-1.65) 105(4.95,1.65) 106(1.65,1.65) 107(-1.65,1.65) 108(-4.95,1.65)

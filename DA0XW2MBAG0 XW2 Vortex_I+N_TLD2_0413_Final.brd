# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ39: length 68.5
  TOP w0.102: v1(163.99,54.16) 163.23,53.41 163.23,50.66 162.1,49.54 JDIM1000.187
  IN4 w0.102: v1(165.82,100.09) 165.21,99.48 165.21,97.47 165.95,96.73 165.95,96.22 166.5,95.66 166.5,91.19 170.21,87.48 170.21,87.03 171.65,85.59 171.65,72.61 170.78,71.73 170.78,71.37 170.46,71.05 170.46,70.9 170.63,70.73 170.63,70.58 170.49,70.44 170.35,70.44 170.14,70.64 170.05,70.64 169.88,70.47 169.88,70.33 170.08,70.13 170.08,70.03 169.91,69.87 169.77,69.87 169.59,70.04 169.45,70.04 163.81,64.4 163.81,62.72 163.99,62.54 163.99,62.31 163.81,62.13 163.81,61.9 163.99,61.73 163.99,61.5 163.81,61.32 163.81,60.99 163.99,60.81 163.99,60.58 163.81,60.41 163.81,60.18 163.99,60 163.99,59.77 163.81,59.59 163.81,59.36 163.99,59.19 163.99,58.96 163.81,58.78 163.81,58.55 163.99,58.37 163.99,58.14 163.81,57.97 163.81,57.74 163.99,57.56 163.99,57.33 163.81,57.15 163.81,56.93 163.99,56.75 163.99,56.52 163.81,56.34 163.81,56.11 163.99,55.93 163.99,55.71 163.81,55.53 163.81,55.3 163.99,55.12 163.99,54.89 163.81,54.72 163.81,54.34 v1(163.99,54.16)
  BOTTOM w0.076: v1(165.82,100.09) 165.49,100.39 U9001.AA1
  BOTTOM w0.102: JDIM1001.187 162.1,55.03 162.34,54.8 162.72,54.8 163.07,54.44 163.38,54.44 163.79,54.85 164.12,54.85 164.83,54.14 164.83,53.86 164.65,53.68 164.47,53.68 v1(163.99,54.16)
M_A_DQ40: length 72.7
  TOP w0.102: JDIM1000.190 162.85,55.51 163.08,55.29 163.08,54.56 163.22,54.42 163.49,54.42 163.61,54.54 163.61,54.78 163.75,54.92 164.15,54.92 164.4,54.68 164.4,53.3 v1(163.99,52.89)
  IN4 w0.102: v1(165.82,98.82) 165.44,98.44 165.44,97.61 166.22,96.82 166.22,96.46 166.73,95.95 166.73,91.55 170.47,87.82 170.47,87.05 172.14,85.38 172.14,72.41 171.26,71.53 171.26,70.53 169.81,69.08 169.66,69.08 169.49,69.25 169.35,69.25 169.2,69.11 169.2,68.96 169.38,68.79 169.38,68.65 169.23,68.5 169.09,68.5 168.91,68.68 168.77,68.68 168.63,68.53 168.63,68.39 168.8,68.21 168.8,68.07 168.66,67.93 168.51,67.93 168.34,68.1 168.2,68.1 168.05,67.96 168.05,67.81 168.23,67.64 168.23,67.5 168.08,67.35 167.94,67.35 167.76,67.53 167.62,67.53 167.48,67.38 167.48,67.24 167.65,67.06 167.65,66.92 167.47,66.74 167.33,66.74 167.15,66.92 167.01,66.92 166.87,66.77 166.87,66.63 167,66.5 167,66.27 166.83,66.1 166.19,66.1 164.29,64.2 164.29,62.97 164.47,62.8 164.47,53.38 v1(163.99,52.89)
  BOTTOM w0.076: U9001.V5 166.57,102.4 166.57,100.41 166.57,99.57 v1(165.82,98.82)
  BOTTOM w0.102: JDIM1001.190 162.85,49.45 162.81,49.5 162.41,49.5 162.19,49.72 162.19,50.13 162.43,50.37 162.94,50.37 163.17,50.61 163.17,51.47 163.58,51.87 163.58,52.49 v1(163.99,52.89)
M_A_DQ41: length 71.2
  TOP w0.102: JDIM1000.191 163.1,49.79 164.62,51.31 164.62,52.58 164.83,52.78 164.83,53.66 v1(165.31,54.14)
  IN4 w0.102: v1(166.74,97.29) 166.74,96.72 167.16,96.3 167.16,92.06 170.97,88.25 170.97,87.31 172.8,85.49 172.8,72.13 171.92,71.26 171.92,70.25 171.62,69.96 171.62,69.81 171.75,69.69 171.75,69.54 171.61,69.4 171.46,69.4 171.34,69.53 171.19,69.53 171.05,69.38 171.05,69.24 171.18,69.11 171.18,68.97 171.03,68.82 170.89,68.82 170.76,68.95 170.62,68.95 170.47,68.81 170.47,68.66 170.6,68.54 170.6,68.39 170.46,68.25 170.31,68.25 170.19,68.38 170.04,68.38 169.9,68.23 169.9,68.09 170.03,67.96 170.03,67.82 169.88,67.67 169.74,67.67 169.61,67.8 169.47,67.8 169.32,67.66 169.32,67.51 169.68,67.16 169.68,66.99 169.56,66.87 169.39,66.87 169.04,67.23 168.89,67.23 168.75,67.08 168.75,66.94 169.06,66.62 169.06,66.46 168.94,66.34 168.78,66.34 168.49,66.63 168.29,66.63 165.5,63.83 165.5,62.98 165.65,62.83 165.65,58.54 165.38,58.28 165.38,58.05 165.28,57.95 165.23,57.95 165.13,57.84 165.13,57.64 165.23,57.54 165.28,57.54 165.38,57.44 165.38,57.23 165.28,57.13 165.23,57.13 165.13,57.03 165.13,56.7 165.31,56.52 165.31,55.93 165.13,55.75 165.13,55.41 165.23,55.31 165.28,55.31 165.38,55.21 165.38,55.01 165.28,54.9 165.23,54.9 165.13,54.8 165.13,54.32 v1(165.31,54.14)
  BOTTOM w0.076: U9001.V2 166.87,100.76 166.87,100.53 166.87,100.22 166.94,100.16 166.94,97.48 v1(166.74,97.29)
  BOTTOM w0.102: v1(165.31,54.14) 165.13,54.32 165.13,54.47 165.51,54.85 165.51,55.07 165.31,55.27 165.12,55.27 164.75,54.9 164.55,54.9 163.96,55.48 163.53,55.48 163.38,55.33 163.38,55.05 163.2,54.87 163.03,54.87 162.77,55.13 162.77,55.35 163.1,55.69 JDIM1001.191
M_A_DQ42: length 68.7
  TOP w0.102: JDIM1000.208 167.36,55.11 168.22,54.25 168.22,52.51 v1(168.92,51.82)
  IN4 w0.102: v1(168.92,51.82) 168.62,51.82 168.43,52 168.43,53.29 168.71,53.57 168.71,60.54 168.2,61.05 168.2,61.85 168.89,62.54 169.09,62.54 169.19,62.44 169.38,62.44 169.53,62.6 169.53,62.77 169.41,62.89 169.41,63.06 169.53,63.18 169.7,63.18 169.82,63.06 169.96,63.06 170.1,63.2 170.1,63.35 169.98,63.46 169.98,63.63 170.1,63.75 170.27,63.75 170.39,63.63 170.54,63.63 170.68,63.78 170.68,63.92 170.56,64.04 170.56,64.21 170.68,64.33 170.85,64.33 170.97,64.21 171.11,64.21 174.46,67.56 174.46,70.21 175.34,71.08 175.34,85.74 173.26,87.82 173.26,89.21 169.58,92.9 169.58,96.2 167.9,97.87 167.9,99.67 v1(168.34,100.11)
  BOTTOM w0.076: U9001.U1 168.01,100.39 v1(168.34,100.11)
  BOTTOM w0.102: JDIM1001.208 167.36,49.99 167.69,50.33 168.13,50.33 168.32,50.14 169.17,50.14 169.37,50.34 169.37,51.36 v1(168.92,51.82)
M_A_DQ43: length 69.6
  TOP w0.102: v1(167.16,51.43) 166.87,51.43 166.71,51.26 166.71,50.93 167.28,50.36 167.28,50.21 167.08,50.02 166.94,50.02 166.42,50.54 166.05,50.54 165.77,50.26 165.77,49.84 166.1,49.51 JDIM1000.203
  IN4 w0.102: v1(168.34,100.74) 167.66,100.06 167.66,97.78 169.29,96.15 169.29,92.8 173.01,89.09 173.01,87.69 175.01,85.69 175.01,71.22 174.13,70.34 174.13,67.7 171.18,64.75 170.63,64.75 167.87,61.99 167.87,60.91 168.38,60.4 168.38,53.7 168.1,53.42 168.1,51.19 167.93,51.01 167.59,51.01 v1(167.16,51.43)
  BOTTOM w0.076: U9001.U2 168.01,101.04 v1(168.34,100.74)
  BOTTOM w0.102: JDIM1001.203 166.1,52.49 v1(167.16,51.43)
M_A_DQ44: length 69.1
  TOP w0.102: v1(165.31,52.87) 164.85,52.41 164.85,50.9 164.33,50.38 164.08,50.38 163.86,50.16 163.86,49.84 164.1,49.6 JDIM1000.195
  IN4 w0.102: v1(167.19,96.84) 167.34,96.69 167.34,92.21 171.25,88.3 171.25,87.38 173.13,85.51 173.13,72 172.25,71.12 172.25,69.57 172.11,69.43 172.11,68.88 171.96,68.74 171.82,68.74 171.69,68.87 171.54,68.87 171.4,68.73 171.4,68.58 171.53,68.45 171.53,68.31 171.39,68.16 171.24,68.16 171.11,68.29 170.97,68.29 170.83,68.15 170.83,68.01 170.96,67.88 170.96,67.73 170.81,67.59 170.67,67.59 170.54,67.72 170.39,67.72 170.25,67.57 170.25,67.43 170.38,67.3 170.38,67.18 168.73,65.53 168.59,65.53 168.35,65.77 168.18,65.77 168.06,65.65 168.06,65.48 168.3,65.24 168.3,65.1 168.16,64.96 168.01,64.96 167.79,65.18 167.62,65.18 167.5,65.06 167.5,64.89 167.72,64.67 167.72,64.53 167.58,64.38 167.44,64.38 167.27,64.55 167.1,64.55 166.98,64.43 166.98,64.26 167.15,64.09 167.15,63.95 167.01,63.81 166.86,63.81 166.7,63.97 166.53,63.97 166.41,63.85 166.41,63.68 166.57,63.52 166.57,63.38 166.43,63.23 166.29,63.23 166.11,63.4 165.95,63.4 165.83,63.29 165.83,63.12 166,62.94 166,62.8 165.98,62.78 165.98,58.41 165.71,58.14 165.71,53.1 165.49,52.87 v1(165.31,52.87)
  BOTTOM w0.076: U9001.V1 167.15,96.85 167.17,96.84 v1(167.19,96.84)
  BOTTOM w0.102: JDIM1001.195 164.1,55.77 164.38,55.5 165.37,55.5 165.77,55.1 165.77,53.33 v1(165.31,52.87)
M_A_DQ45: length 71.5
  TOP w0.102: JDIM1000.194 163.85,55.5 164.62,54.73 164.62,52.86 164.42,52.66 164.42,52.06 v1(163.99,51.62)
  IN4 w0.102: v1(165.82,98.19) 165.64,98.01 165.64,97.75 166.48,96.91 166.48,96.64 166.94,96.18 166.94,91.85 170.72,88.07 170.72,87.18 172.47,85.43 172.47,72.27 171.59,71.4 171.59,70.39 166.75,65.55 166.6,65.55 166.53,65.62 166.38,65.62 166.24,65.48 166.24,65.34 166.32,65.26 166.32,65.12 166.17,64.97 166.03,64.97 165.95,65.05 165.81,65.05 165.66,64.91 165.66,64.76 165.74,64.69 165.74,64.54 165.6,64.4 165.45,64.4 165.38,64.47 165.23,64.47 165.09,64.33 165.09,64.19 165.17,64.11 165.17,63.97 165.01,63.81 164.75,63.81 164.62,63.69 164.62,63.11 164.8,62.93 164.8,56.53 164.98,56.35 164.98,56.07 164.8,55.89 164.8,53.07 164.4,52.66 164.4,52.41 164.8,52 164.8,51.85 164.57,51.62 v1(163.99,51.62)
  BOTTOM w0.076: v1(165.82,98.19) 166.34,98.19 166.53,98.37 166.53,99.1 166.72,99.29 166.72,100.47 166.72,100.94 166.86,101.08 166.86,102.04 U9001.V4
  BOTTOM w0.102: JDIM1001.194 163.85,49.33 163.69,49.5 163.18,49.5 162.97,49.7 162.49,49.7 162.39,49.8 162.39,50.05 162.51,50.17 163.02,50.17 163.38,50.53 163.38,51.38 163.74,51.75 163.86,51.75 v1(163.99,51.62)
M_A_DQ46: length 71.6
  TOP w0.102: v1(167.16,53.97) 167.57,53.57 167.57,50.12 167.1,49.66 JDIM1000.207
  IN4 w0.102: v1(167.16,53.97) 167.16,54.29 166.93,54.52 166.93,54.88 167.06,55.01 167.55,55.01 167.65,55.11 167.65,55.31 167.55,55.41 167.03,55.41 166.93,55.51 166.93,55.72 167.03,55.82 167.55,55.82 167.65,55.92 167.65,56.12 167.55,56.23 167.03,56.23 166.93,56.33 166.93,56.53 167.03,56.63 167.55,56.63 167.65,56.73 167.65,56.94 167.55,57.04 167.03,57.04 166.93,57.14 166.93,57.47 167.72,58.26 167.72,60.13 167.21,60.64 167.21,62.26 173.47,68.52 173.47,70.62 174.35,71.49 174.35,85.64 172.4,87.59 172.4,88.93 168.74,92.59 168.74,95.97 167.13,97.58 167.13,101.45 v1(168.34,102.66)
  BOTTOM w0.076: U9001.U5 168.01,102.99 v1(168.34,102.66)
  BOTTOM w0.102: v1(167.16,53.97) 166.69,53.5 166.51,53.5 166.38,53.63 166.38,54.36 166.53,54.52 167.42,54.52 167.57,54.67 167.57,54.86 167.41,55.02 166.88,55.02 166.78,55.12 166.78,55.33 167.1,55.65 JDIM1001.207
M_A_DQ47: length 69.8
  TOP w0.102: v1(167.16,52.7) 166.58,52.7 166.36,52.93 166.36,54.11 166.68,54.44 166.68,54.9 166.36,55.22 JDIM1000.204
  IN4 w0.102: v1(168.34,102.01) 167.41,101.08 167.41,97.65 169.02,96.04 169.02,92.69 172.75,88.96 172.75,87.56 174.68,85.64 174.68,71.36 173.8,70.48 173.8,68.38 173.5,68.08 173.5,67.94 173.62,67.82 173.62,67.65 173.5,67.53 173.33,67.53 173.21,67.65 173.07,67.65 172.92,67.51 172.92,67.36 173.04,67.24 173.04,67.08 172.92,66.96 172.76,66.96 172.64,67.08 172.49,67.08 172.35,66.93 172.35,66.79 172.47,66.67 172.47,66.5 172.35,66.38 172.18,66.38 172.06,66.5 171.92,66.5 171.77,66.36 171.77,66.21 171.89,66.09 171.89,65.93 171.77,65.81 171.61,65.81 171.49,65.93 171.34,65.93 171.2,65.78 171.2,65.64 171.32,65.52 171.32,65.35 171.2,65.23 171.03,65.23 170.91,65.35 170.77,65.35 167.54,62.13 167.54,60.77 168.05,60.26 168.05,58.12 167.79,57.86 167.79,57.48 168.05,57.21 168.05,55.05 167.67,54.67 167.67,54.31 167.93,54.06 167.93,53.81 167.67,53.55 167.67,53.02 167.36,52.7 v1(167.16,52.7)
  BOTTOM w0.076: v1(168.34,102.01) 168.01,102.34 U9001.U4
  BOTTOM w0.102: JDIM1001.204 166.36,49.8 167.57,51.01 167.57,52.3 v1(167.16,52.7)
M_A_DQ48: length 69.1
  TOP w0.102: JDIM1000.229 172.6,50.12 172.4,50.33 172.09,50.33 171.95,50.18 171.69,50.18 171.55,50.33 171.55,51.85 v1(171.95,52.26)
  IN4 w0.102: v1(170.13,97.6) 170.13,96.71 170.49,96.35 170.49,93.38 174.05,89.82 174.05,88.17 176.48,85.74 176.48,70.61 175.6,69.73 175.6,66.36 172.05,62.81 171.36,62.81 169.86,61.31 169.86,58.11 169.96,58.01 170.09,58.01 170.21,57.88 170.21,57.6 170.09,57.48 169.96,57.48 169.86,57.38 169.86,51.28 170.09,51.05 170.75,51.05 v1(171.95,52.26)
  BOTTOM w0.076: U9001.R2 169.38,100.75 169.38,100.21 169.45,100.14 169.45,99.5 169.69,99.26 169.69,98.63 170.13,98.19 v1(170.13,97.6)
  BOTTOM w0.102: JDIM1001.229 172.6,55.58 173.01,55.18 173.01,53.31 v1(171.95,52.26)
M_A_DQ49: length 70.6
  TOP w0.102: v1(171.95,54.16) 171.34,53.55 171.34,49.98 171.6,49.72 JDIM1000.225
  IN4 w0.102: v1(170.85,102.66) 169.75,101.56 169.75,98.64 173.42,94.97 173.42,94.83 173.02,94.42 173.02,94.28 173.16,94.14 173.31,94.14 173.71,94.54 173.85,94.54 174,94.4 174,94.25 173.59,93.85 173.59,93.71 173.74,93.56 173.88,93.56 174.28,93.96 174.43,93.96 175.5,92.89 175.5,88.65 178.04,86.11 178.04,69.98 177.15,69.09 177.15,65.22 174.9,62.96 174.39,62.96 172.36,60.93 172.36,54.39 172.13,54.16 v1(171.95,54.16)
  BOTTOM w0.076: U9001.P5 170.52,102.99 v1(170.85,102.66)
  BOTTOM w0.102: JDIM1001.225 171.6,55.55 171.1,55.05 171.1,54.8 171.28,54.61 171.55,54.61 172.1,55.16 172.46,55.16 172.75,54.87 172.75,53.98 172.58,53.81 172.3,53.81 v1(171.95,54.16)
M_A_DQ50: length 72.3
  TOP w0.102: v1(168.92,50.55) 168.57,50.55 168.31,50.81 168.31,51.87 168.19,51.99 167.92,51.99 167.82,51.9 167.82,50.71 168.59,49.94 168.59,49.72 168.47,49.6 168.19,49.6 168.1,49.51 JDIM1000.211
  IN4 w0.102: v1(169.22,98.5) 169.22,97.33 170.18,96.38 170.18,93.18 173.77,89.59 173.77,88.07 176.15,85.69 176.15,70.74 175.27,69.87 175.27,66.5 171.92,63.14 171.23,63.14 169.71,61.63 169.2,61.63 169.08,61.52 169.08,61.32 169.53,60.87 169.53,50.6 169.32,50.4 169.06,50.4 v1(168.92,50.55)
  BOTTOM w0.076: U9001.R4 169.37,102.04 169.37,101.18 169.22,101.03 v1(169.22,98.5)
  BOTTOM w0.102: JDIM1001.211 168.1,51.36 v1(168.92,50.55)
M_A_DQ51: length 70.8
  TOP w0.102: v1(171.95,52.89) 172.37,53.31 172.37,54.32 171.83,54.86 170.25,54.86 169.36,55.75 JDIM1000.216
  IN4 w0.102: v1(170.85,102.01) 170.08,101.24 170.08,98.78 175.83,93.03 175.83,88.79 178.37,86.25 178.37,69.84 177.48,68.95 177.48,65.08 174.6,62.2 174.46,62.2 174.35,62.31 174.21,62.31 174.06,62.16 174.06,62.02 174.17,61.91 174.17,61.77 174.03,61.63 173.88,61.63 173.78,61.73 173.63,61.73 173.49,61.59 173.49,61.45 173.6,61.34 173.6,61.19 173.45,61.05 173.31,61.05 173.2,61.16 173.06,61.16 172.91,61.01 172.91,60.87 173.02,60.76 173.02,60.62 172.77,60.37 172.77,54.18 172.52,53.93 172.52,53.23 172.77,52.98 172.77,52.73 172.6,52.56 172.29,52.56 v1(171.95,52.89)
  BOTTOM w0.076: U9001.P4 170.52,102.34 v1(170.85,102.01)
  BOTTOM w0.102: v1(171.95,52.89) 171.55,52.49 171.55,51.43 171.1,50.99 170.21,50.99 169.96,50.73 169.96,49.92 169.7,49.67 169.53,49.67 169.36,49.49 JDIM1001.216
M_A_DQ52: length 71
  TOP w0.102: JDIM1000.215 169.1,49.84 169.35,50.09 169.35,52.65 v1(168.92,53.09)
  IN4 w0.102: v1(168.92,53.09) 169.2,53.37 169.2,60.74 168.69,61.24 168.69,61.66 168.99,61.96 169.58,61.96 171.29,63.68 171.43,63.68 171.64,63.47 171.78,63.47 171.92,63.62 171.92,63.76 171.72,63.96 171.72,64.11 171.89,64.28 171.98,64.28 172.21,64.05 172.35,64.05 172.5,64.19 172.5,64.34 172.3,64.54 172.3,64.68 172.44,64.83 172.58,64.83 172.79,64.62 172.93,64.62 173.07,64.77 173.07,64.91 172.87,65.11 172.87,65.26 173.02,65.4 173.16,65.4 173.36,65.2 173.5,65.2 173.65,65.34 173.65,65.49 173.45,65.69 173.45,65.83 173.59,65.98 173.73,65.98 173.94,65.78 174.08,65.78 174.22,65.92 174.22,66.06 174.02,66.26 174.02,66.41 174.17,66.55 174.31,66.55 174.51,66.35 174.65,66.35 174.8,66.49 174.8,66.64 174.6,66.84 174.6,66.98 174.94,67.33 174.94,70 175.82,70.88 175.82,85.64 173.54,87.92 173.54,89.42 169.88,93.08 169.88,96.32 168.78,97.43 v1(168.78,98.98)
  BOTTOM w0.076: U9001.R5 169.07,102.39 169.07,101.05 169.07,101.05 169.07,99.73 168.78,99.44 v1(168.78,98.98)
  BOTTOM w0.102: v1(168.92,53.09) 168.57,52.74 168.46,52.74 168.36,52.84 168.36,53.81 168.69,54.14 168.69,55.27 169.1,55.68 JDIM1001.215
M_A_DQ53: length 69.6
  TOP w0.102: JDIM1000.224 171.36,55.71 172.57,54.49 172.57,51.61 v1(171.95,50.99)
  IN4 w0.102: v1(170.85,100.71) 170.42,100.28 170.42,98.91 176.16,93.16 176.16,88.92 178.7,86.38 178.7,69.7 177.81,68.81 177.81,64.95 173.1,60.23 173.1,52.13 v1(171.95,50.99)
  BOTTOM w0.076: U9001.P2 170.52,101.04 v1(170.85,100.71)
  BOTTOM w0.102: v1(171.95,50.99) 171.95,49.82 171.81,49.67 171.6,49.67 171.43,49.84 171.43,50.48 171.25,50.66 170.52,50.66 170.34,50.48 170.34,49.82 170.44,49.72 170.97,49.72 171.36,49.33 JDIM1001.224
M_A_DQ54: length 70.5
  TOP w0.102: v1(170.39,53.97) 169.77,53.97 169.32,53.53 169.07,53.53 168.82,53.78 168.82,54.36 169.19,54.74 169.19,54.96 169.01,55.15 168.81,55.15 168.45,54.8 168.18,54.8 168,54.97 168,55.25 168.36,55.61 JDIM1000.212
  IN4 w0.102: v1(170.39,53.97) 170.19,54.18 170.19,57.11 170.78,57.7 170.78,60.71 170.68,60.81 170.29,60.81 170.19,60.92 170.19,61.12 170.29,61.22 170.68,61.22 170.78,61.32 170.78,61.76 171.5,62.48 172.19,62.48 174,64.29 174.14,64.29 174.25,64.18 174.39,64.18 174.54,64.33 174.54,64.47 174.43,64.58 174.43,64.72 174.57,64.87 174.72,64.87 174.82,64.76 174.97,64.76 175.11,64.9 175.11,65.05 175,65.15 175,65.3 175.15,65.44 175.29,65.44 175.4,65.33 175.54,65.33 175.69,65.48 175.69,65.62 175.58,65.73 175.58,65.87 175.93,66.23 175.93,69.59 176.81,70.47 176.81,85.79 174.28,88.32 174.28,90.86 174.15,90.99 173.95,90.99 173.8,90.85 173.66,90.85 173.52,90.99 173.52,91.13 173.69,91.31 173.69,91.45 173.54,91.59 173.4,91.59 173.23,91.42 173.08,91.42 172.94,91.56 172.94,91.71 173.11,91.88 173.11,92.03 172.97,92.17 172.83,92.17 172.65,92 172.51,92 172.36,92.14 172.36,92.28 172.54,92.46 172.54,92.6 172.24,92.9 171.36,92.9 170.79,93.46 170.79,96.38 170.61,96.56 v1(170.61,97.16)
  BOTTOM w0.076: v1(170.61,97.16) 170.61,98.1 169.95,98.75 169.95,99.41 169.67,99.69 U9001.R1
  BOTTOM w0.102: v1(170.39,53.97) 169.58,53.16 169.58,50.26 169.12,49.79 168.77,49.79 168.36,49.38 JDIM1001.212
M_A_DQ55: length 68.8
  TOP w0.102: v1(173.73,53.55) 173.2,53.02 173.01,53.02 172.88,53.14 172.88,53.53 173.49,54.14 173.49,54.57 173.13,54.92 172.66,54.92 172.36,55.23 JDIM1000.228
  IN4 w0.102: v1(173.73,53.55) 173.43,53.86 173.43,54.14 173.72,54.43 173.72,54.64 173.43,54.93 173.43,55.18 173.53,55.28 174.07,55.28 174.17,55.38 174.17,55.61 174.1,55.69 173.53,55.69 173.43,55.79 173.43,55.99 173.53,56.1 174.1,56.1 174.17,56.17 174.17,56.43 174.1,56.5 173.53,56.5 173.43,56.6 173.43,56.81 173.53,56.91 174.1,56.91 174.17,56.98 174.17,57.24 174.1,57.32 173.5,57.32 173.43,57.39 173.43,57.62 173.54,57.73 174.05,57.73 174.15,57.83 174.15,60.16 173.9,60.41 173.9,60.56 178.14,64.81 178.14,68.68 179.03,69.57 179.03,86.52 176.49,89.06 176.49,93.35 170.85,98.99 v1(170.85,100.07)
  BOTTOM w0.076: v1(170.85,100.07) 170.52,100.39 U9001.P1
  BOTTOM w0.102: v1(173.73,53.55) 172.6,52.42 172.6,50.21 172.36,49.97 JDIM1001.228
M_A_DQ56: length 68.2
  TOP w0.102: v1(174.82,52.36) 174.28,52.91 174.28,54.41 173.36,55.34 JDIM1000.232
  IN4 w0.102: v1(174.82,52.36) 175.27,52.36 175.42,52.51 175.42,53.78 175.17,54.03 175.17,54.49 175.42,54.74 175.42,60.38 175.75,60.72 176.03,60.72 176.12,60.63 176.26,60.63 176.4,60.78 176.4,60.92 176.25,61.07 176.25,61.22 176.39,61.36 176.54,61.36 176.69,61.21 176.84,61.21 176.98,61.35 176.98,61.49 176.88,61.6 176.88,61.84 177.06,62.03 177.65,62.03 179.29,63.66 179.29,68.2 180.18,69.09 180.18,87 177.64,89.54 177.64,94.18 173.11,98.71 v1(172.19,98.71)
  BOTTOM w0.076: v1(172.19,98.71) 172.19,99.32 171.95,99.56 171.95,99.82 171.75,100.02 171.75,101.09 171.86,101.2 171.86,102.02 U9001.M4
  BOTTOM w0.102: v1(174.82,52.36) 174.32,51.85 173.59,51.85 173.36,51.61 JDIM1001.232
M_A_DQ57: length 64.4
  TOP w0.102: JDIM1000.233 173.6,49.88 173.36,50.12 173.18,50.12 173.01,50.3 173.01,52.08 173.21,52.28 v1(173.73,52.28)
  IN4 w0.102: v1(173.73,52.28) 173.73,51.83 173.84,51.72 174.12,51.72 174.28,51.87 174.28,54.8 174.66,55.18 174.66,60.64 178.63,64.61 178.63,68.48 179.51,69.37 179.51,86.72 176.97,89.26 176.97,93.4 173.57,96.81 v1(173.57,97.36)
  BOTTOM w0.076: v1(173.57,97.36) 173.57,98.31 172.88,98.99 172.88,99.26 172.26,99.88 172.26,100.09 172.18,100.17 U9001.M1
  BOTTOM w0.102: v1(173.73,52.28) 174.14,52.69 174.14,53.92 173.6,54.45 JDIM1001.233
M_A_DQ58: length 70
  TOP w0.102: v1(179.33,52.83) 179.33,53.42 178.56,54.2 178.56,54.34 178.79,54.58 178.79,54.75 178.62,54.92 178.45,54.92 178.21,54.68 178.07,54.68 177.85,54.9 JDIM1000.250
  IN4 w0.102: v1(179.33,52.83) 179.33,53.33 179.43,53.44 179.56,53.44 179.66,53.54 179.66,53.82 179.56,53.92 179.43,53.92 179.33,54.02 179.33,54.3 179.43,54.4 179.56,54.4 179.66,54.5 179.66,54.78 179.56,54.88 179.43,54.88 179.33,54.99 179.33,55.27 179.43,55.37 179.56,55.37 179.66,55.47 179.66,55.75 179.56,55.85 179.43,55.85 179.33,55.95 179.33,56.23 179.43,56.33 179.56,56.33 179.66,56.43 179.66,56.71 179.56,56.81 179.43,56.81 179.33,56.92 179.33,57.2 179.43,57.3 179.56,57.3 179.66,57.4 179.66,57.68 179.56,57.78 179.43,57.78 179.33,57.88 179.33,58.16 179.43,58.26 179.56,58.26 179.66,58.36 179.66,58.64 179.56,58.75 179.43,58.75 179.33,58.85 179.33,59.13 179.43,59.23 179.56,59.23 179.66,59.33 179.66,59.61 179.56,59.71 179.13,59.71 178.92,59.91 178.92,60.17 179.16,60.4 179.3,60.4 179.46,60.25 179.6,60.25 179.8,60.45 179.8,60.59 179.67,60.72 179.67,60.91 180.13,61.37 180.45,61.37 180.55,61.27 180.88,61.27 181.5,61.89 181.5,66.8 182.38,67.69 182.38,87.93 179.86,90.45 179.86,95.51 v1(173.37,102.01)
  BOTTOM w0.076: v1(173.37,102.01) 173.04,102.34 U9001.L4
  BOTTOM w0.102: v1(179.33,52.83) 179.74,52.42 179.74,51.23 178.55,50.05 177.85,49.35 JDIM1001.250
M_A_DQ59: length 66.9
  TOP w0.102: v1(178.09,51.62) 178.09,51.11 177.64,50.67 175.98,50.67 175.8,50.49 175.8,50.22 175.95,50.07 176.38,50.07 176.6,49.84 JDIM1000.245
  IN4 w0.102: v1(178.09,51.62) 178.87,52.4 178.87,59.48 178.52,59.83 178.52,60.23 181.17,62.88 181.17,66.94 182.05,67.83 182.05,87.79 179.53,90.31 179.53,95.26 174.08,100.71 v1(173.37,100.71)
  BOTTOM w0.076: U9001.L2 173.04,101.04 v1(173.37,100.71)
  BOTTOM w0.102: v1(178.09,51.62) 177.58,52.13 177.58,53.93 176.6,54.91 JDIM1001.245
M_A_DQ60: length 72.4
  TOP w0.102: JDIM1000.236 174.35,55.1 175.56,53.89 175.56,52.83 175.71,52.68 175.94,52.68 176.1,52.84 176.1,53.44 176.51,53.85 v1(176.66,53.85)
  IN4 w0.102: v1(171.74,99.16) 172.96,99.16 177.97,94.16 177.97,89.67 180.51,87.13 180.51,68.96 179.62,68.07 179.62,63.52 176,59.91 176,59.43 176.16,59.27 176.54,59.27 176.64,59.17 176.64,58.89 176.54,58.79 176.16,58.79 176.03,58.67 176.03,58.44 176.16,58.31 176.54,58.31 176.64,58.21 176.64,57.93 176.54,57.83 176.16,57.83 176.05,57.73 176.05,57.45 176.16,57.34 176.54,57.34 176.64,57.24 176.64,56.96 176.54,56.86 176.16,56.86 176.03,56.73 176.03,56.51 176.16,56.38 176.54,56.38 176.64,56.28 176.64,56 176.54,55.9 176.16,55.9 176.03,55.77 176.03,55.33 176.66,54.69 v1(176.66,53.85)
  BOTTOM w0.076: U9001.M5 171.6,102.4 171.6,102.32 171.6,102.32 171.6,101.7 171.6,101.7 171.6,99.87 171.74,99.72 v1(171.74,99.16)
  BOTTOM w0.102: JDIM1001.236 174.35,51.06 175.42,52.13 175.42,52.6 v1(176.66,53.85)
M_A_DQ61: length 66.8
  TOP w0.102: v1(174.82,53.63) 175.23,53.22 175.23,51.94 174.6,51.31 JDIM1000.237
  IN4 w0.102: v1(174.82,53.63) 174.61,53.85 174.61,54.49 175.04,54.92 175.04,60.55 177.06,62.58 177.15,62.58 177.37,62.36 177.52,62.36 177.66,62.5 177.66,62.64 177.47,62.84 177.47,62.98 177.61,63.13 177.75,63.13 177.95,62.93 178.09,62.93 178.24,63.07 178.24,63.22 178.04,63.41 178.04,63.56 178.19,63.7 178.33,63.7 178.52,63.51 178.67,63.51 178.81,63.65 178.81,63.79 178.62,63.99 178.62,64.13 178.96,64.47 178.96,68.34 179.84,69.23 179.84,86.86 177.3,89.4 177.3,94.21 173.7,97.81 v1(173.12,97.81)
  BOTTOM w0.076: v1(173.12,97.81) 173.12,98.38 172.59,98.9 172.59,99.24 172.11,99.73 172.11,99.97 171.9,100.17 171.9,100.76 U9001.M2
  BOTTOM w0.102: JDIM1001.237 174.6,55.64 175.01,55.23 175.01,55.08 174.86,54.92 174.05,54.92 173.9,54.77 173.9,54.57 174.05,54.41 175.17,54.41 175.29,54.29 175.29,54.1 v1(174.82,53.63)
M_A_DQ62: length 71.4
  TOP w0.102: JDIM1000.246 176.85,55.39 178.85,53.4 178.85,52.04 v1(179.33,51.56)
  IN4 w0.102: v1(173.37,102.66) 180.19,95.83 180.19,90.58 182.72,88.06 182.72,67.55 181.83,66.66 181.83,61.75 179.99,59.92 179.99,51.42 179.43,50.86 178.95,50.86 178.82,50.99 178.82,51.21 178.98,51.37 179.14,51.37 v1(179.33,51.56)
  BOTTOM w0.076: U9001.L5 173.04,102.99 v1(173.37,102.66)
  BOTTOM w0.102: JDIM1001.246 176.85,49.68 176.35,50.18 176.35,50.52 176.61,50.78 177.02,50.78 177.58,50.22 177.99,50.22 v1(179.33,51.56)
M_A_DQ63: length 66.6
  TOP w0.102: v1(178.09,52.89) 178.49,52.49 178.49,51.14 177.6,50.25 JDIM1000.249
  IN4 w0.102: v1(173.37,100.06) 173.64,100.34 173.95,100.34 179.2,95.08 179.2,90.17 181.72,87.65 181.72,67.96 180.84,67.07 180.84,63.01 178.07,60.25 178.07,59.81 178.54,59.34 178.54,57.66 178.44,57.56 178.18,57.56 178.09,57.47 178.09,57.16 178.16,57.08 178.44,57.08 178.54,56.98 178.54,56.7 178.44,56.6 178.19,56.6 178.09,56.5 178.09,56.22 178.19,56.12 178.44,56.12 178.54,56.02 178.54,55.74 178.44,55.63 178.19,55.63 178.09,55.53 178.09,55.23 178.16,55.15 178.44,55.15 178.54,55.05 178.54,54.77 178.44,54.67 178.19,54.67 178.09,54.57 178.09,54.29 178.19,54.19 178.44,54.19 178.54,54.08 178.54,53.81 178.44,53.7 178.19,53.7 178.09,53.6 v1(178.09,52.89)
  BOTTOM w0.076: v1(173.37,100.06) 173.04,100.39 U9001.L1
  BOTTOM w0.102: JDIM1001.249 177.6,54.39 178.02,53.97 178.02,53.61 178.24,53.4 178.57,53.4 178.7,53.27 178.7,53.02 178.57,52.89 v1(178.09,52.89)
M_A_DQSN0: length 84.2
  TOP w0.102: JDIM1000.11 116.1,49.8 114.32,51.59 114.32,53.41 114.54,53.63 114.83,53.63 v1(115,53.8)
  IN4 w0.076: 134.88,99.78 134.89,99.79 134.89,99.86 136.75,101.71 136.96,101.71 v1(137.07,101.61)
  IN4 w0.114: v1(115,53.8) 115,53.8 114.71,53.52 114.4,53.52 113.8,54.11 113.8,55.27 114.51,55.98 114.51,60.34 114.87,60.7 114.87,61.48 114.51,61.84 114.51,62.25 115.59,63.33 115.59,67.34 115.71,67.45 115.87,67.45 116.15,67.73 116.15,68.3 115.9,68.56 115.45,68.56 115.34,68.67 115.34,69.06 115.45,69.18 115.9,69.18 116.15,69.43 116.15,70.03 115.9,70.28 115.45,70.28 115.34,70.4 115.34,70.79 115.45,70.91 115.9,70.91 116.15,71.16 116.15,71.76 115.9,72.01 115.45,72.01 115.34,72.13 115.34,72.52 115.45,72.63 115.9,72.63 116.15,72.89 116.15,73.48 115.9,73.74 115.45,73.74 115.34,73.85 115.34,74.25 115.45,74.36 115.7,74.36 116.15,74.82 116.15,76.64 125.68,86.17 125.68,88.26 126.29,88.87 126.29,95.27 130.27,99.25 134.35,99.25 134.88,99.78
  BOTTOM w0.076: U9001.BR5 139.89,103.03 139.89,103.18 139.78,103.29 139.63,103.29 139.23,102.89 137.86,102.89 137.07,102.09 v1(137.07,101.61)
  BOTTOM w0.102: v1(115,53.8) 115,53.75 115.3,53.46 115.4,53.46 115.48,53.53 115.48,54.8 115.68,55 115.97,55 116.64,54.33 116.76,54.33 117.05,54.61 117.05,54.79 116.4,55.44 116.4,55.56 116.31,55.65 116.19,55.65 116.1,55.73 JDIM1001.11
M_A_DQSN1: length 77.1
  TOP w0.102: v1(119.75,52.66) 119.13,52.66 118.95,52.84 118.95,54.11 119.85,55 121.06,55 121.35,55.29 JDIM1000.32
  IN4 w0.114: v1(138.59,97.56) 137.63,97.56 136.35,96.29 132.3,96.29 129.73,93.72 129.73,84.93 120.85,76.04 120.85,65.24 120.41,64.8 120.41,62.5 119.02,61.11 119.02,57.8 119.62,57.2 119.62,56.71 119.02,56.11 119.02,55.39 119.32,55.08 119.32,54.6 119.02,54.29 119.02,52.86 119.21,52.66 v1(119.75,52.66)
  BOTTOM w0.076: v1(138.59,97.56) 140.08,97.56 140.24,97.72 142.66,100.14 142.66,100.51 142.24,100.94 142.24,101.46 U9001.BL3
  BOTTOM w0.102: JDIM1001.32 121.35,49.58 121.42,49.64 121.59,49.64 121.65,49.71 121.65,49.91 121.5,50.06 120.63,50.06 120.3,50.39 120.3,52.81 120.13,52.98 120.01,52.98 119.75,52.73 v1(119.75,52.66)
M_A_DQSN2: length 75.1
  TOP w0.102: v1(125.64,52.69) 125.55,52.6 125.09,52.6 124.8,52.3 124.8,51.37 126.6,49.56 JDIM1000.53
  IN4 w0.114: v1(140.68,96.51) 140.68,95.5 138.93,93.75 138.93,88.16 126.16,75.39 126.16,72.75 125.43,72.01 125.43,71.64 125.57,71.5 125.9,71.5 126.16,71.25 126.16,70.65 125.9,70.4 125.54,70.4 125.43,70.28 125.43,69.89 125.54,69.78 125.9,69.78 126.16,69.52 126.16,68.93 125.9,68.67 125.54,68.67 125.43,68.56 125.43,68.16 125.54,68.05 125.83,68.05 126.16,67.72 126.16,67.02 125.43,66.28 125.43,61.25 124.77,60.6 124.77,57.6 125.15,57.22 125.15,54.47 124.62,53.94 124.62,52.72 124.88,52.46 125.42,52.46 v1(125.64,52.69)
  BOTTOM w0.076: U9001.BG3 144.81,101.69 144.93,101.57 144.93,101.44 144.81,101.32 144.81,100.2 145.07,99.94 145.07,99.17 142.85,96.94 142.05,96.94 141.21,96.11 140.69,96.11 140.59,96.2 140.59,96.42 v1(140.68,96.51)
  BOTTOM w0.102: v1(125.64,52.69) 125.64,52.63 126.01,52.26 126.16,52.26 126.22,52.31 126.22,54.61 126.9,55.29 126.9,55.55 126.6,55.85 JDIM1001.53
M_A_DQSN3: length 73.4
  TOP w0.102: v1(129.63,51.9) 129.52,52.02 129.17,52.02 129,52.18 129,54.2 129.72,54.92 131.27,54.92 131.85,55.5 JDIM1000.74
  IN4 w0.114: v1(129.63,51.9) 129.66,51.92 130.17,51.92 130.36,52.12 130.36,61.84 130.66,62.14 130.66,74.68 142.01,86.02 142.01,92.4 145.95,96.34 145.95,96.78 145.95,96.79 v1(145.95,97.34)
  BOTTOM w0.076: U9001.BD3 147.33,101.39 147.33,100.2 147.64,99.89 147.64,98.29 146.29,96.93 146.1,96.93 145.95,97.08 v1(145.95,97.34)
  BOTTOM w0.102: v1(129.63,51.9) 129.63,51.95 129.92,52.23 130.08,52.23 130.23,52.08 130.23,51.25 129.83,50.84 129.83,50.38 130.07,50.13 130.89,50.13 131.33,50.58 131.63,50.58 132.15,50.06 132.15,49.62 132.09,49.56 131.92,49.56 131.85,49.49 JDIM1001.74
M_A_DQSN4: length 69.5
  TOP w0.102: v1(160.98,52.64) 160.88,52.54 160.54,52.54 160.31,52.31 160.31,51.05 160.6,50.76 160.88,50.76 160.99,50.65 160.99,50.38 160.81,50.2 159.88,50.2 159.6,49.93 JDIM1000.177
  IN4 w0.114: v1(160.98,52.64) 161.38,52.25 161.55,52.25 161.63,52.33 161.63,57.17 161.35,57.45 161.35,64.82 167.65,71.12 168.1,71.12 169.06,72.08 169.06,72.45 169.93,73.32 169.93,85.49 165.14,90.28 165.14,94.93 164.99,95.08 v1(164.7,95.08)
  BOTTOM w0.076: v1(164.7,95.08) 165.1,95.48 165.1,95.9 165.26,96.06 165.26,100.09 165.08,100.26 165.08,101.63 165.14,101.69 U9001.AA3
  BOTTOM w0.102: v1(160.98,52.64) 160.98,52.6 161.27,52.31 161.49,52.31 161.58,52.39 161.58,53.89 160.85,54.61 160.41,54.61 159.9,55.12 159.9,55.48 159.83,55.55 159.67,55.55 159.6,55.62 JDIM1001.177
M_A_DQSN5: length 71.2
  TOP w0.102: JDIM1000.198 164.85,55.71 165.15,55.41 165.15,54.9 165.89,54.16 165.89,51.27 165.79,51.17 165.68,51.17 165.31,51.54 v1(165.31,51.6)
  IN4 w0.114: v1(165.31,51.6) 165.7,51.21 165.9,51.21 166.2,51.51 166.2,57.94 166.47,58.2 166.47,62.55 172.74,68.82 172.74,70.92 173.62,71.8 173.62,85.49 171.75,87.36 171.75,88.53 168.19,92.08 168.19,94.98 168.01,95.16 v1(167.72,95.16)
  BOTTOM w0.076: U9001.U3 167.86,101.71 167.68,101.71 167.6,101.63 167.6,97.68 168.25,97.02 168.25,96.11 168.11,95.97 168.11,95.55 v1(167.72,95.16)
  BOTTOM w0.102: v1(165.31,51.6) 164.61,51.6 164.22,51.22 163.84,51.22 163.62,51 163.62,50.46 163.38,50.22 163.38,49.88 163.55,49.72 164.14,49.72 164.34,49.92 164.34,50.15 164.45,50.25 164.6,50.25 164.7,50.15 164.7,49.7 164.85,49.55 JDIM1001.198
M_A_DQSN6: length 70.6
  TOP w0.102: v1(170.39,52.7) 170.31,52.62 169.84,52.62 169.63,52.41 169.63,51.03 169.83,50.82 170.32,50.82 170.39,50.75 170.39,50.56 169.99,50.17 169.99,49.74 170.1,49.63 JDIM1000.219
  IN4 w0.114: v1(171.28,95.47) 171.57,95.47 172.12,94.92 172.12,93.91 173.51,92.51 174.52,92.51 174.77,92.27 174.77,88.33 177.31,85.79 177.31,70.28 176.42,69.39 176.42,65.52 174.59,63.69 174.09,63.69 172.39,62 171.86,62 171.27,61.4 171.27,57.72 171.62,57.36 171.62,56.93 171.39,56.7 170.96,56.7 170.68,56.42 170.68,55.85 170.93,55.59 171.49,55.59 171.62,55.46 171.62,54.97 171.04,54.39 171.04,52.46 170.89,52.31 170.78,52.31 v1(170.39,52.7)
  BOTTOM w0.076: U9001.P3 170.16,101.69 170.11,101.64 170.11,100.04 170.43,99.72 170.43,99.08 171.28,98.23 171.28,97.34 171.68,96.93 171.68,95.87 v1(171.28,95.47)
  BOTTOM w0.102: v1(170.39,52.7) 170.39,52.64 170.76,52.27 170.96,52.27 171.08,52.39 171.08,54.13 170.4,54.8 170.4,55.41 170.1,55.7 JDIM1001.219
M_A_DQSN7: length 69.2
  TOP w0.102: v1(176.66,52.58) 176.66,52.52 177.04,52.14 177.22,52.14 177.32,52.25 177.32,53.87 175.35,55.84 JDIM1000.240
  IN4 w0.114: v1(176.66,52.58) 177.06,52.18 177.29,52.18 177.34,52.23 177.34,60.55 180.11,63.32 180.11,67.86 180.99,68.75 180.99,87.33 178.45,89.87 178.45,94.6 176.08,96.97 175.47,96.97 174.26,98.18 v1(174.26,99.16)
  BOTTOM w0.076: v1(174.26,99.16) 174.26,99.04 174.09,98.86 173.85,98.86 172.79,99.93 172.79,100.1 172.63,100.26 172.63,101.46 172.55,101.54 172.55,101.71 172.62,101.79 172.82,101.79 U9001.L3
  BOTTOM w0.102: v1(176.66,52.58) 176.61,52.52 176.1,52.52 175.76,52.18 175.76,51.08 175.64,50.97 174.92,50.97 174.66,50.7 174.66,50.2 174.89,49.97 175.26,49.97 175.35,49.87 JDIM1001.240
M_A_DQSN8: length 72
  TOP w0.102: JDIM1000.95 137.1,49.37 137.19,49.46 137.28,49.46 137.4,49.59 137.4,49.73 137.18,49.94 136.05,49.94 135,50.99 135,51.81 135.27,52.08 135.41,52.08 135.49,52.16 135.49,52.38 135.3,52.57 134.76,52.57 134.43,52.25 v1(134.43,52.2)
  IN4 w0.114: v1(147.86,95.16) 147.86,94.22 146.39,92.74 146.39,84.43 135.28,73.32 135.28,71.24 135.03,71 135.03,55.26 135.41,54.87 135.41,52.48 135.13,52.2 v1(134.43,52.2)
  BOTTOM w0.076: v1(147.86,95.16) 148.25,95.16 149.84,96.75 149.84,101.46 149.93,101.55 149.93,101.7 149.85,101.77 149.64,101.77 U9001.BA3
  BOTTOM w0.102: JDIM1001.95 137.1,55.85 135.99,54.73 134.2,54.73 133.89,54.42 133.75,54.29 133.75,52.61 133.97,52.4 134.23,52.4 v1(134.43,52.2)
M_A_DQSP0: length 84.2
  TOP w0.102: JDIM1000.13 116.6,49.47 116.54,49.54 116.36,49.54 116.31,49.59 116.31,49.89 114.52,51.68 114.52,53.32 114.63,53.43 114.84,53.43 115,53.27 v1(115,53.17)
  IN4 w0.076: 134.71,99.95 134.72,99.96 134.79,99.96 136.45,101.63 136.73,101.91 136.84,102.02 v1(137.55,102.02)
  IN4 w0.114: 134.71,99.95 134.25,99.49 130.17,99.49 126.05,95.37 126.05,88.97 125.44,88.36 125.44,86.27 115.91,76.74 115.91,74.92 115.6,74.6 115.35,74.6 115.09,74.35 115.09,73.75 115.35,73.5 115.8,73.5 115.91,73.38 115.91,72.99 115.8,72.87 115.35,72.87 115.1,72.62 115.1,72.03 115.35,71.77 115.8,71.77 115.91,71.66 115.91,71.26 115.8,71.15 115.35,71.15 115.1,70.89 115.1,70.3 115.35,70.04 115.8,70.04 115.91,69.93 115.91,69.53 115.8,69.42 115.35,69.42 115.1,69.16 115.1,68.57 115.35,68.32 115.8,68.32 115.91,68.2 115.91,67.83 115.77,67.69 115.61,67.69 115.35,67.44 115.35,63.43 114.27,62.35 114.27,61.74 114.62,61.38 114.62,60.8 114.27,60.44 114.27,56.08 113.56,55.37 113.56,54.01 114.3,53.27 114.89,53.27 v1(115,53.17)
  BOTTOM w0.076: v1(137.55,102.02) 137.56,102.03 137.56,102.38 137.92,102.73 138.99,102.73 139.12,102.6 139.12,102.45 139.3,102.27 139.55,102.27 U9001.BP5
  BOTTOM w0.102: v1(115,53.17) 115.08,53.25 115.48,53.25 115.68,53.45 115.68,54.71 115.76,54.8 115.88,54.8 116.56,54.12 116.85,54.12 117.25,54.53 117.25,54.87 116.6,55.52 JDIM1001.13
M_A_DQSP1: length 77.2
  TOP w0.102: JDIM1000.34 121.85,55.74 121.72,55.61 121.67,55.61 121.56,55.49 121.56,55.21 121.15,54.8 119.93,54.8 119.16,54.02 119.16,52.92 119.21,52.87 119.32,52.87 v1(119.75,53.3)
  IN4 w0.114: v1(119.75,53.3) 119.75,53.21 119.45,52.91 119.31,52.91 119.26,52.96 119.26,54.19 119.56,54.5 119.56,55.18 119.26,55.49 119.26,56.01 119.86,56.61 119.86,57.3 119.26,57.9 119.26,61.01 120.65,62.4 120.65,64.7 121.09,65.14 121.09,75.94 129.97,84.83 129.97,93.62 132.4,96.04 136.45,96.04 137.73,97.32 137.94,97.32 138.15,97.11 v1(138.15,97.11)
  BOTTOM w0.076: v1(138.15,97.11) 138.71,97.11 139.01,97.4 140.14,97.4 142.81,100.08 142.81,100.58 142.39,101 142.39,101.49 142.58,101.69 U9001.BK3
  BOTTOM w0.102: JDIM1001.34 121.85,49.99 121.58,50.26 120.72,50.26 120.5,50.48 120.5,52.89 120.21,53.18 119.87,53.18 v1(119.75,53.3)
M_A_DQSP2: length 75.1
  TOP w0.102: JDIM1000.55 127.1,49.51 127,49.61 126.84,49.61 125,51.45 125,52.22 125.18,52.4 125.3,52.4 v1(125.64,52.06)
  IN4 w0.114: v1(125.64,52.06) 125.47,52.22 124.78,52.22 124.38,52.62 124.38,54.04 124.91,54.57 124.91,57.12 124.53,57.5 124.53,60.7 125.18,61.35 125.18,66.38 125.92,67.12 125.92,67.62 125.73,67.81 125.44,67.81 125.18,68.06 125.18,68.66 125.44,68.91 125.8,68.91 125.92,69.03 125.92,69.42 125.8,69.53 125.44,69.53 125.18,69.79 125.18,70.38 125.44,70.64 125.8,70.64 125.92,70.75 125.92,71.15 125.8,71.26 125.47,71.26 125.18,71.54 125.18,72.11 125.92,72.85 125.92,75.49 138.69,88.26 138.69,93.85 140.44,95.6 140.44,95.85 v1(140.23,96.06)
  BOTTOM w0.076: U9001.BF3 145.08,101.51 145.08,101.37 144.97,101.26 144.97,100.26 145.23,100.01 145.23,99.11 142.91,96.79 142.11,96.79 141.27,95.95 140.62,95.95 140.52,96.06 v1(140.23,96.06)
  BOTTOM w0.102: v1(125.64,52.06) 126.25,52.06 126.42,52.23 126.42,54.53 127.1,55.21 JDIM1001.55
M_A_DQSP3: length 73.4
  TOP w0.102: v1(129.63,52.54) 129.63,52.49 129.37,52.22 129.25,52.22 129.2,52.27 129.2,54.11 129.8,54.71 131.36,54.71 132.07,55.42 132.25,55.42 132.35,55.53 JDIM1000.76
  IN4 w0.114: v1(145.5,96.89) 145.71,96.69 145.71,96.44 141.76,92.5 141.76,86.12 130.42,74.78 130.42,62.24 130.12,61.94 130.12,52.22 130.07,52.16 129.93,52.16 129.63,52.46 v1(129.63,52.54)
  BOTTOM w0.076: U9001.BC3 147.53,101.69 147.48,101.64 147.48,100.26 147.8,99.95 147.8,98.23 146.35,96.78 146.03,96.78 145.92,96.89 v1(145.5,96.89)
  BOTTOM w0.102: JDIM1001.76 132.35,50.15 131.72,50.78 131.25,50.78 130.8,50.34 130.15,50.34 130.03,50.46 130.03,50.76 130.44,51.16 130.44,52.16 130.16,52.43 129.74,52.43 v1(129.63,52.54)
M_A_DQSP4: length 69.5
  TOP w0.102: v1(160.98,52.01) 160.98,52.06 160.7,52.34 160.62,52.34 160.51,52.23 160.51,51.14 160.69,50.96 160.97,50.96 161.2,50.73 161.2,50.29 160.9,50 159.96,50 159.81,49.84 159.81,49.62 159.87,49.56 160.03,49.56 160.1,49.48 JDIM1000.179
  IN4 w0.114: v1(164.7,95.71) 165.39,95.03 165.39,90.38 170.17,85.59 170.17,73.22 169.3,72.35 169.3,71.98 168.2,70.88 167.75,70.88 161.6,64.72 161.6,57.55 161.87,57.27 161.87,52.23 161.65,52.01 v1(160.98,52.01)
  BOTTOM w0.076: v1(164.7,95.71) 165.1,96.12 165.1,100.03 164.93,100.2 164.93,101.39 U9001.AB3
  BOTTOM w0.102: JDIM1001.179 160.1,55.2 160.5,54.81 160.94,54.81 161.78,53.97 161.78,52.31 161.58,52.1 161.08,52.1 v1(160.98,52.01)
M_A_DQSP5: length 71.1
  TOP w0.102: JDIM1000.200 165.36,54.99 166.1,54.25 166.1,51.19 165.88,50.97 v1(165.31,50.97)
  IN4 w0.114: v1(167.72,95.79) 168.43,95.08 168.43,92.18 171.99,88.63 171.99,87.46 173.86,85.59 173.86,71.7 172.98,70.82 172.98,68.72 166.71,62.45 166.71,58.1 166.44,57.84 166.44,51.41 166,50.97 v1(165.31,50.97)
  BOTTOM w0.076: U9001.V3 167.45,101.39 167.45,97.62 168.1,96.96 168.1,96.17 v1(167.72,95.79)
  BOTTOM w0.102: v1(165.31,50.97) 165.31,51.03 164.94,51.4 164.69,51.4 164.31,51.01 163.92,51.01 163.82,50.91 163.82,50.37 163.59,50.14 163.59,49.97 163.63,49.92 164.06,49.92 164.14,50 164.14,50.23 164.36,50.45 164.68,50.45 164.9,50.23 164.9,49.79 165.36,49.33 JDIM1001.200
M_A_DQSP6: length 70.5
  TOP w0.102: v1(170.39,52.07) 170.04,52.42 169.92,52.42 169.83,52.32 169.83,51.11 169.92,51.03 170.4,51.03 170.59,50.83 170.59,50.48 170.2,50.08 170.2,49.83 170.39,49.63 170.55,49.63 170.6,49.58 JDIM1000.221
  IN4 w0.114: v1(170.39,52.07) 170.99,52.07 171.28,52.36 171.28,54.29 171.86,54.87 171.86,55.56 171.59,55.83 171.03,55.83 170.92,55.95 170.92,56.32 171.06,56.46 171.49,56.46 171.86,56.83 171.86,57.46 171.51,57.82 171.51,61.3 171.96,61.75 172.49,61.75 174.19,63.45 174.69,63.45 176.66,65.42 176.66,69.29 177.55,70.18 177.55,85.89 175.01,88.43 175.01,92.37 174.62,92.76 173.61,92.76 172.36,94.01 172.36,95.02 v1(171.28,96.1)
  BOTTOM w0.076: U9001.R3 169.96,101.39 169.96,99.98 170.28,99.66 170.28,99.01 171.12,98.17 171.12,97.27 171.53,96.87 171.53,96.36 v1(171.28,96.1)
  BOTTOM w0.102: v1(170.39,52.07) 171.04,52.07 171.28,52.31 171.28,54.21 170.6,54.88 JDIM1001.221
M_A_DQSP7: length 69.2
  TOP w0.102: v1(176.66,51.94) 177.31,51.94 177.53,52.16 177.53,53.96 175.85,55.63 JDIM1000.242
  IN4 w0.114: v1(176.66,51.94) 177.39,51.94 177.58,52.13 177.58,60.45 180.35,63.22 180.35,67.76 181.24,68.65 181.24,87.43 178.7,89.97 178.7,94.7 176.18,97.21 175.57,97.21 174.51,98.28 174.51,98.5 v1(174.71,98.71)
  BOTTOM w0.076: U9001.M3 172.47,101.39 172.47,100.2 172.64,100.04 172.64,99.86 173.79,98.71 v1(174.71,98.71)
  BOTTOM w0.102: JDIM1001.242 175.85,49.46 175.75,49.56 175.69,49.56 175.56,49.69 175.56,49.96 175.34,50.17 174.97,50.17 174.86,50.28 174.86,50.61 175.01,50.76 175.73,50.76 175.96,50.99 175.96,52.1 176.18,52.32 176.34,52.32 176.66,52 v1(176.66,51.94)
M_A_DQSP8: length 72
  TOP w0.102: JDIM1000.97 137.61,49.81 137.27,50.15 136.13,50.15 135.21,51.07 135.21,51.73 135.36,51.87 135.49,51.87 135.69,52.08 135.69,52.47 135.38,52.78 134.48,52.78 v1(134.43,52.83)
  IN4 w0.114: v1(134.43,52.83) 134.82,52.44 135.03,52.44 135.17,52.58 135.17,54.77 134.79,55.16 134.79,71.1 135.04,71.34 135.04,73.42 146.15,84.53 146.15,92.84 147.62,94.32 147.62,94.55 147.52,94.65 v1(147.35,94.65)
  BOTTOM w0.076: v1(147.35,94.65) 147.96,94.65 148.32,95 150,96.68 150,101.39 U9001.AY3
  BOTTOM w0.102: JDIM1001.97 137.61,55.71 137.45,55.56 137.1,55.56 136.08,54.53 134.29,54.53 133.96,54.2 133.96,52.7 134.06,52.6 134.2,52.6 v1(134.43,52.83)
M_A_ODT0: length 64.3
  IN4 w0.114: v1(161.23,95.39) 161.84,94.79 161.84,93.41 162.39,92.87 162.39,89.42 165.43,86.37 165.43,75.67 156.32,66.57 156.32,51.52 v1(155.38,50.57)
  BOTTOM w0.076: v1(161.23,95.39) 162.58,96.74 162.58,101.41 U9001.AD3
  BOTTOM w0.102: JDIM1001.155 154.1,55.64 154.72,55.03 154.72,51.23 v1(155.38,50.57)
M_A_ODT1: length 61.8
  IN4 w0.114: v1(161.23,98.57) 161.23,98.1 161.39,97.95 161.83,97.95 162.01,97.77 162.01,96.89 162.61,96.29 162.61,93.54 163.07,93.07 163.07,89.85 166.88,86.04 166.88,74.36 160.93,68.41 160.77,68.41 160.63,68.55 160.47,68.55 160.28,68.36 160.28,68.2 160.42,68.06 160.42,67.9 160.23,67.71 160.07,67.71 159.93,67.85 159.77,67.85 159.58,67.66 159.58,67.5 159.72,67.36 159.72,67.2 159.53,67.01 159.37,67.01 159.23,67.15 159.07,67.15 158.88,66.96 158.88,66.8 159.01,66.66 159.01,66.5 158.83,66.31 158.66,66.31 158.53,66.45 158.37,66.45 158.18,66.26 158.18,66.1 158.31,65.96 158.31,65.8 158.19,65.68 157.92,65.68 157.77,65.52 157.77,60.64 157.92,60.49 157.92,54.92 157.95,54.9 v1(157.95,54.02)
  BOTTOM w0.076: v1(161.23,98.57) 161.62,98.95 161.62,99.21 161.78,99.37 161.78,100.1 161.68,100.2 161.68,100.67 161.83,100.82 161.83,102.14 162.02,102.34 U9001.AE4
  BOTTOM w0.102: v1(157.95,54.02) 157.36,54.61 156.61,54.61 155.6,55.62 JDIM1001.161
M_A_ODT2: length 66.2
  TOP w0.102: JDIM1000.155 154.1,49.48 154.74,50.11 155.63,50.11 155.99,50.47 155.99,51.77 v1(156.97,52.75)
  IN4 w0.114: v1(156.97,52.75) 157.47,53.25 157.47,60.3 157.35,60.42 157.35,66.14 160.48,69.27 160.64,69.27 160.84,69.08 161,69.08 161.19,69.27 161.19,69.43 160.99,69.62 160.99,69.78 161.18,69.97 161.34,69.97 161.54,69.78 161.7,69.78 161.89,69.97 161.89,70.13 161.69,70.32 161.69,70.48 161.88,70.67 162.04,70.67 162.24,70.48 162.4,70.48 162.59,70.67 162.59,70.83 162.39,71.02 162.39,71.18 162.58,71.37 162.75,71.37 162.94,71.18 163.1,71.18 163.29,71.37 163.29,71.53 163.1,71.72 163.1,71.88 163.28,72.07 163.45,72.07 163.64,71.88 163.8,71.88 163.99,72.07 163.99,72.23 163.8,72.42 163.8,72.58 163.98,72.77 164.15,72.77 164.34,72.58 164.5,72.58 164.69,72.77 164.69,72.93 164.5,73.12 164.5,73.28 164.69,73.47 164.85,73.47 165.04,73.28 165.2,73.28 165.39,73.47 165.39,73.63 165.2,73.82 165.2,73.99 165.39,74.17 165.55,74.17 165.74,73.98 165.9,73.98 166.09,74.17 166.09,74.33 165.9,74.52 165.9,74.69 166.07,74.86 166.33,74.86 166.46,75 166.46,86.08 162.86,89.68 162.86,92.99 162.38,93.47 162.38,96.16 v1(161.23,97.3)
  BOTTOM w0.076: U9001.AE1 162.12,98.19 v1(161.23,97.3)
M_A_ODT3: length 69.3
  TOP w0.102: v1(157.95,51.86) 157.95,51.85 155.6,49.51 JDIM1000.161
  IN4 w0.114: v1(163.3,102.66) 162.79,102.15 162.79,96.89 163.08,96.61 163.08,93.66 163.5,93.23 163.5,90.15 167.72,85.94 167.72,74.02 158.61,64.91 158.61,61.43 159.14,60.9 159.14,57.63 158.79,57.28 158.79,53.5 158.9,53.38 159.07,53.38 159.19,53.27 159.19,53 159.07,52.89 158.9,52.89 158.79,52.77 158.79,52.35 159.04,52.1 159.04,49.58 158.92,49.46 158.02,49.46 157.89,49.59 157.89,49.84 158.05,50 158.35,50 158.48,50.12 158.48,51.58 158.19,51.86 v1(157.95,51.86)
  BOTTOM w0.076: v1(163.3,102.66) 162.98,102.34 U9001.AD4
M_B_A0: length 89.5
  TOP w0.102: v1(149.96,34.43) 150.36,34.83 150.36,35.4 150.02,35.74 150.02,38.19 149.35,38.86 JDIM1003.144
  IN1 w0.076: v1(158.9,105.92) 159.28,105.54 159.28,104.42 159.6,104.1 159.6,100.71 159.78,100.54 159.78,88.47 159.89,88.36
  IN1 w0.152: 159.89,88.36 160.29,87.96 160.29,82.6 152.86,75.17 152.86,65.44 152.29,64.87 152.29,56.14 153.29,55.14 153.29,47.97 151,45.68 151,36.44 150.47,35.92 150.47,34.94 v1(149.96,34.43)
  BOTTOM w0.076: U9001.AJ9 158.58,105.6 v1(158.9,105.92)
  BOTTOM w0.102: JDIM1002.144 149.35,33.14 148.57,33.92 148.57,34.73 148.69,34.86 148.94,34.86 149.07,34.72 149.07,34.11 149.21,33.97 149.5,33.97 v1(149.96,34.43)
M_B_A1: length 90.7
  TOP w0.102: JDIM1003.133 146.6,33.27 146.45,33.43 146.15,33.43 146.02,33.55 146.02,33.84 146.12,33.94 146.52,33.94 146.87,33.59 147.05,33.59 147.18,33.72 147.18,33.87 146.69,34.36 145.73,34.36 145.62,34.26 145.62,33.9 145.5,33.77 145.32,33.77 145.14,33.95 145.14,34.33 v1(144.64,34.84)
  IN1 w0.076: 157.08,102.29 157.08,103.01 157.39,103.31 v1(157.46,103.31)
  IN1 w0.152: v1(144.64,34.84) 145.19,35.39 145.19,35.9 146.1,36.81 146.1,47.17 146.51,47.58 146.51,48.95 147.58,50.02 147.58,52.1 147.28,52.41 147.28,52.69 147.58,52.99 147.58,53.31 147.43,53.46 147.12,53.46 146.97,53.61 146.97,53.84 147.12,53.99 147.43,53.99 147.58,54.15 147.58,54.5 147.42,54.66 147.42,55.15 147.27,55.3 147.1,55.3 146.95,55.46 146.95,55.71 147.07,55.84 147.27,55.84 147.42,55.99 147.42,56.22 147.27,56.37 147.07,56.37 146.95,56.5 146.95,56.75 147.1,56.9 147.27,56.9 147.42,57.06 147.42,75.6 156.24,84.41 156.24,91.5 156.65,91.91 156.65,101.74 157.08,102.17 157.08,102.29
  BOTTOM w0.076: U9001.AK6 157.79,103.64 v1(157.46,103.31)
  BOTTOM w0.102: v1(144.64,34.84) 145.45,35.64 145.45,38.19 146.6,39.35 JDIM1002.133
M_B_A2: length 92.5
  TOP w0.102: v1(145.29,34.76) 145.29,35.12 146.35,36.18 JDIM1003.132
  IN1 w0.076: v1(157.46,102.66) 157.46,102.25 156.9,101.68 156.9,91.51 156.64,91.24 156.64,90.99
  IN1 w0.152: v1(145.29,34.76) 144.25,33.71 144.25,33.49 144.45,33.29 144.74,33.29 145.19,33.75 145.47,33.75 145.83,33.39 146.36,33.39 146.59,33.62 146.59,34.13 146.37,34.35 146.37,35.02 145.83,35.56 145.83,35.84 146.6,36.61 146.6,38.68 146.75,38.83 146.86,38.83 147.01,38.99 147.01,39.21 146.86,39.37 146.75,39.37 146.6,39.52 146.6,39.75 146.75,39.9 146.86,39.9 147.01,40.05 147.01,40.28 146.86,40.43 146.75,40.43 146.6,40.59 146.6,41.08 147.01,41.49 147.01,47.78 147.43,48.2 148.37,48.2 148.57,48.41 148.57,48.73 148.08,49.23 148.08,49.62 148.57,50.12 148.57,54.59 147.92,55.25 147.92,75.39 156.64,84.11 156.64,90.99
  BOTTOM w0.076: v1(157.46,102.66) 157.79,102.99 U9001.AK5
  BOTTOM w0.102: JDIM1002.132 146.35,33.07 146.08,33.34 146.08,33.49 146.21,33.62 146.21,34 145.96,34.25 145.7,34.25 145.24,33.8 145.02,33.8 144.8,34.01 144.8,34.27 v1(145.29,34.76)
M_B_A3: length 91.3
  TOP w0.102: v1(144.62,36.09) 144.42,36.29 144.23,36.29 144.05,36.11 144.05,35.9 144.18,35.77 144.18,35.53 144.02,35.37 144.02,35.13 144.18,34.97 144.18,34.37 144.3,34.25 144.52,34.25 145.41,33.37 145.87,33.37 146.1,33.14 JDIM1003.131
  IN1 w0.076: 155.86,91.63 155.86,92.01 155.81,92.06 155.81,101.23 156.5,101.91 156.5,102.45 v1(156.7,102.66)
  IN1 w0.152: v1(144.62,36.09) 144.68,36.09 145.61,37.02 145.61,41.14 145.12,41.63 145.12,47.08 145.32,47.28 145.32,47.54 145.12,47.74 145.12,47.97 145.24,48.1 145.87,48.1 146.02,48.25 146.02,48.48 145.87,48.63 145.45,48.63 145.32,48.76 145.32,49.07 145.49,49.24 146.1,49.24 146.34,49.48 146.34,49.71 146.26,49.8 146.26,50.03 146.48,50.26 146.82,50.26 146.97,50.41 146.97,50.74 146.68,51.03 146.68,52.9 146.45,53.13 146.45,56.96 146.93,57.43 146.93,57.96 146.77,58.12 146.62,58.12 146.45,58.29 146.45,58.52 146.6,58.67 146.78,58.67 146.93,58.82 146.93,59.05 146.78,59.2 146.6,59.2 146.45,59.36 146.45,59.59 146.6,59.74 146.78,59.74 146.93,59.89 146.93,60.12 146.78,60.27 146.6,60.27 146.45,60.42 146.45,60.65 146.6,60.8 146.78,60.8 146.93,60.96 146.93,61.19 146.78,61.34 146.6,61.34 146.45,61.49 146.45,61.72 146.6,61.87 146.78,61.87 146.93,62.02 146.93,62.25 146.78,62.41 146.6,62.41 146.45,62.56 146.45,62.79 146.6,62.94 146.78,62.94 146.93,63.09 146.93,63.32 146.78,63.47 146.6,63.47 146.45,63.62 146.45,63.85 146.6,64.01 146.78,64.01 146.93,64.16 146.93,64.39 146.78,64.54 146.6,64.54 146.45,64.69 146.45,64.92 146.6,65.07 146.78,65.07 146.93,65.22 146.93,65.45 146.78,65.61 146.6,65.61 146.45,65.76 146.45,65.99 146.6,66.14 146.78,66.14 146.93,66.29 146.93,66.52 146.78,66.67 146.6,66.67 146.45,66.82 146.45,67.05 146.6,67.21 146.78,67.21 146.93,67.36 146.93,75.8 155.86,84.74 155.86,91.63
  BOTTOM w0.076: v1(156.7,102.66) 157.03,102.99 U9001.AL5
  BOTTOM w0.102: v1(144.62,36.09) 145.07,36.54 145.07,38.32 146.1,39.36 JDIM1002.131
M_B_A4: length 93.1
  TOP w0.102: v1(144.62,36.73) 145.39,35.96 145.73,35.96 146.13,36.36 146.13,38.9 145.96,39.08 145.62,39.08 145.35,39.35 JDIM1003.128
  IN1 w0.076: v1(156.7,103.29) 156.47,103.29 156.24,103.06 156.24,101.91 155.61,101.28 155.61,93.31 155.57,93.28 155.57,93.02
  IN1 w0.152: 155.57,93.02 155.57,85.14 145.96,75.53 145.96,75.03 146.11,74.88 146.28,74.88 146.43,74.73 146.43,74.5 146.28,74.35 146.11,74.35 145.96,74.2 145.96,73.97 146.11,73.81 146.28,73.81 146.43,73.66 146.43,73.43 146.28,73.28 146.11,73.28 145.96,73.13 145.96,72.9 146.11,72.75 146.28,72.75 146.43,72.6 146.43,72.37 146.28,72.21 146.11,72.21 145.96,72.06 145.96,71.83 146.11,71.68 146.28,71.68 146.43,71.53 146.43,71.3 146.28,71.15 146.11,71.15 145.96,71 145.96,70.77 146.11,70.61 146.28,70.61 146.43,70.46 146.43,70.23 146.28,70.08 146.11,70.08 145.96,69.93 145.96,69.7 146.11,69.55 146.28,69.55 146.43,69.39 146.43,69.17 146.28,69.01 146.11,69.01 145.96,68.86 145.96,68.63 146.11,68.48 146.28,68.48 146.43,68.33 146.43,67.74 145.96,67.26 145.96,62.52 145.8,62.36 145.6,62.36 145.45,62.21 145.45,61.98 145.6,61.83 145.8,61.83 145.96,61.68 145.96,61.45 145.8,61.3 145.6,61.3 145.45,61.14 145.45,60.92 145.6,60.76 145.8,60.76 145.96,60.61 145.96,60.38 145.8,60.23 145.6,60.23 145.45,60.08 145.45,59.85 145.6,59.7 145.8,59.7 145.96,59.54 145.96,59.32 145.8,59.16 145.6,59.16 145.45,59.01 145.45,58.78 145.6,58.63 145.8,58.63 145.96,58.48 145.96,58.25 145.8,58.1 145.6,58.1 145.45,57.94 145.45,57.72 145.6,57.56 145.8,57.56 145.96,57.41 145.96,57.18 145.8,57.03 145.6,57.03 145.45,56.88 145.45,56.65 145.6,56.5 145.8,56.5 145.96,56.34 145.96,56.11 145.8,55.96 145.6,55.96 145.45,55.81 145.45,55.43 145.96,54.92 145.96,52.74 146.18,52.51 146.18,50.66 144.82,49.3 144.82,48.43 144.62,48.22 144.62,41.42 145.11,40.93 145.11,37.22 v1(144.62,36.73)
  BOTTOM w0.076: v1(156.7,103.29) 157.04,103.63 U9001.AL6
  BOTTOM w0.102: v1(144.62,36.73) 144.18,36.3 144.18,34.12 145.35,32.95 JDIM1002.128
M_B_A5: length 92.5
  TOP w0.102: JDIM1003.126 144.85,39.38 144.69,39.21 144.05,39.21 143.92,39.08 143.92,38.83 144.05,38.7 144.43,38.7 144.69,38.44 144.98,38.44 145.26,38.72 145.55,38.72 145.75,38.52 145.75,37.23 145.57,37.06 145.31,37.06 145.19,37.17 145.19,37.82 145.02,38 v1(144.62,38)
  IN1 w0.076: 155.3,93.02 155.3,93.28 155.45,93.42 155.45,102.94 v1(155.81,103.31)
  IN1 w0.152: 155.3,93.02 155.3,85.58 145.46,75.73 145.46,72.49 145.33,72.36 145.1,72.36 144.95,72.21 144.95,71.98 145.1,71.83 145.33,71.83 145.46,71.7 145.46,71.42 145.33,71.3 145.1,71.3 144.95,71.15 144.95,70.92 145.1,70.76 145.33,70.76 145.46,70.64 145.46,70.36 145.33,70.23 145.1,70.23 144.95,70.08 144.95,69.85 145.1,69.7 145.31,69.7 145.46,69.55 145.46,69.32 145.31,69.16 145.1,69.16 144.95,69.01 144.95,68.78 145.1,68.63 145.31,68.63 145.46,68.48 145.46,68.25 145.31,68.1 145.1,68.1 144.95,67.95 144.95,67.72 145.1,67.56 145.31,67.56 145.46,67.41 145.46,67.18 145.31,67.03 145.1,67.03 144.95,66.88 144.95,66.65 145.1,66.5 145.31,66.5 145.46,66.34 145.46,66.12 145.31,65.96 145.1,65.96 144.95,65.81 144.95,65.58 145.1,65.43 145.31,65.43 145.46,65.28 145.46,65.05 145.31,64.9 145.1,64.9 144.95,64.74 144.95,64.52 145.1,64.36 145.31,64.36 145.46,64.21 145.46,63.98 145.31,63.83 145.1,63.83 144.95,63.68 144.95,63.45 145.1,63.3 145.31,63.3 145.46,63.14 145.46,62.92 144.95,62.42 144.95,53.18 145.33,52.8 145.33,50.6 144.74,50.01 144.18,50.01 143.92,49.75 143.92,49.47 144.33,49.06 144.33,48.76 144.18,48.6 143.96,48.6 143.81,48.45 143.81,48 144.13,47.68 144.13,41.22 144.62,40.73 v1(144.62,38)
  BOTTOM w0.076: v1(155.81,103.31) 156.14,103.64 U9001.AM6
  BOTTOM w0.102: JDIM1002.126 144.85,33.07 143.98,33.94 143.98,37.36 v1(144.62,38)

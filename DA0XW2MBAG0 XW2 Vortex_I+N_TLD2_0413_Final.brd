# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Nets (continued)
VMB_DQ46: U2000.E30(FBB_D46) VRAM2502.M11(DQ22 | DQ14)
VMB_DQ47: U2000.D30(FBB_D47) VRAM2502.M13(DQ23 | DQ15)
VMB_DQ48: U2000.A32(FBB_D48) VRAM2502.A11(DQ8 | DQ16)
VMB_DQ49: U2000.C31(FBB_D49) VRAM2502.A13(DQ9 | DQ17)
VMB_DQ50: U2000.C32(FBB_D50) VRAM2502.B11(DQ10 | DQ18)
VMB_DQ51: U2000.B32(FBB_D51) VRAM2502.B13(DQ11 | DQ19)
VMB_DQ52: U2000.D29(FBB_D52) VRAM2502.E11(DQ12 | DQ20)
VMB_DQ53: U2000.A29(FBB_D53) VRAM2502.E13(DQ13 | DQ21)
VMB_DQ54: U2000.C29(FBB_D54) VRAM2502.F11(DQ14 | DQ22)
VMB_DQ55: U2000.B29(FBB_D55) VRAM2502.F13(DQ15 | DQ23)
VMB_DQ56: U2000.B21(FBB_D56) VRAM2502.A4(DQ0 | DQ24)
VMB_DQ57: U2000.C23(FBB_D57) VRAM2502.A2(DQ1 | DQ25)
VMB_DQ58: U2000.A21(FBB_D58) VRAM2502.B4(DQ2 | DQ26)
VMB_DQ59: U2000.C21(FBB_D59) VRAM2502.B2(DQ3 | DQ27)
VMB_DQ60: U2000.B24(FBB_D60) VRAM2502.E4(DQ4 | DQ28)
VMB_DQ61: U2000.C24(FBB_D61) VRAM2502.E2(DQ5 | DQ29)
VMB_DQ62: U2000.B26(FBB_D62) VRAM2502.F4(DQ6 | DQ30)
VMB_DQ63: U2000.C26(FBB_D63) VRAM2502.F2(DQ7 | DQ31)
VMB_WCK01: U2000.F8(FBB_WCK01) VRAM2503.D4(WCK01 | WCK23)
VMB_WCK01#: U2000.E8(FBB_WCK01*) VRAM2503.D5(WCK01# | WCK23#)
VMB_WCK23: U2000.A5(FBB_WCK23) VRAM2503.P4(WCK23 | WCK01)
VMB_WCK23#: U2000.A6(FBB_WCK23*) VRAM2503.P5(WCK23# | WCK01#)
VMB_WCK45: U2000.D24(FBB_WCK45) VRAM2502.P4(WCK23 | WCK01)
VMB_WCK45#: U2000.D25(FBB_WCK45*) VRAM2502.P5(WCK23# | WCK01#)
VMB_WCK67: U2000.B27(FBB_WCK67) VRAM2502.D4(WCK01 | WCK23)
VMB_WCK67#: U2000.C27(FBB_WCK67*) VRAM2502.D5(WCK01# | WCK23#)
VOLTAGE_ADC: PC12002.2 PR12001.1 PR12003.1 R6025.2
VOLTAGE_ADC_R: C6011.2 R6025.1 U6001.C2(GPIO41/ADC4)
VR_SCL_P: PR19006.1 PR19014.1 U6001.D5(GPIO33/I2C5_SCL0/C\T\S\)
VR_SDA_P: PR19007.1 PR19016.1 U6001.D4(GPIO36/I2C5_SDA0/RTS)
VR_STB: PR19011.2 PR20007.1 PR20022.1 PR20037.1 PR20052.1 PR21002.1 PR21007.1 PR21012.1
VR_SVID_ALERT#: C9002.1 PR19002.2 PR19023.2 R9030.2 R9318.1
VR_SVID_CLK: PR19003.2 PR19028.1 R9311.2 R9314.2
VR_SVID_CLK_R: R9314.1 U9001.BH32(VIDSCK)
VR_SVID_DATA: PR19001.2 PR19025.1 R9036.2
VR_TEMP: PR19052.1 PR20006.1 PR20021.1 PR20036.1 PR20051.1 PR21001.1 PR21006.1 PR21011.1
VRAVDDQ_FB: PC14019.1 PR14011.1 PR14012.2 PR14013.2 PR14014.2 PU14000.13(FB)
VRAVR_ON: PR19010.2 R9284.2
VREFP: C3607.2 U3600.40(VREFP)
VRM_LPM#: PQ14000.2(G) PR13005.1 PR13013.1 PR26000.2 PR26001.2
VRM_LPM_GND#: PQ26002.1(EMITTER) Q3606.3(D)
VRPPM_SLP_S0#: CON401.15 PR19012.1 PR23021.2 PR24004.1 R9338.1 U9002.BC28(GPP_B12/SLP_S0#)
VRPVDDQ_PG: PR14010.1 PR25008.2
VSEL2_P2_P3.1: TP8519.1 U8500.L10(SCL_3/VSEL_1_P1/GPIO_P3.7)
WIFI_3V: C4104.1 C4105.2 C4106.2 C4107.2 C4108.2 C4109.1 C4110.2 R4108.1 U4100.4(3.3V#4) U4100.5(3.3V#5) U4100.72(3.3V#72) U4100.73(3.3V#73) U4100.A48(3.3V#A48) U4100.A49(3.3V#A49)
WIFI_32KHZ: R4113.2 R4124.2 U4100.27(SUSCLK(32KHZ)(3.3V)/NC) U4100.A25(C_P32K/C_P32K)
WIFI_PCEI_WL: R4106.1 U4100.29(PEWAKE#/NC)
WIFI_PCIE_REST: R4117.2 R4122.2 U4100.31(PERST#/NC)
WIRELESS_ON: Q4104.3(D) Q4201.3(D) Q6804.2(G) R4215.2 R6825.1 U4100.64(LED2#/LED2#) U4100.65(LED1#/LED1#)
WL_HOST_WAKE: Q4101.1(S) R4106.2 R4125.2
WL_LED_ALL#_Q: Q6804.3(D) R6807.2 R6814.1
WLAN_CLK_REQ3#: Q4101.3(D) R4103.2 R9172.1 U9002.BB30(GPP_B8/SRCCLKREQ3#)
WLAN_CLK_REQ3#_R: Q4101.4(S) R4101.1 R4103.1 R4116.2
WLAN_DISABLE: Q4106.5(G) R4100.1 R6234.2 U6001.E4(GPO32/T\R\I\S\)
WLAN_DISABLE#: Q4106.1(S) Q4106.3(D) R4102.1 U12005.2(INA)
WLAN_LED_EN: Q4104.2(G) R9221.1 U9002.AE44(GPP_H18/SML4ALERT#)
WLAN_TRANSMIT_OFF#_R: R4114.2 U4100.28(W_DISABLE1#/W_DISABLE1#)
WLAN_XMIT_OFF#: R4112.1 R9324.2 U9002.AR18(GPP_D15/ISH_UART0_RTS#/GSPI2_CS)
WW_LED#: CON4201.10(LED) Q4201.1(S) R4201.2
WWAN_ASPM_EXIT: R4209.2 R4227.1 R9344.2 R9622.1 U4200.6(C)
WWAN_CLK_REQ8#: CON4201.52(NC_52) R9186.1 U9002.AE41(GPP_H2/SRCCLKREQ8#)
WWAN_CONFIG_0: R4207.2 R9357.1
WWAN_CONFIG_0_R: R9237.2 R9357.2 U9002.BF14(GPP_D16/ISH_UART0_CTS#/CNV_WCEN)
WWAN_CONFIG_2: CON4201.75(CONFIG_2) R9106.2 R9618.1 R9624.1
WWAN_CONFIG_3: CON4201.1(CONFIG3) Q4200.2(G) R9105.1 R9619.1 R9623.1
WWAN_DET#: R4222.2 U6001.E6(GPIO01)
WWAN_DET#_R: CON4201.69(CONFIG_1) Q9010.2(G) R4200.1 R4203.1 R4222.1
WWAN_FWUPD#: Q4200.1(S) R4221.2 R9343.2
WWAN_FWUPD#_R: R9079.1 R9343.1 U9002.BF36(GPP_A12/BM_BUSY#/ISH_GP6/SX_EXI)
WWAN_OFF#: R4206.1 R4219.2 R6066.1 U6001.K2(GPO35/T\E\S\T\)
WWAN_POWER_OFF#: CON4201.6(PWR_ON/OFF) R4206.2 R4210.2
WWAN_RESET#: Q4200.3(D) R4211.2 R4221.1
WWAN_TRANSMIT_OFF#_R: CON4201.8(W_DISABLE) D4200.2(ANODE) R4223.1
WWAN_WAKE#: CON4201.54(NC_54) R4226.2 R18022.1 R18023.2
WWAN_WAKE#_R: R18022.2 U9002.AH40(GPP_E6/SATA_DEVSLP2)
WWAN_XMIT_OFF#: D4200.1(CATHODE) Q4201.2(G) R4202.1 U9002.BA20(GPP_D9/ISH_SPI_CS#/GSPI2_CS0#)
XCLK_RBIAS: R9167.2 U9002.T3(XCLK_BIASREF)
XDP_BPM0: CON400.21(OBSFN_B0) U9001.BR27(BPM#_0)
XDP_BPM1: CON400.23(OBSFN_B1) U9001.BT27(BPM#_1)
XDP_BPM2: TP9034.1 U9001.BM31(BPM#_2)
XDP_BPM3: TP9035.1 U9001.BT30(BPM#_3)
XDP_DBRESET#: CON401.13 R401.1 R9101.1 U9002.AU2(SYS_RESET#)
XDP_SPI_IO2: R406.1 R6214.1
XTAL24_IN: L9000.3 R9168.2 R9169.2 U9002.U10(XTAL_IN)
XTAL24_IN_L: C9212.2 L9000.4 R9168.1 Y9000.1
XTAL24_OUT: L9000.2 R9169.1 R9170.2 U9002.U9(XTAL_OUT)
XTAL24_OUT_L: C9213.2 L9000.1 R9170.1 R9587.2
XTAL24_OUT_L_L: R9587.1 Y9000.3
XTAL_25_IN: C8050.2 L8000.4 R8018.1 Y8000.1
XTAL_25_OUT: C8051.2 L8000.1 R8019.1 Y8000.3
XTAL_IN: C7315.1 U7300.27(XI_RESERVE) Y7300.1
XTAL_OUT: C7314.1 U7300.28(XO_RESERVE) Y7300.3
XTALOUTBUFF: R2084.1 U2000.J4(XTAL_OUTBUFF)
XTALSSIN: R2083.1 U2000.H1(XTAL_SSIN)
N473130: JDIM1000.165(S3#/C1) TP1001.1
N484850: JDIM1000.162(S2#/C0) TP1000.1
N561500: JDIM1003.162(S2#/C0) TP1007.1
N562420: JDIM1003.165(S3#/C1) TP1006.1
N4140647: PC9803.2 PC9805.1 PR9820.1 PU9802.2(VDD)
N5284227: JDIM1001.162(S2#/C0) TP1002.1
N5284228: JDIM1001.165(S3#/C1) TP1003.1
N6172027: JDIM1002.162(S2#/C0) TP1004.1
N6172028: JDIM1002.165(S3#/C1) TP1005.1
N16771972: Q2012.1(S) R2080.1 U2000.AK12(PEX_CLKREQ*)
N16948284: R7016.2 R7019.2 R7022.2 U7005.4(ILIM_SEL)
N16948310: R7013.2 U7005.15(ILIMI_LO)
N16948312: R7008.2 U7005.5(EN)
N16948334: R7011.1 U7005.16(ILIM_HI)
N17042326: Q2014.3 R2142.1 R2143.1
N17267000: PC19000.1 PR19000.1 PU19000.44(VDD33)
N17269856: L3608.1 U3602.E6(INB1) U3602.F6(INB2) U3602.G6(INB3)
N17269865: C3653.1 C3654.1 C3655.1 C3656.1 U3602.A7(VDDP1) U3602.B7(VDDP2) U3602.C7(VDDP3) U3602.E7(VBST1) U3602.F7(VBST2) U3602.G7(VBST3)
N17269924: L3607.1 U3603.E6(INB1) U3603.F6(INB2) U3603.G6(INB3)
N17269933: C3657.1 C3658.1 C3659.1 C3660.1 U3603.A7(VDDP1) U3603.B7(VDDP2) U3603.C7(VDDP3) U3603.E7(VBST1) U3603.F7(VBST2) U3603.G7(VBST3)
N17327231: Q9000.2(BASE) R9018.2
N17654321: Q9006.1 R9123.1
N17654323: Q9006.3 Q9007.1
N17980871: Q6301.3(COLLECTOR) R6300.1 R6301.1 R6304.2 U6300.2(I0) U6301.2(I0)
N17988049: C1000.2 R1015.2
N17989426: C1088.2 R1041.1
N18005245: D3001.2(ANODE) R3019.1 U3002.4(EN)
N18039182: CON6800.1 R6809.2
N18039210: CON6800.2 R6812.2
N18039226: CON6800.3 R6813.2
N18039254: CON6800.4 R6814.2
N18039268: CON6800.5 R6815.1
N18039296: CON6800.6 R6816.1
N18039311: CON6800.7 R6817.2
N18039329: CON6800.8 R6811.2
N18039352: CON6800.9 R6818.2
N18039370: CON6800.10 R6819.2
N18039389: CON6800.11 R6820.2
N18039414: CON6800.12 R6821.2
N18039420: CON6800.13 R6822.1
N18113226: C2215.2 R2110.2 R2111.1
N18140305: C2167.2 R2059.1 R2060.2
N18140958: C2217.2 R2117.2 R2118.1 R2140.1
N18141435: C2219.2 R2122.2 R2123.1 R2141.1
N18332322: TP9021.1 U9002.BE33(GPP_A16/CLKOUT_48)
N18377760: R3648.2 U3602.A4(INT)
N18379805: R3649.2 U3603.A4(INT)
N18439683: PC11004.2 PC11005.1 PR11002.1 PR11005.1
N18439702: PC11003.2 PC11004.1 PR11001.1 PR11004.1
N18441298: C2231.2 D2004.2(ANODE) Q2019.2(G) Q2019.5(G) R2147.2 R2148.2
N19453152: C9224.2 R9260.1 U9002.D1(VCCPRIM_1P0521) U9002.E1(VCCPRIM_1P0522)
N19516437: PC25002.2 PR25003.2 PR25005.2 PR25007.1 PR25011.1 PR25015.2 PR25017.1 PR25025.1 PR25026.1
N19743923: CON5000.18(RSVD) R5001.1
N19870020: Q6002.5(G) Q6002.6(D) R6005.1 R6096.2
N19870172: Q6003.2(G) R6179.2
N19870194: Q6003.3(D) Q6008.2(G) R6177.2 R6178.2
N19870369: LED6000.2 R6094.2
N19870371: LED6000.1 R6095.2
N19873939: PC13006.1 PR13000.2
N19874615: PC13028.2 PR13011.1
N19874621: PC13022.1 PR13009.2
N19874656: PC13013.2 PR13003.1
N19883422: PC13035.2 PR26010.2 PU13002.21(VCC)
N19883517: PR13016.2 PU13002.6(TON)
N19883529: PC13036.1 PR13017.1
N19883555: PC13042.2 PR13019.1
N20025646: PC11021.2 PC11022.1 PR11017.1 PR11026.2
N20025647: PC11020.1 PC11021.1 PR11016.1 PR11024.2
N20025709: PC11012.1 PR11010.1
N20059068: PD11007.1(CATHODE) PD11008.3(COMMON ANODE) PR11008.1
N20282259: C6032.2 R6187.2 U6001.M6(VREF_PECI)
N20549842: Q4102.2(BASE) Q4103.3(COLLECTOR) R4104.1 R4107.1 R4111.2
N20618845: TP9039.1 U9002.BC1(RSVD#BC1)
N21534191: JCN9000.4(ESPI_ALERT) R9001.2
N21542905: Q7146.3(D) R7154.2 R7155.1 R7206.2
N21677295: PC16000.2 PR16001.2 PU16000.11(AGND)
N21677318: PC16011.2 PR16005.1
N21830961: R4025.2 U4000.6(RSVD_NC)
N22420667: C2553.1 R2519.1 R2520.1
N22581784: R6508.1 U6500.6(GPIO)
N22581796: Q6500.3(D) R6511.2 R6512.1
N22581800: C6503.2 Q6500.2(G) R6512.2
N22650661: R9502.1 U6004.5(EO)
N22855262: PC20010.1 PR20003.2
N22855291: PR20004.1 PR20008.2
N22855292: PC20011.2 PC20012.2 PR20005.1 PR20010.1 PR20013.1 PR20014.1
N22855294: PC20011.1 PR20008.1 PR20011.1 PR20012.2
N22855298: PR20009.2 PR20010.2
N22855301: PR20009.1 PR20012.1 PR20013.2
N22855337: PC20020.1 PR20017.2
N22855368: PC20021.2 PC20022.2 PR20019.1 PR20025.1 PR20028.1 PR20029.1
N22855370: PC20021.1 PR20023.1 PR20026.1 PR20027.2
N22855374: PR20024.1 PR20027.1 PR20028.2
N22855375: PR20024.2 PR20025.2
N22855427: PC20034.1 PR20033.2
N22855458: PC20035.2 PC20036.2 PR20035.1 PR20040.1 PR20043.1 PR20044.1
N22855460: PC20035.1 PR20038.1 PR20041.1 PR20042.2
N22855464: PR20039.1 PR20042.1 PR20043.2
N22855465: PR20039.2 PR20040.2
N22855516: PC20044.1 PR20048.2
N22855547: PC20045.2 PC20046.2 PR20050.1 PR20055.1 PR20058.1 PR20059.1
N22855549: PC20045.1 PR20053.1 PR20056.1 PR20057.2
N22855553: PR20054.1 PR20057.1 PR20058.2
N22855554: PR20054.2 PR20055.2
N22855607: PR20018.1 PR20023.2
N22855616: PR20034.1 PR20038.2
N22855622: PR20049.1 PR20053.2
N22857752: PC21011.1 PR21003.2
N22857755: PC21010.1 PU21000.21(BST)
N22857779: PC21023.1 PR21008.2
N22857782: PC21022.1 PU21001.21(BST)
N22857845: PC21035.1 PR21013.2
N22857847: PC21030.1 PU21002.13(BST)
N22936532: C2529.1 R2511.1 R2512.1
N22985955: C2527.1 R2509.1 R2510.1
N22992688: C2536.1 R2514.1 R2515.1
N23148426: Q9002.2(G) Q9002.3(D) R9308.1
N23208307: CON4000.14(GND#2) R4019.1
N23208323: CON4000.13(GND#1) R4020.2
N23249859: CON3601.3 R3640.1
N23300592: U2006.4(OUT Y) U2007.1(INB)
N23309364: D2008.3(COMMON ANODE) Q2006.2(G) R2101.2 U2007.4(OUT Y)
N23324590: C2161.2 Q2000.2(G) Q2006.3(D) R2050.2
N23331618: CON400.39(PWRGOOD/HOOK0) R404.1
N23445462: PR23007.1 PR23020.1 PR23021.1 PU23000.1(A)
N23692787: PC9013.2 PR9001.2 PR9004.1
N23796258: Q9001.2(G) Q9001.3(D) R9002.1
N23796391: LED9000.2 R9301.1
N24173296: PC25001.2 PD25000.3(COMMON ANODE) PR25001.1 PR25002.1 PR25004.1 PR25008.1 PR25014.1 PR25016.1
N24218229: PQ12003.3(D) PR12010.1
N24218333: PC12001.2 PR12000.2 PR12001.2
N24414354: CON4000.9(A1_GREEN+) R9549.2
N24414492: CON4000.11(B1_AMBER+) R9550.2
N24794111: CON400.55(TCK1) R403.1
N24857035: C7319.2 U7301.8(HSON)
N24857037: C7321.2 U7301.7(HSOP)
N25358852: C858.2 R908.1 R909.2
N25359574: C6007.2 U6001.A6(CAP)
N25362513: R911.2 R912.2 U49.5(VCC)
N25369401: C9235.2 R17898.2 U9002.AY8(VCCPRIM_3P33) U9002.BB7(VCCPRIM_3P34)
N25375127: TP22011.1 U9002.AW2(GPP_J8/CNV_MFUART2_RXD)
N25377172: Q9035.2(BASE) R17907.1 R17985.1
N25434094: PQ12009.1(EMITTER) PR12030.2 PR12031.2 PR12032.2
N25434098: PR12022.1 PR12023.1 PR12028.2 PR12030.1
N25434108: PQ12008.3(D) PR12020.1 PR12031.1
N25434127: PQ12005.1(S) PR12017.1 PR12019.1 PR12021.1
N25434139: PC12008.2 PQ12005.3(D) PQ12006.1(EMITTER) PR12017.2 PR12022.2
N25434159: PQ12007.1(EMITTER) PR12021.2 PR12024.2
N25434165: PQ12005.2(G) PR12025.2 PR12029.2
N25434218: PR12018.1 PR12019.2 PR12020.2
N25434240: PQ12009.2(BASE) PR12028.1
N25489287: PR11038.2 PR11039.1
N25500449: PQ12011.3(COLLECTOR) PQ12012.2(BASE) PR12036.2
N25500523: PC12010.2 PQ12011.2(BASE) PR12034.1 PR12035.2
N25553256: Q9040.2(G) Q9040.3(D) R17943.1
N25553310: Q9036.2(G) Q9036.3(D) R17938.1
N25553361: Q9037.2(G) Q9037.3(D) R17939.1
N25553432: Q9038.2(G) Q9038.3(D) R17941.1
N25553485: Q9039.2(G) Q9039.3(D) R17942.1
N25557141: R17951.1 U500.33(CSDA)
N25557143: R17952.1 U500.34(CSCL)
N25557296: R17949.1 U501.33(CSDA)
N25557298: R17950.1 U501.34(CSCL)
N25688589: PR23022.1 PR23023.1 PU23000.5(VCC)
N25688835: PR23024.1 PR23025.1 PU23001.5(VCC)
N25796977: PC8001.1 PR26011.2 PU8001.21(VCC)
N25924440: PQ10005.3(D) PQ10005.6(D) PR10005.2
N25934937: PQ10009.2(G) PR10010.2 PR26017.1
N25934984: PQ26006.3(D) PR26017.2
N25938819: PC23018.2 PR23028.2 PU23002.4(ON)
N25938833: PC23015.1 PR23026.1 PR23027.1 PU23002.3(VBIAS)
N26150460: PR26018.1 PU25002.4(Y)
N27027955: PD25000.2(CATHODE2) PR25012.1
N27029563: PQ10017.3(C2) PR10024.2
N27029564: PQ10011.4(G) PQ10017.6(C1) PR10029.1
N27029566: PQ10017.2(B1) PQ10017.5(B2) PR10032.1
N27029568: PD2.2 PQ10014.2(G) PQ10015.2(G) PR10025.1
N27029569: PQ10018.3(C2) PR10026.1
N27029586: PQ10018.2(B1) PQ10018.5(B2) PR10033.1
N27029588: PQ10012.4(G) PQ10018.6(C1) PR10030.1
N27029591: PQ10015.1(S) PQ10018.4(E2)
N27029606: PQ10014.1(S) PQ10017.4(E2)
N27168565: JCN9000.3(GND#2) JCN9000.23(NC#1) R9016.2
N27205864: R17984.2 U6001.J3(GPIO67/PS2_CLK0)
N27414743: Q9004.2(BASE) R9028.1 R9316.1
N27414752: Q9003.2(G) Q9004.3(COLLECTOR) R9313.2
N27585860: PC19006.1 PR19027.2
N27585915: PC19012.1 PR19054.2
N27755546: PR16008.1 PU16000.6(LP#)
N27758362: PQ26002.3(COLLECTOR) PR26001.1
N27758389: PQ26001.3(COLLECTOR) PR26003.1 PR26004.2
N27758591: PQ26000.1(S) PQ26001.1(EMITTER)
N27758609: PQ26001.2(BASE) PR26002.2
N27758909: PQ26005.3(COLLECTOR) PR26006.1
N27758919: PQ26005.2(BASE) PR26008.2
N27758929: PQ26004.3(COLLECTOR) PR26008.1 PR26009.2
N27758969: PQ26004.2(BASE) PR26007.2
N28417448: PR18000.2 PU18000.6(TON)
N28417565: PC18013.2 PR18004.1
N29149167: D9001.1(ANODE1) R9280.1
N29485598: LED9002.2 R9374.1
N29485608: LED9003.2 R9375.1
N29486150: R18003.2 R18004.2 U12003.1(INB)
N29486152: C12037.2 D9003.2(ANODE) R18006.2 U12003.2(INA)
N29490156: R18008.2 U6001.J4(GPIO70/PS2_DAT0)
N29550422: Q9046.2(G) Q9046.3(D) R18011.2
N30251420: PR20060.2 PU20004.12(O\T\1\2\)
N30251430: PR20061.2 PU20004.15(O\T\3\4\)
N30251475: PR20062.2 PU20004.6(O\T\5\6\)
N30251477: PR20063.2 PU20004.9(O\T\7\8\)
N30251495: PR20072.1 PU20004.7(TMSNS6) PU20004.10(TMSNS8) PU20004.13(TMSNS2) PU20004.16(TMSNS4)
N30251533: PR20066.1 PR20067.2 PU20004.14(TMSNS3)
N30251545: PR20068.1 PR20069.2 PU20004.5(TMSNS5)
N30251549: PR20070.1 PR20071.2 PU20004.8(TMSNS7)
N30251553: PR20064.1 PR20065.2 PU20004.11(TMSNS1)
N30292191: PQ11000.4(G) PQ11005.6(C1) PR11042.1
N30292231: PQ11004.1(S) PQ11005.4(E2)
N30292255: PQ11005.2(B1) PQ11005.5(B2) PR11040.1
N30292285: PD11006.2 PQ11004.2(G) PR11043.1
N30295612: PQ11005.3(C2) PR11041.2
N30474489: R6513.2 U6500.16(NC#10)
N30634969: C3085.2 D3002.2(ANODE) Q3000.2(G) R3027.2 R3082.1
N30635290: D3002.1(CATHODE) R3024.1 R3025.1 R3082.2
N30700095: R9031.1 R9032.1 R17987.2 R17992.2
N30710492: Q3009.5(G) R3091.1 R3092.2
N30714432: Q3000.3(D) Q3010.3(D) R3017.2 R3023.2 R3027.1
N30715592: Q3000.5(G) Q3000.6(D) R3016.2
N30790939: Q4000.2(G) R4014.2
N30790954: Q4000.5(G) R4013.2
N30794855: LED9000.1 Q9001.6(D)
N30917415: R2231.2 R2232.2 U2008.1(INB)
N31652171: PC19008.1 PR19039.2
N32334351: PQ10002.2(G) PR10000.1 PR10004.1
N32334559: PC10001.2 PC25009.1 PQ10001.4(G) PQ10003.3(D) PR10003.1 PR10007.1
N32334561: PC10000.2 PC25008.1 PQ10000.4(G) PQ10002.3(D) PR10002.1 PR10006.1
N32334573: PQ10003.2(G) PR10001.1 PR10005.1
N32336654: PQ10008.2(BASE) PR10012.2 PR10015.1
N32336656: PR10015.2 PR10017.2 PR10020.1
N32336668: PQ10008.3(COLLECTOR) PQ10010.2(BASE) PR10018.1
N32338342: PQ10019.3(C2) PR10027.2
N32338344: PQ10013.4(G) PQ10019.6(C1) PR10031.1
N32338348: PQ10019.2(B1) PQ10019.5(B2) PR10034.1
N32338352: PD3.2 PQ10016.2(G) PR10028.1
N32338380: PQ10016.1(S) PQ10019.4(E2)
N32372408: PQ23005.5(G) PQ23005.6(D) PR23009.2 PR23012.1
N32372455: PQ23008.5(G) PQ23008.6(D) PR23015.2 PR23018.1
N32372459: PQ23008.3(D) PR23016.2
N32372479: PQ23003.2(G) PQ23006.2(G) PR23008.1
N32372487: PQ23004.2(G) PR23011.1
N32372499: PQ23005.3(D) PR23010.2
N32372521: PQ23007.5(G) PQ23007.6(D) PR23013.2 PR23017.1
N32374859: PQ14002.3(D) PR14016.2
N32376959: PC22014.1 PR22004.1 PU22001.5(ON2)
N32376975: PC22016.1 PU22001.12(CT1)
N32376979: PC22017.1 PU22001.10(CT2)
N32376989: PC22021.1 PR22007.1 PU22001.3(ON1)
N32380200: PQ26003.1(S) PQ26004.1(EMITTER)
N32431871: PD11005.2(ANODE) PR11012.1 PR11015.2
N32460418: PC11019.1 PR11014.1
N32461932: PR11030.1 PU11001.3(ALERT#)
N32555675: PC15000.1 PR15001.2 PU15000.11(AGND)
N32555692: PC15012.2 PR15005.1
N32555708: PR15007.1 PU15000.6(LP#)
N32555744: PR15009.1 PU15000.3(C1)
N32555746: PR15010.1 PU15000.4(C0)
N32555758: PR15008.2 PU15000.7(MODE)
N32576682: PQ14001.3(D) PR14014.1
N32604102: Q8012.2(BASE) R8098.1
N32605621: R8574.2 U8500.A10(LSTX_P1/GPIO_P4.4)
N32605622: R8575.2 U8500.A11(LSRX_P1/GPIO_P4.5)
N32606041: R8573.1 U8500.L11(LSRX_P2/GPIO_P5.2)
N32606042: R8572.1 U8500.K11(LSTX_P2/GPIO_P5.1)
N32608552: Q7120.3(D) R7141.1 R7142.2 R7205.2
N32654425: R9065.1 U9002.BE39(GPP_A0/RCIN#/ESPI_ALERT1#)
N32913947: R9191.1 U9002.BD1(GPPJ_RCOMP_1P81) U9002.BE1(GPPJ_RCOMP_1P82) U9002.BE2(GPPJ_RCOMP_1P83)
N32915328: R9189.1 U9002.BE5(SD_RCOMP_1P8)
N32915331: R9190.1 U9002.BE4(SD_RCOMP_3P3)
N32919695: R9050.2 U9001.A37(VSS_A37)
N33014852: R8023.1 U8001.U2(BATLOW#)
N33014907: R8024.1 U8001.U1(SLP_S3#)
N33019370: R8025.2 R8026.2 R8027.1 R8028.1 R8029.1
N33282670: R6404.1 U6402.1(SET)
N33283807: CON5100.75(GND_75) R5104.2
N33283853: CON5100.10(DAS/DSS#) D5100.1
N33283871: CON5100.12(3.3VAUX_12) R5102.1
N33283909: CON5100.68(SUSCLK) TP5100.1
N33296743: R4000.1 U4000.36(PE_RST_N)
N33310214: CON5101.75(GND_75) R5109.2
N33310227: CON5101.10(DAS/DSS#) D5101.1
N33310234: CON5101.12(3.3VAUX_12) R5106.1
N33310253: CON5101.68(SUSCLK) TP5102.1
N33315294: R7300.1 R7304.2 U7300.7(SCARD0DATA)
N33315355: C7303.1 R7302.2 U7300.23(RESET)
N33315356: R7301.2 R7303.2 U7300.26(PWRSV_SEL)
N33316932: C4008.2 R4007.2 Y4000.1
N33316952: Q4001.2(BASE) R4011.2 R4012.1
N33316977: R4008.2 TP22070.1 U4000.30(TEST_EN)
N33316979: R4009.1 U4000.12(RBIAS)
N33316984: R4004.1 U4000.1(RSVD_VCC3P3_1)
N33317032: C4010.1 C4012.1 C4014.1 C4016.1 C4018.1 U4001.3(TCT1) U4001.4(TCT2) U4001.9(TCT3) U4001.10(TCT4)
N33317033: C4015.1 R4017.1
N33317035: C4017.1 R4018.1
N33317047: C4019.2 R4015.2 R4016.2 R4017.2 R4018.2
N33317104: C4011.1 R4015.1
N33317105: C4013.1 R4016.1
N33344911: TP9008.1 U9001.BT2(RSVD_TP2)
N33344918: TP9007.1 U9001.BR1(RSVD_TP1)
N33344928: R9049.2 U9001.A36(VSS_A36)
N33351835: R9111.1 U9002.AH4(PCH_JTAGX)
N33355782: TP9025.1 U9002.AW48(SPI0_CS1#)
N33356879: TP9030.1 U9002.BD38(GPP_A17/SD_VDD1_PWR_EN#/ISH_GP7)
N33510752: CON4201.23(WAKE_OUT_WWAN) R4214.1
N33510760: R4214.2 TP4201.1
N33531364: R3610.2 U3600.4(RESERVED#1) U3600.5(RESERVED#2)
N33531809: R3604.2 R3607.1 U3600.47(JSENSE)
N33579886: D7170.2(ANODE) R7100.1 R7191.2
N33579897: D7171.2(ANODE) R7101.1 R7192.2
N33708500: R4131.2 U4103.1(B) U4103.2(A)
N33708566: R4132.2 U4102.1(B) U4102.2(A)
N33864211: R3034.2 U3005.4(EN)
N33864385: C3016.2 R3000.2 U3000.4(VIN#1) U3000.5(VIN#2)
N33864703: R3012.2 U3001.4(EN)
N33864761: R3026.2 U3003.4(EN)
N34047388: R635.2 U603.10(REXT)
N34048694: R3201.1 U3201.3(OC#)
N34892414: LED9004.4 R9627.2
N34892436: LED9004.3 R18047.2
N35265666: Q6351.2(G) Q6351.3(D) R6358.2
N35690359: Q3603.3(D) R3638.2 U3601.6(SD#)
N35906868: PC14006.1 PR14003.1
N35907016: PC14016.2 PR14004.1
N36022935: PC22015.1 PR22005.1 PU22000.5(ON2)
N36022943: PC22019.1 PU22000.12(CT1)
N36022944: PC22020.1 PU22000.10(CT2)
N36022949: PC22018.1 PR22006.1 PU22000.3(ON1)
N36026151: PC17007.1 PR17009.1
N36026175: PC17012.2 PR17013.1
N36026221: PR17015.1 PU17000.7(MODE)
N36430440: R9059.2 U9002.F3(USB2_VBUSSENSE)
N36430441: R9060.2 U9002.G3(USB2_ID)
N36798878: PC8014.1 PR8004.2
N36798889: PQ8004.3(D) PR8013.2
N36798895: PC8017.1 PQ8004.2(G) PR8018.2 PR8021.1
N36799011: PC8007.1 PR8002.2
N36799059: PQ8002.2(G) PQ8003.3(D) PR8010.2 PR8012.1
N36799063: PQ8002.3(D) PR8022.2
N36799154: PR8001.1 PU8001.6(TON)
N36871877: PC9804.1 PR9816.1 PR9819.2 PU9802.16(P\W\R\D\W\N\)
N36874414: PC9808.2 PC9809.1 PR9821.2 PU9802.15(VDD/IO)
N36891973: PQ23007.3(D) PR23014.2
N36893850: PC22029.1 PR22010.1 PU22002.5(ON2)
N36893866: PC22027.1 PU22002.12(CT1)
N36893870: PC22028.1 PU22002.10(CT2)
N36893880: PC22022.1 PR22008.1 PU22002.3(ON1)
N37010922: R18064.2 TP22069.1 U8001.R4(TEST_EN)
N37114488: R18078.1 U12006.36(REXT)
N37514618: TP9502.1 U9500.11(INT2)
N37516232: R548.2 U501.31(REXT)
N37516240: TP505.1 U501.30(PD#)
N37705554: R522.1 U500.31(REXT)
N37705574: TP503.1 U500.30(PD#)
N37711258: R7205.1 U7112.B4(EN)
N37711431: R7187.2 U7112.A4(F\L\T\)
N37711689: C7152.2 U7112.D4(CAP)
N37712209: R7188.1 U7112.A3(ILIM)
N37713533: R7206.1 U7113.B4(EN)
N37713562: R7189.1 U7113.A4(F\L\T\)
N37713602: R7190.1 U7113.A3(ILIM)
N37973156: D7170.1(CATHODE) Q7130.5(G)
N37973157: D7171.1(CATHODE) Q7130.2(G)
N38208157: Q4103.2(BASE) R4112.2
N38208218: Q4102.3(COLLECTOR) R4110.2 R4114.1
N38214825: R4119.2 U4100.A15(LNA_EN/GND)
N40748080: PQ10004.3(D) PQ10004.6(D) PR10004.2
N42587939: PC9511.1 PU9501.10(CT2)
N42587941: PC9510.1 PU9501.12(CT1)
N42628948: R3040.2 U3007.48(CA_DET)
N42837801: Q2010.2(G) Q2013.3(D) R2078.2
N43915287: CON400.48(DBR#/HOOK7) R401.2
N46097153: R2504.2 VRAM2501.J1(MF)
N46097158: R2500.2 VRAM2501.J13(ZQ)
N46097163: R2506.2 VRAM2500.J13(ZQ)
N46097165: R2503.2 VRAM2500.J1(MF)
N46098616: R2522.2 VRAM2503.J13(ZQ)
N46098640: R2518.2 VRAM2503.J1(MF)
N46098642: R2517.2 VRAM2502.J1(MF)
N46098644: R2513.2 VRAM2502.J13(ZQ)
N46263503: PR9017.2 PU9001.6(REFADJ)
N52951734: PR14008.2 PU14000.14(MODE)
N53913035: PD11001.1(CATHODE) PD11003.1(CATHODE) PR11007.1
N53993617: Q6800.3(D) R6827.1 R6828.1
N54010638: PR14012.1 PR14015.2
N54011668: PQ14000.3(D) PR14013.1
N54024226: PD25000.1(CATHODE1) PR25013.1
N54024229: PC25000.1 PR25009.2 PR25010.2 PU25000.2(MINUS INPUT) PU25000.6(MINUS INPUT)
N54024270: PR25014.2 PR25018.1 PU25000.3(PLUS INPUT)
N54024274: PR25015.1 PR25019.1 PU25000.5(PLUS INPUT)
N54025517: PC24000.1 PR24000.1 PR24001.1 PU24000.5(VCC)
N54025545: PR24003.2 PU24000.1(B)
N54025557: PR24004.2 PU24000.6(C)
N54989092: Q6806.2 R6828.2
N55136487: PR17011.2 PR17012.2 PU17000.6(LP#)
N55136655: PR17014.1 PR17017.1
N55154530: PC25005.1 PR25022.1 PR25024.1 PU25001.2
N55387237: C9249.2 R9276.2 R9277.1
N56147095: R3637.1 U3601.11(HPRIGHT)
N56147100: C3632.1 U3601.17(CPM)
N56147116: C3633.2 U3601.15(CPVSS_15) U3601.16(CPVSS_16)
N56147163: R3636.1 U3601.14(HPLEFT)
N56147202: C3632.2 U3601.18(CPP)
N56148149: C3638.1 U3601.5(RIGHTINM-)
N56148151: C3634.1 U3601.1(LEFTINML-)
N56962017: PR16009.1 PU16000.3(C1)
N56962020: PR16010.1 PU16000.4(C0)
N56962461: PR16007.2 PU16000.7(MODE)
N57264302: PC14000.1 PR14000.1 PU14000.3(3V3)
N57531109: PC17000.1 PR17006.2 PU17000.10(3V3)
N62824235: Q6300.3(D) Q6301.2(BASE) R6302.2
N67022652: L6000.1 R6034.2
N215281515: TP4108.1 U4100.11(COEX_TXD/NC)
N215281516: TP4109.1 U4100.12(COEX_RXD/NC)
N215281517: TP4110.1 U4100.13(COEX3/NC)
N1682558515: C7153.2 U7113.D4(CAP)

Pads without a net: CON401 16 17 18; CON3000 4; CON3001 1 10 12; CON3200 13 14; CON3601 7 8; CON4200 2 3; CON4201 20 22 24 28 29 31 35 37 38 40 42 44 46 48 56 58 59 60 61 62 63 64 65 68; CON5000 8 9 20 21 22; CON5100 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; CON5101 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; CON7200 1; D6803 3 4 5; JCN9000 1 2; NOREF#2 1; NOREF#5 1; NOREF#7 1; NOREF#9 1; NOREF#10 1; NOREF#12 1; PAD15 1; PAD18 1; PCN12000 4; PQ9001 2; PQ9004 2; PQ9005 2; PQ9006 2; PQ9007 2; PQ9008 2; PQ20000 2; PQ20001 2; PQ20002 2; PQ20003 2; PU9802 7 8 9 10; PU13000 4; PU13001 4; PU14000 11; PU20004 1; PU25001 1; R9625 1 2; R9626 1 2; R18106 1 2; R18107 1 2; U500 35 36 37 63 64 65 66; U501 35 36 37 63 64 65 66; U2000 A9 A26 A27 A30 AC6 AC28 AF30 AF32 AG7 AG10 AG12 AG26 AH6 AH9 AH31 AJ4 AJ5 AJ6 AJ8 AJ9 AJ11 AJ26 AJ28 AJ31 AJ32 AJ33 AK6 AK8 AK9 AK26 AK31 AL6 AL7 AL8 AL9 AL10 AL11 AM5 AM6 AM7 AM8 AM9 AM34 AN2 AN3 AN5 AN6 AN8 AN9 AP3 AP5 AP6 AP8 B2 B6 B23 C6 C15 D6 D7 D9 D19 D20 D22 D23 D26 D28 E1 E4 E26 E34 F26 G14 G20 H6 H30 H31 J30 J31 J32 J33 L7 M30 M34 P1 P3 P8 R4 R28 V32; U3001 3; U3002 3; U3003 3; U3005 3; U3007 22 23 24 25; U3011 1; U3600 16 17 18 20 21 44 45 46; U4000 25; U4100 1 2 3 7 8 9 10 14 15 16 18 19 21 22 24 25 45 46 47 48 49 50 51 52 60 61 66 67 A8 A9 A10 A11 A12 A13 A14 A16 A17 A18 A27 A28 A29 A30 A45 A46 A47; U4101 3; U6001 E8 L3 M2; U6500 3 4 5 10 11 12 13 15 25 26 27 28 29 30 31; U7003 3; U7004 3; U7005 13; U7112 B1 B2 C1; U7113 B1 B2 C1; U7300 20 21 22 24 25; U7301 31; U8001 AB3 AB5 AB15 AB17 AB19 AB21 AB23 AC3 AC5 AC15 AC17 AC19 AC21 B23 D19 D20 E19 E20 H5 J9 J11 N4 N5 V8; U8500 B6 B7 B8 B9 F10 G8 G10 H4 H5 H8 H10 H11 J10 J11 L4; U9001 A27 AA14 AE29 AJ8 AP14 AP29 AT13 AU13 AW13 AY13 B27 B30 B38 BH30 BJ28 BK28 BL31 BL34 BN33 BN35 BR2 BR31 BR35 C30 C38 D1 E1 E2 E30 F30 G3 G13 H24 J3 J24 N29 R14; U9002 A17 A25 AA1 AA45 AC6 AC7 AC9 AC11 AD47 AE9 AE11 AE48 AH14 AH15 AJ47 AL35 AM7 AN4 AN46 AP2 AP3 AP41 AR13 AR42 AR48 AT10 AV6 AV13 AV34 AW3 AW13 B9 B15 B17 B18 B25 B26 B27 B40 BC17 BD8 BD17 BD34 BE8 BE12 BE18 BE34 BF10 BF19 C3 C9 C15 C16 C17 C18 C26 C27 C40 D4 D29 E28 E45 F14 F16 F26 F44 F46 G1 G2 G14 G17 G26 G45 G46 G47 G48 G49 H2 H3 H47 H48 J13 K3 K4 K6 K7 K13 K29 L26 L46 L47 L48 M26 M29 M45 N32 N47 N48 P21 P24 P47 P48 R13 R15 R21 R24 R32 R44 R46 R47 T1 T2 T43 T46 T47 U2 U3 U13 U35 U37 U40 U41 U47 U48 V47 V48 W6 W7 W43 W44 W46 W47 Y2 Y15 Y35 Y36 Y40 Y41 Y46 Y47 Y48; U12002 1; U12006 2 4 9 10 12 25 26 28 29 33 34 37; VRAM2500 A5 A10 U5 U10; VRAM2501 A5 A10 U5 U10; VRAM2502 A5 A10 U5 U10; VRAM2503 A5 A10 U5 U10

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 9473 vias
v2: diameter 0.813, hole 0.406, TOP to BOTTOM, 25 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 491 vias
v4: diameter 0.61, hole 0.356, TOP to BOTTOM, 1344 vias
v5: diameter 1.082, hole 0.541, TOP to BOTTOM, 15 vias
v6: diameter 0.884, hole 0.442, TOP to BOTTOM, 50 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V05A_PG: length 31.4
  TOP w0.127: v1(297.78,60.75) 298.25,60.29 299.59,60.29 300.57,59.31 302.66,59.31 303.13,58.85 306.19,58.85 306.74,59.4 306.74,60.72 306.74,60.72 306.74,61.13 306.79,61.18 308.16,61.18 308.27,61.29 PR18003.1
  BOTTOM w0.127: PR25011.2 291.62,47.83 291.88,48.1 291.88,49.2 291.78,49.3 291.78,49.68 291.88,49.79 291.88,55.78 292.71,56.61 292.71,58.25 293.14,58.68 293.14,58.92 293.85,59.63 295.22,59.63 295.3,59.7 296.28,59.7 297.34,60.75 v1(297.78,60.75)
1V8_AON: length 146.9
  TOP w0.254: Q2020.5 206.74,50.43 207.04,50.13 207.04,49.48 206.88,49.31 206.61,49.31 206.41,49.11 v1(206.41,48.83)
  TOP w0.279: v1(222.79,85.59) 222.79,85.18 223.14,84.84 U2001.5
  TOP w0.381: R2145.1 209.21,50.9 208.74,50.43 Q2020.2 ; R2145.1 209.57,51.01 Q2021.2 ; R2145.1 209.46,51.53 209.07,51.91 206.73,51.91 205.71,52.92 v1(202.29,52.92) ; v1(221.33,91.37) 221.39,91.44 R2036.2 R2029.2 ; R2119.1 v1(233.96,77.32) ; R2033.1 215.93,91.59 215.7,91.36 v1(215.68,91.36) 215.65,91.36 215.42,91.14 R2037.1 ; PR9505.1 203.73,80.7 v1(203.36,80.7) ; R2044.1 221.27,94.05 220.99,93.77 v1(220.99,93.56) ; D2004.1 219.28,78.75 220.64,80.11 R2148.1 221.14,80.73 v1(221.01,80.99) ; R2042.1 217.96,91.54 v1(218.13,91.37) ; R2040.1 216.85,94.18 216.85,93.53 216.82,93.51 v1(216.8,93.51) ; R2032.2 R2097.2 225,87.89 v1(224.79,87.69) ; v1(216.85,91.37) 216.95,91.47 R2039.1 ; v1(220.12,93.53) 220.12,94.19 R2043.1 ; v1(219.23,91.37) 219.33,91.28 R2031.1 ; R2034.1 v1(215.93,93.53) ; R2035.1 v1(219.23,95.82)
  TOP w0.508: v1(219.36,105.34) 218.91,105.79 C2143.2 ; v1(231.43,65.6) 231.77,65.94 231.77,67.24 231.93,67.4 R2107.1 ; R2114.1 230.58,88.6 C2149.2 230.58,89.54 231.05,90.01 v1(231.05,90.36)
  IN2 w0.381: v1(215.55,52.26) 215.55,52.67 215.02,53.2 213.14,53.2 212.83,52.9 210.39,52.9 208.48,50.99 206.79,50.99 206.41,50.6 v1(206.41,48.83)
  IN2 w0.508: v1(225.99,58.21) 225.97,58.19 225.97,57.52 225.44,57 225.44,56.01 222.36,52.92 216.22,52.92 v1(215.55,52.26) ; v1(205.9,91.38) 204.1,91.38 202.22,89.5 201.59,89.5 v1(200.62,88.53) ; v1(224.29,81.62) 224.59,81.62 225.77,80.45 225.77,79.97 226.37,79.36 227.01,79.36 227.47,78.9 227.47,78.32 227.72,78.07 v1(227.72,77.69) ; v1(202.29,52.92) 202.67,53.3 204.48,53.3 206.79,50.99
  IN4 w0.381: v1(208.06,89.97) 207.94,89.97 206.53,91.38 v1(205.9,91.38)
  IN4 w0.508: v1(233.96,77.32) 233.96,76.62 234.27,76.31 234.27,75.61 232.04,73.37 232.04,71.62 230.38,69.97 230.38,66.64 v1(231.43,65.6)
  BOTTOM w0.254: PR9213.1 215.17,51.62 215.55,52 v1(215.55,52.26) ; PR9006.1 201.83,52.46 v1(202.29,52.92)
  BOTTOM w0.279: PU9503.5 204.61,84.28 204.63,84.29 PC9516.2
  BOTTOM w0.381: v1(196.81,93.59) 196.4,93.18 195.23,93.18 194.08,92.03 Q2011.2 ; v1(208.06,89.97) 208.06,90.18 207.47,90.77 ; R2080.2 R2089.1 195.1,101.44 195.49,101.82 v1(195.74,101.82) 196.12,101.82 196.37,102.07 R2070.2 196.37,102.53 R2071.2 ; 207.47,90.77 Q2024.5 ; 207.47,90.77 207.47,92.11 R2138.1 ; Q2024.2 205.29,90.77 v1(205.9,91.38) R2139.1 ; v1(219.23,91.37) R2095.1
  BOTTOM w0.508: v1(231.43,65.6) 231.43,64.94 231.55,64.81 231.55,59.96 229.81,58.21 v1(225.99,58.21) ; R2034.1 v1(215.93,93.53) ; R2095.1 R2092.2 R2090.2 R2098.2 ; v1(216.85,91.37) 216.85,91.9 R2039.1 ; R2050.1 198.03,91.54 v1(198.15,91.66) ; R2033.1 215.93,91.62 v1(215.68,91.36) 215.94,91.1 215.91,91.08 Q2014.2 ; PC9516.2 205,83.52 204.7,83.22 v1(204.12,83.22) 204.12,81.47 v1(203.36,80.7) ; v1(218.13,91.37) 217.96,91.54 R2042.1
  vias: v1(198.79,91.66) v1(220.81,103.8) v1(221.75,103.84) v1(223.65,81.62) v1(223.81,84.8) v1(233.2,90.36) v1(233.97,90.36)
1V8_AON_EN: length 23.2
  TOP w0.114: PR9501.2 196.15,80.41 194.75,80.41 194.22,79.87 v1(194.22,79.51)
  IN2 w0.089: v1(200.18,89.57) 200.18,89.34 199.8,88.96 198.88,88.96 197.75,87.82 197.75,86.53 198.32,85.95 198.77,85.95 199.54,85.18 199.54,82.96 197.13,80.56 194.9,80.56 194.22,79.87 v1(194.22,79.51)
  BOTTOM w0.114: v1(200.18,89.57) R2127.1 200.68,90.25 201.07,90.64 202.34,90.64 202.74,90.25 U2004.4
1V8_AON_S:
  vias: v1(197.77,87.72)
1V8_MAIN: length 53.8
  TOP w0.381: R2232.1 228.23,84.15 227.72,83.64 v1(227.72,83.5)
  TOP w0.508: v1(194.27,130.7) 194.2,130.77 L2010.1 194.94,131.61 L2001.2
  IN1 w0.508: v1(203.28,119.72) 202.87,120.13 198.25,120.13 197.11,121.27 197.11,125.59 194.27,128.44 v1(194.27,130.7)
  IN4 w0.381: v1(227.72,83.5) 226.45,83.5 226.4,83.45 223.49,83.45 223.41,83.38 220.96,83.38 220.6,83.01 220.09,83.01 219.12,83.99 206.46,83.99 205.9,84.55 205.9,85.37 204.24,87.04 203.48,87.04 199.55,90.97 v1(199.55,91.07)
  BOTTOM w0.305: U2000.AN28 U2000.AM28
  vias: v1(190.28,85.43) v1(191.12,85.12) v1(191.12,84.49) v1(191.75,85.12) v1(191.75,84.49) v1(204.1,119.72) v1(204.95,119.72) v1(205.78,113.03) v1(205.77,110.55) v1(206.61,118.86) v1(206.66,112.2) v1(206.66,111.31) v1(206.66,110.55) v1(206.66,109.79) v1(206.66,108.77) v1(207.42,113.34) v1(207.42,112.45) v1(208.06,108.39) v1(218.55,104.71) v1(219.18,104.71)
1V8_MAIN_EN: length 86.2
  TOP w0.114: R2231.1 229.36,83.37 228.71,82.72 228.33,82.72 227.62,82.01 227.62,79.52 226.28,78.18 v1(226.28,78.12) ; R2126.2 218.22,94.1 218.57,93.74 218.57,92.17 218.92,91.83 219.61,91.83 v1(220.07,91.37) 220.11,91.34 R2031.2 ; v1(193.49,79.51) 193.49,79.89 v1(193.77,80.17) 193.77,80.88 PR9504.1
  IN3 w0.089: v1(198.53,84.42) 199.33,83.63 199.33,83.08 198.14,81.89 197.18,81.89 195.56,80.28 194.26,80.28 v1(193.49,79.51)
  IN4 w0.076: v1(226.28,78.12) 225.88,77.73 225.48,77.73 225.33,77.88 219.42,77.88 217.43,79.87 205.25,79.87 204.49,79.11 201.65,79.11 200.66,80.1 194.09,80.1 v1(193.49,79.51)
  BOTTOM w0.114: PU9503.1 200.81,84.28 200.21,84.88 PD9501.1 199.8,84.88 199,84.88 v1(198.53,84.42) ; PU25002.2 228.37,82.23 228.12,81.98 226.72,81.98 226.54,81.8 226.54,81.37 226.64,81.27 226.76,81.27 227.44,80.59 227.44,80.1 226.6,79.26 226.6,78.45 v1(226.28,78.12) 226.28,78.18 225.09,79.37 223.48,79.37 222.67,80.18 222.15,80.18 221.9,80.42 221.9,81.37 220.7,82.57 220.7,84.37 220.32,84.76 220.32,85.99 220.51,86.18 220.51,87.05 220.44,87.11 220.44,88.76 220.55,88.87 220.55,89.57 220.16,89.97 219.8,89.97 219.62,90.15 219.62,90.91 v1(220.07,91.37)
1V8_MAIN_EN_R: length 9.3
  TOP w0.114: R2126.1 218.22,95.44 217.84,95.82 217.84,97.1 217.84,97.1 217.84,97.29 217.84,97.29 217.84,97.69 217.05,98.48 216.86,98.67 216.86,100.83 217.09,101.06 217.09,101.48 217.08,101.49 217.08,102.58 v1(216.7,102.96)
  BOTTOM w0.114: v1(216.7,102.96) 216.7,103.02 U2000.P7
1V8_MAIN_S:
  vias: v1(193.61,88.23)
1V8A_PG: length 42.4
  TOP w0.127: PR16014.1 290.8,13.78 291.03,13.55 v1(292.26,13.55)
  IN2 w0.127: v1(296.93,27.77) 297.43,27.27 299.24,27.27 300.26,26.25 300.26,18.51 297.67,15.92 297.67,13.3 296.63,12.26 294.95,12.26 293.66,13.55 v1(292.26,13.55)
  BOTTOM w0.127: PR25007.2 291.62,41.05 292.94,39.72 292.94,36.6 293.81,35.74 293.81,32 293.91,31.9 293.91,31.46 294.8,30.57 295.43,30.57 296.93,29.07 v1(296.93,27.77)
2V5_PG: length 19.8
  TOP w0.127: v1(208.95,31.08) 208.95,30.37 211.49,27.83 211.49,26 209.2,23.71 v1(206.92,23.71) 205.65,23.71 205.4,23.46 202.95,23.46 v1(202.48,23.93)
  BOTTOM w0.127: v1(202.48,23.93) 202.73,24.19 R9279.1 R9278.2 ; PR15012.1 208.21,32.2 208.44,31.97 208.44,31.59 v1(208.95,31.08)
3V3DS_PG: length 85
  IN1 w0.127: v1(219.87,47.59) 219.87,48.17 222.99,51.3 227.39,51.3 228.01,50.68 228.01,34.52 225.58,32.09 225.05,32.09 v1(224.42,31.47)
  IN4 w0.127: v1(262.67,33.67) 258.81,33.67 255.41,30.27 232.37,30.27 229.85,32.78 229.09,32.78 228.89,32.98 227.69,32.98 227.34,32.63 225.58,32.63 v1(224.42,31.47)
  BOTTOM w0.127: PR25024.2 265.76,40.21 264.19,38.65 264.19,37.68 263.53,37.02 263.53,35.42 262.67,34.56 v1(262.67,33.67) ; PR13015.1 218.57,47.24 219.52,47.24 v1(219.87,47.59)
5V_PG: length 115.5
  IN1 w0.076: v1(225.06,31.45) 224.24,30.63 212.44,30.63 210.88,32.2 205.54,32.2 204.12,33.62 201.84,33.62 200.82,34.63 v1(200.82,34.91)
  IN4 w0.076: v1(292.74,32.02) 292.1,31.38 291.12,31.38 290.73,31.77 283.05,31.77 282.52,31.23 280.42,31.23 279.69,31.97 275.55,31.97 274.91,32.6 271.13,32.6 270.04,33.7 266.03,33.7 264.41,32.07 262.88,32.07 261.82,31 257.17,31 255.8,29.63 230.56,29.63 227.92,32.27 225.88,32.27 v1(225.06,31.45)
  BOTTOM w0.114: v1(292.74,32.02) 292.74,36.03 292.39,36.38 292.39,39.06 290.26,41.19 290.26,44.57 291.37,45.68 PR25025.2
  BOTTOM w0.254: PR13007.1 200.2,35.25 200.54,34.91 v1(200.82,34.91)
5V_USBSRC_PG: length 123
  TOP w0.114: PR13018.1 214.49,47.98 v1(215.42,48.91)
  IN1 w0.076: v1(225.69,31.44) 225.69,31.75 228.31,34.37 228.31,50.8 227.51,51.6 222.87,51.6 220.45,49.18 215.7,49.18 v1(215.42,48.91)
  IN4 w0.076: v1(225.69,31.44) 227.66,29.48 255.86,29.48 257.23,30.85 261.91,30.85 262.97,31.92 264.47,31.92 266.1,33.54 269.97,33.54 271.06,32.45 274.85,32.45 275.48,31.82 279.62,31.82 280.37,31.07 282.57,31.07 283.12,31.62 290.67,31.62 291.05,31.23 292.72,31.23 v1(293.38,31.89)
  BOTTOM w0.114: v1(293.38,31.89) 293.38,35.71 292.62,36.47 292.62,39.58 291.12,41.09 291.12,42.01 PR25026.2
8813VID: length 3.2
  BOTTOM w0.254: PR9014.2 210.98,51.1 210.98,51.98 210.31,52.65 PU9001.5
8813VOUT1: length 5.1
  BOTTOM w0.254: PU9001.11 206.8,50.74 206.42,50.36 205.88,50.36 204.98,49.46 PC9033.1 204.89,48.85 205,48.74 PC9034.1 205,47.58 PR9025.1
8813VREF: length 2.9
  BOTTOM w0.254: PU9001.8 208.3,50.12 PC9024.1 PR9015.1
9610VCC: length 3.5
  BOTTOM w0.305: PR9035.2 218.97,56.95 PC9044.1 219.23,56.02 v1(219.08,55.87) 218.46,55.24 PU9002.8
+0.6V_DDR_VTT: length 92.3
  TOP w0.254: PU14000.8 96.19,62.34 v1(95.66,61.81) ; 180.37,38.7 179.85,39.22 JDIM1003.258
  TOP w0.508: 180.37,38.7 180.7,38.37 v1(182.79,38.37)
  IN1 w0.508: v1(183.98,55.97) 184.61,55.34 v1(187.48,55.34) ; v1(182.79,38.37) 182.99,38.37 183.92,37.44 183.92,35.43 180.51,32.02 180.51,31.51 179.69,30.7 v1(179.36,30.7) ; v1(95.66,61.81) 95.13,61.81 93.73,63.21 v1(92.87,63.21)
  IN3 w0.508: v1(183.98,55.97) 183.98,49.11 183.98,48.92 183.34,48.29 183.34,47.51 182.02,46.19 v1(182.02,46.04) 182.02,45.53 182.79,44.77 182.79,43.04 182.02,42.28 182.02,38.83 182.48,38.37 v1(182.79,38.37)
  IN4 w1.016: 163.48,29.68 114.33,29.68 113.82,30.19
  vias: v1(92.11,63.21) v1(112.3,31.71) v1(112.81,31.33) v1(164.88,28.56) v1(165.51,28.56) v1(173.64,29.05) v4(92.62,66.38) v4(92.62,65.62) v4(103.03,63.69) v4(103.77,63.67)
+1.0V_GFX_EN: length 25.9
  TOP w0.114: PQ9502.2 v1(191.28,73.48) ; v1(204.21,86.13) 204.63,85.71 PR9507.1
  IN2 w0.089: v1(191.28,73.48) 191.34,73.55 191.34,76.85 192.06,77.56 195.74,77.56 200.65,82.48 200.65,86.13 v1(200.44,86.35)
  BOTTOM w0.114: v1(200.44,86.35) 200.85,85.94 202.31,85.94 202.67,85.58 PU9503.4 203.98,85.58 204.21,85.81 v1(204.21,86.13) 204.77,85.56 PR9522.1
+1.2V: length 150.7
  TOP w0.508: v1(345.34,34.5) 345.35,34.51 345.35,38.29 344.41,39.23 344.41,41.57 v1(345.35,42.51) ; v1(344.46,46.7) 343.41,45.66 343.41,35.45 v1(344.35,34.51)
  IN1 w0.381: v1(320.2,67.65) 320.58,67.65 321.34,66.89 321.34,65.5 322.74,64.1 323.5,64.1 325.55,62.05 v1(326.14,62.05)
  IN1 w0.508: v1(320.12,54.55) 320.48,54.19 328.56,54.19 v1(329.79,52.96) 329.79,49 330.74,48.05 v1(330.74,45.89) ; v4(330.49,61.89) 330.31,62.07 v1(330.31,62.55) 330.21,62.65 329.14,62.65 328.84,62.96 v1(328.07,62.96) ; v1(339.93,33.61) 339.93,33.92 338.58,35.27 336.96,35.27 334.09,32.4 v1(334.09,31.05)
  IN2 w0.508: v1(330.74,45.89) 331.04,45.58 331.04,33.16 332.09,32.12 334,32.12 v1(334.84,31.28)
  IN3 w0.381: v1(321.89,62.51) 324.33,62.51 325.15,63.34 327.69,63.34 v1(328.07,62.96)
  BOTTOM w0.178: U501.42 343.75,41.04 345.22,42.51 v1(345.35,42.51) ; C504.1 329.46,60.08 329.41,60.02 U500.55 ; 342.95,46.21 342.17,45.43 U501.32 ; U500.43 324.61,60.45 321.72,63.34 321.72,63.85 C512.1 ; 319.31,59.91 319.56,59.65 319.56,58.64 319.94,58.26 U500.32 ; C503.1 321.22,63.18 v1(321.89,62.51) 324.21,60.19 U500.42 ; 336.89,35.12 336.89,35.35 337.78,36.24 U501.3 ; C540.1 346.81,42.75 346.11,42.05 345.42,42.05 v1(344.41,41.04) 344.01,40.64 U501.43
  BOTTOM w0.381: C545.1 345.59,42.75 v1(345.35,42.51) ; v4(330.49,61.89) 330.59,61.79 R17975.2 ; v1(330.74,45.89) 330.74,46.04 331.79,47.09 C539.1 333.25,47.09 333.42,46.93 335.59,46.93 335.9,46.62 336.25,46.62 337.52,45.35 ; v1(330.31,62.55) 331.63,62.55 332.04,62.13 R17975.1 ; v1(350.78,42.69) 350.71,42.75 C541.1 C542.1 C540.1
  BOTTOM w0.508: C504.1 329.47,61.06 C513.1 329.66,62.06 330.16,62.55 v1(330.31,62.55) ; R17973.1 334.66,31.46 v1(334.84,31.28) ; R17973.1 R17973.2 333.88,31.27 v1(334.09,31.05) ; R17973.1 C538.1 335.41,33.16 336.89,34.63 336.89,35.12 ; R17974.2 321.66,67.83 320.96,68.52 v1(320.96,68.8) ; v1(320.2,67.65) 320.45,67.65 320.68,67.43 R17974.1 320.88,67 321.22,66.66 C502.1 C511.1 C512.1 ; v1(313.35,60.94) 313.35,61.06 314.33,62.04 R17972.2 R17972.1 C506.1 317.91,61.05 318.52,60.44 318.78,60.44 319.31,59.91
  vias: v1(206.1,2.99) v1(206.1,2.33) v1(206.76,2.99) v1(206.76,2.33) v1(330.66,60.52) v1(339.43,33.19) v1(339.72,32.61) v1(340.21,33.04) v1(342.93,61.43) v1(344.61,33.67) v1(344.99,28.32) v1(345.45,28.77) v1(345.97,28.4) v1(346.06,29.1) v1(350.81,65.24) v1(350.81,64.61) v1(361.47,54.83) v1(361.47,54.19) v1(362.11,54.83) v1(362.11,54.19)
+1.2V_8409: length 17.6
  TOP w0.114: C12066.2 361.6,59.53 v1(362.11,59.02) 361.6,58.51 C12065.1 ; v3(358.1,62.57) 358.55,62.57 358.93,62.19 C12063.2 C12062.1 C12061.1 v3(356.9,62.57) ; v1(354.49,58.49) 354.51,58.51 C12057.1 C12058.1 C12060.2 v1(354.49,60.54)
  TOP w0.381: C12052.1 357,55.06 v3(356.9,54.95)
  BOTTOM w0.178: v3(356.9,54.95) 356.9,54.96 U12006.46 ; v1(362.11,59.02) 362.05,58.96 U12006.30 ; U12006.15 356.9,62.57 v3(356.9,62.57) ; U12006.6 354.54,58.57 354.49,58.51 v1(354.49,58.49) ; U12006.11 354.51,60.57 v1(354.49,60.54) ; U12006.43 358.1,55.01 v3(358.05,54.95) ; U12006.18 v3(358.1,62.57)
  BOTTOM w0.381: v3(356.9,54.95) 356.4,54.46 C12055.2 ; C12054.2 v3(358.05,54.95)
+1.2V_VCCPLL_OC: length 48.7
  TOP w0.508: v1(118.9,100.29) 119.15,100.05 119.15,98.25 118.27,97.37 115.34,97.37 114.84,96.87 114.84,95.85 115.59,95.1 PR23014.1 115.98,94.45 117.22,93.22 PC23013.1 119.24,93.22 PC23012.1 120.33,93.17 120.45,93.05 PQ23006.1 ; R9044.2 147.7,108.55 v1(147.02,108.55)
  IN3 w0.508: v1(147.02,108.55) 146.03,108.55 145.4,109.18 144.81,109.18 144.28,108.65 131.93,108.65 124.24,100.95 119.56,100.95 v1(118.9,100.29)
+1.2VSUS: length 310.3
  TOP w0.203: v1(132.89,43.83) 133.47,44.41 C1004.1 ; C1099.1 132.24,44.41 v1(132.88,45.05) ; C1038.1 125.61,43.86 v1(125.39,43.65) ; C1036.1 168.97,44.66 168.29,45.34 167.25,45.34 ; v1(118.9,45.23) 118.68,45 C1060.1 ; C1009.1 C1104.1 ; v1(171.48,44.39) 171.51,44.41 C1008.1
  TOP w0.254: JDIM1003.220 170.36,41.73 v1(170.09,42) ; JDIM1003.12 116.35,41.46 v1(116.07,41.75) ; JDIM1000.199 165.1,47.36 v1(165.77,46.7) ; 141.35,58.34 JDIM1000.112 ; 148.85,58.34 JDIM1000.142 ; 147.35,58.34 JDIM1000.136 ; v1(126.85,41.67) JDIM1003.54 ; v1(132.1,30.7) JDIM1003.75 ; 126.4,60.96 126.4,58.89 ; v1(159.67,42.21) 159.85,42.03 JDIM1003.178 ; v1(121.78,47.13) 121.6,47.31 JDIM1000.33 ; 144.35,58.34 JDIM1000.124 ; JDIM1000.75 132.1,47.22 132.37,46.95 v1(132.88,46.95) ; 153.85,58.34 JDIM1000.154 ; v1(137.73,43.16) 137.73,43.18 137.35,42.8 JDIM1003.96 ; v1(175.22,46.72) 175.6,47.11 JDIM1000.241 ; 152.35,58.34 JDIM1000.148 ; 142.85,58.34 JDIM1000.118 ; 155.35,58.34 JDIM1000.160 ; 175.6,29.75 v1(175.6,30.8) JDIM1003.241 ; 145.85,58.34 JDIM1000.130
  TOP w0.381: C1016.1 165.5,45.17 v1(165.77,45.43) ; v1(119.72,43.52) 120.29,44.09 C1011.1 ; v1(121.78,45.22) 122.32,44.68 C1106.1 ; v1(137.19,45.05) 136.56,44.41 C1015.1 ; v1(165.49,43.12) 164.51,44.1 C1109.1 ; v1(137.2,43.8) 137.82,44.41 C1105.1 ; v1(130.74,45.2) 130.6,45.06 C1012.1 ; C1107.1 127.67,44.41 v1(126.85,45.23) ; v1(161.17,45.39) 161.46,45.11 C1013.1 ; C1104.1 115.99,43.73 v1(116.07,43.65) ; v1(175.22,44.67) 174.96,44.67 174.71,44.41 C1017.1 ; C1010.1 114.21,43.74 v1(114.13,43.65)
  TOP w0.508: 139.48,27.14 139.48,24.35 v1(140.49,23.33) ; 158.02,27.52 158.02,24.09 157.51,23.59 v1(157.51,22.98) v1(157.51,17.77) ; C1111.1 167.25,44.41 167.25,45.34 v1(167.16,45.43)
  IN2 w0.508: v1(157.51,17.77) 162.79,17.77 163.69,16.87 171.79,16.87 172.28,16.37 174.8,16.37 175.66,17.23 180.65,17.23 182.23,18.81 195.59,18.81 196.17,19.39 204.75,19.39 205.33,18.81 214.94,18.81 216.54,20.41 218.99,20.41 223.76,25.18 232.69,25.18 234.81,27.3 237.17,27.3 238.48,28.62 245.34,28.62 248.81,32.08 249.65,32.08 252.12,34.55 253,34.55 255.5,37.05 258.05,37.05 259.29,38.28 259.29,39.66 259.75,40.12 259.75,41.83 263.42,45.5 264.37,45.5 266.45,47.58 266.45,48.54 267.75,49.83 267.75,51.7 269.75,53.7 270.4,53.7 271,54.3 271,55.17 270.86,55.31 270.86,57.63 271.87,58.64 271.87,59.23 v1(274.09,61.44)
  BOTTOM w0.203: v1(125.39,45.23) 125.61,45.01 C1038.1 125.61,43.86 v1(125.39,43.65) ; v1(118.9,45.23) 118.68,45 C1060.1 ; v1(171.48,44.39) 171.51,44.41 C1008.1 ; v1(116.07,43.65) 116.83,44.41 C1009.1 ; v1(132.89,43.83) 133.46,43.83 133.79,44.16 C1004.1 ; v1(140.49,23.33) 140.54,23.38 C1123.1 ; C1036.1 168.97,44.64 168.59,45.02 167.57,45.02 167.28,45.31 ; v1(132.88,45.05) 133.23,44.7 C1095.1 ; v1(171.48,45.02) 171.23,45.02 170.82,44.61 C1092.1 ; v1(130.79,43.6) 131.6,44.41 C1071.1 ; C1067.1 C1013.1 ; C1124.1 157.48,23.88 R1030.1 ; C1100.1 126.68,45.05 v1(126.85,45.23)
  BOTTOM w0.254: JDIM1002.33 121.6,41.44 v1(121.78,41.62) ; 155.35,30.85 JDIM1002.160 ; JDIM1002.220 v1(170.36,30.68) ; JDIM1001.123 144.1,58.6 144.18,58.67 ; 171.1,46.93 170.85,46.93 170.36,47.42 JDIM1001.220 ; 142.85,30.93 JDIM1002.118 ; JDIM1002.142 148.85,30.93 148.6,30.68 v1(148.63,30.68) ; 145.7,58.54 145.6,58.45 JDIM1001.129 ; v1(159.85,30.64) JDIM1002.178 ; v1(164.57,42.18) 165.1,41.65 JDIM1002.199 ; JDIM1002.148 152.35,30.93 v1(152.1,30.68) ; v1(175.22,42.12) 175.6,41.73 JDIM1002.241 ; v1(159.42,46.93) 159.85,47.37 JDIM1001.178 ; JDIM1002.75 132.1,41.54 132.87,42.31 ; v1(141.3,30.7) 141.33,30.7 141.35,30.72 JDIM1002.112 ; JDIM1002.136 147.35,30.93 147.35,30.93 v1(147.35,30.7) ; v1(126.85,47.13) JDIM1001.54 ; JDIM1001.111 141.1,59.2 ; v1(145.4,30.7) 145.85,31.16 JDIM1002.130 ; JDIM1002.154 153.85,31.1 153.4,30.65 v1(153.4,30.62) ; JDIM1001.96 137.35,47.12 v1(137.19,46.95) ; JDIM1002.12 116.35,31.14 116.64,30.85 v1(116.64,30.67) ; JDIM1001.153 153.6,58.51 ; JDIM1001.159 155.1,58.42 ; v1(165.26,58.74) 165.1,58.59 JDIM1001.199 ; JDIM1002.54 126.85,31.16 126.52,30.82 v1(126.52,30.62) ; 148.6,58.97 JDIM1001.141 ; JDIM1001.12 116.35,46.99 v1(116.07,46.7) ; 147.1,58.68 JDIM1001.135 ; v1(144.74,30.68) 144.74,30.74 144.35,31.13 JDIM1002.124 ; JDIM1001.163 156.1,58.43 ; JDIM1002.96 137.35,31.17 137.7,30.82 v1(137.7,30.62) ; JDIM1001.147 152.1,58.73 ; 142.6,58.88 JDIM1001.117
  BOTTOM w0.381: v1(175.22,44.67) 174.79,44.67 C1017.1 ; C1012.1 130.6,45.06 v1(130.74,45.2) ; v1(137.2,43.8) 137.82,44.41 C1105.1 ; v1(119.72,43.52) 120.29,44.09 C1011.1 ; v1(137.19,45.05) 136.56,44.41 C1015.1 ; C1109.1 164.51,44.1 v1(165.49,43.12) ; v1(126.85,43.58) 127.13,43.58 127.97,44.41 C1107.1 ; C1010.1 114.21,43.74 v1(114.13,43.65) ; 171.1,46.93 v1(171.46,46.93) ; C1047.1 114.45,45.18 v1(114.13,45.18) ; v1(160.97,43.65) 161.46,44.14 C1013.1 ; C1106.1 122.32,44.68 v1(121.78,45.22) ; C1016.1 165.5,45.17 v1(165.77,45.43) ; C1111.1 167.28,45.31 v1(167.16,45.43)
  BOTTOM w0.508: R9085.2 274.09,61 v1(274.09,61.44) ; R1002.1 139.48,23.66 139.88,23.26 140.42,23.26 v1(140.49,23.33) ; R1030.1 157.52,22.99 v1(157.51,22.98) ; 132.87,42.31 v1(132.89,42.31)
  vias: v1(111.87,71.69) v1(111.87,71.06) v1(111.87,70.42) v1(111.87,69.79) v1(111.87,69.1) v1(112.86,71.64) v1(112.86,71.01) v1(112.86,70.37) v1(112.86,69.74) v1(112.86,69.05) v1(115.98,30.6) v1(118.11,59.88) v1(118.11,59.25) v1(119.72,59.91) v1(119.72,59.27) v1(121.29,30.67) v1(121.39,60.34) v1(121.39,59.7) v1(121.39,59.07) v1(121.93,30.65) v1(122.97,60.01) v1(122.97,59.37) v1(125.64,59.98) v1(125.64,59.35) v1(127.15,59.98) v1(127.15,59.35) v1(127.16,30.6) v1(128.45,59.98) v1(128.45,59.35) v1(132.29,60.97) v1(132.29,60.34) v1(132.29,59.68) v1(132.29,59.04) v1(132.29,58.41) v1(134.4,67.32) v1(134.4,66.69) v1(134.4,66) v1(134.4,65.34) v1(134.4,64.68) v1(134.4,64.05) v1(134.4,60.7) v1(134.4,60.03) v1(137.07,30.62) v1(137.17,60.01) v1(137.24,60.64) v1(141.94,30.67) v1(142.58,30.68) v1(142.73,46.34) v1(142.73,45.07) v1(142.73,44.44) v1(142.73,43.17) v1(142.73,41.87) v1(143.24,30.67) v1(145.57,46.19) v1(145.57,45.56) v1(145.57,43.02) v1(145.57,42.38) v1(146.11,30.72) v1(146.59,45.94) v1(146.59,44.67) v1(146.59,44.03) v1(146.59,42.33) v1(147.99,30.7) v1(149.33,30.7) v1(150.02,42.89) v1(150.02,41.62) v1(150.02,40.98) v1(150.02,40.35) v1(150.02,39.69) v1(150.1,45.63) v1(150.74,103.3) v1(151.47,30.67) v1(152.51,107.91) v1(152.51,107.26) v1(152.76,30.62) v1(152.91,60.39) v1(152.91,59.7) v1(152.91,59.04) v1(152.91,58.38) v1(153.26,103.36) v1(154.06,30.62) v1(154.69,30.62) v1(154.93,43.2) v1(157.97,107.21) v1(160.51,30.65) v1(160.73,105.92) v1(160.79,103.27) v1(162.54,107.87) v1(165.06,63.36) v1(165.16,30.72) v1(165.26,62.55) v1(165.26,61.91) v1(165.26,61.28) v1(165.26,60.64) v1(165.26,60.01) v1(165.26,59.37) v1(165.82,103.31) v1(166.22,107.22) v1(166.53,89.75) v1(167.16,60.14) v1(167.16,59.5) v1(168.36,103.31) v1(170.36,60.31) v1(170.36,59.68) v1(171.94,60.26) v1(171.94,59.63) v1(173.33,103.3) v1(173.56,108.01) v1(173.73,60.03) v1(173.73,59.4) v1(174.32,107.24) v1(175.06,103.31) v1(200.77,13.6) v1(201.05,13.02) v4(109.1,44.21) v4(109.1,43.47) v4(109.1,42.74) v4(109.1,42) v4(109.13,41.26) v4(109.13,40.48) v4(109.13,39.71) v4(109.76,44.59) v4(109.76,43.86) v4(109.76,43.12) v4(109.76,42.38) v4(109.76,41.65) v4(109.76,40.86) v4(109.76,40.1)
+1.2VSUS_S: length 1.7
  TOP w0.254: PU14000.6 95.79,63.34 v1(95.54,63.09)
  TOP w0.508: v1(94.9,63.08) 95.53,63.08 v1(95.54,63.09)
  vias: v1(97.44,53.68) v1(97.82,53.18) v1(98.2,53.68) v1(99.98,48.48)
+1.5V: length 40.3
  TOP w1.016: 95.03,44.79 97.24,42.59 97.24,41.82 101.25,37.81 PJP16001.2 ; 86.85,55.21 87.15,55.21 92.81,49.55 93.45,49.55 93.45,48.03 93.89,47.59 93.89,46.19
  IN4 w1.016: 83.85,55.79 80.52,55.79 77.68,58.64 74.96,58.64 71.66,61.94 70.39,61.94
  BOTTOM w0.508: R3053.2 68.98,60.93 v1(69.42,61.38)
  vias: v1(58.45,64.23) v1(58.86,65.09) v1(59.21,64.53) v1(68.89,61.73) v1(85.22,56.02) v1(85.85,56.02)
+1.05V_DEEP_SUS: length 445.6
  TOP w0.381: R17900.2 231.24,69.71 v1(231.24,69.81)
  TOP w0.508: v1(84.77,71.46) 84.77,72.04 EC9041.1 85.1,72.14 85.35,72.4 EC9042.2 ; v1(188.63,142.53) 188.93,142.23 PQ23004.3 190,141.57 189.89,141.46 PC23006.1 189.89,140.38 190.46,139.82 PQ23003.3 190.46,136.08 189.84,135.46 PC23005.1
  IN1 w0.508: v1(172.75,119.01) 170.44,119.01 169.35,120.11 169.35,127.79 170.43,128.87 171.83,128.87 172.35,129.38 172.35,130.68 171.86,131.16 171.86,134.69 172.37,135.19 175.42,135.19 177.17,133.44 179.23,133.44 180.19,134.41 180.19,136.95 182.71,139.46 185.76,139.46 188.73,142.43 v1(188.63,142.53) ; v1(84.77,71.46) 83.67,71.46 81.57,69.36 81.57,66.16 80.9,65.5 v1(80.9,61.18)
  IN2 w0.381: v1(233.55,75.95) 232.9,76.6 232.9,79.87 234.55,81.52 236.13,81.52 v1(237.37,80.28) 240.52,80.28 v1(240.75,80.51)
  IN2 w0.508: v1(94.16,43.7) 94.65,43.7 100.17,38.19 100.17,29.98 101.51,28.64 101.51,23.79 103.38,21.92 104.92,21.92 105.32,21.52 115.29,21.52 116.16,20.65 164.07,20.65 164.81,21.4 180.37,21.4 180.97,21.99 189.59,21.99 190.52,22.93 191.06,22.93 191.28,22.72 194.99,22.72 195.64,23.37 198.9,23.37 199.8,22.47 206.01,22.47 206.42,22.88 214.68,22.88 215.39,23.59 217.76,23.59 222.41,28.24 231.42,28.24 233.55,30.37 235.85,30.37 237.16,31.68 239.92,31.68 244.51,36.27 245.97,36.27 247.72,38.02 247.72,38.51 250.48,41.26 251.84,41.26 252.52,41.94 252.52,43.53 253.02,44.03 253.02,45.43 v1(253.78,46.19) ; v1(121.83,102.96) 122.08,102.71 122.08,101.27 118.18,97.37 116.75,97.37 116.51,97.61 115.36,97.61 114.59,96.84 114.59,95.47 113.7,94.58 112.17,94.58 111.54,93.94 111.54,91.25 111.16,90.87 111.16,90.26 110.65,89.75 109.89,89.75 108.49,91.15 107.35,91.15 106.97,90.77 106.97,85.73 99.98,78.74 99.98,75.88 98.77,74.68 97.19,74.68 96.49,73.98 93.96,73.98 93.19,73.2 92.07,73.2 90.46,71.59 86.45,71.59 85.95,72.09 85.43,72.09 84.81,71.46 v1(84.77,71.46)
  IN4 w0.508: v1(172.75,119.01) 172.12,118.38 172.12,110.96 171.32,110.17 155.13,110.17 154.24,111.06 145.52,111.06 144.89,110.43 143.16,110.43 142.53,111.06 138.84,111.06 138.2,110.42 135.84,110.42 132.72,107.3 130.26,107.3 128.35,105.4 128.35,104.76 122.94,99.35 v1(122.94,99.28) ; v1(80.9,61.18) 81.49,60.59 81.49,58.4 83.18,56.71 86.14,56.71 86.52,56.33 86.52,53.94 86.27,53.68 86.27,53.13 v1(86.39,53)
  BOTTOM w0.254: R402.2 82.21,70.19 81.06,70.19 80.73,69.87 CON400.44 ; CON400.43 80.73,61.6 80.9,61.43 v1(80.9,61.18)
  BOTTOM w0.381: R9141.2 237.85,80.28 v1(237.37,80.28) ; R9124.1 241.13,80.12 v1(240.75,80.51)
  BOTTOM w0.508: EC9045.1 121.39,103.39 v1(121.83,102.96) 122.97,102.96 123.86,102.07 PQ26000.3 123.86,100.19 v1(122.94,99.28) 122.94,98.54 123.85,97.64 EC9046.1 123.85,92.52 PQ26003.3 ; R402.2 83.34,70.83 83.98,71.46 v1(84.77,71.46) ; v1(86.39,53) 86.4,52.99 EC9044.1 86.4,51.9 87.48,50.82 89.32,50.82 93.29,46.85 93.29,44.58 v1(94.16,43.7)
  vias: v1(229.44,71.46) v1(229.62,72.71) v1(229.62,72.07) v1(248.95,65.24) v1(249.34,68.42) v1(249.71,64.53) v1(249.88,68.99) v1(249.88,67.85) v1(249.91,63.93) v1(250.42,68.42) v1(250.43,67.34) v1(250.78,63.46) v1(250.97,68.97) v1(250.97,67.88) v1(251.5,64.04) v1(252.07,66.78) v1(252.62,67.3) v1(252.62,66.23) v1(253.14,66.78) v1(253.71,66.23) v1(253.78,46.83) v1(254.41,46.83) v1(254.41,46.19) v1(283.62,69.05) v4(284.13,70.68) v4(284.26,69.94) v4(284.51,69.2) v4(284.89,70.65) v4(284.99,69.92) v4(285.15,68.49) v4(285.27,69.23) v4(285.66,70.68) v4(285.78,69.94) v4(285.88,68.49) v4(286.04,69.23) v4(286.42,70.68) v4(286.54,69.94) v4(286.62,68.47) v4(286.77,69.2) v4(287.28,69.94) v4(287.51,69.2)

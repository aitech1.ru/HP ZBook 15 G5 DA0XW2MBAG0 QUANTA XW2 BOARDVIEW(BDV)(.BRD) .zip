# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_DPLL_NSCCLKP: length 107
  IN1 w0.076: v1(185.01,124.52) 184.87,124.38 184.87,123.81 185.3,123.37 185.3,106.34 195.05,96.59 195.05,95.77 196.63,94.2 197.26,94.2 203.49,87.97 205.95,87.97 207.72,86.21 218.95,86.21 219.55,85.61 221.07,85.61 221.46,85.22 225.65,85.22 226.71,84.16 228.1,84.16 228.73,83.54 231.14,83.54 231.59,83.09 231.59,82.48 232.99,81.08 232.99,77.5 234.39,76.11 234.39,75.09 235.49,73.98 235.49,71.67 236.25,70.91 236.25,66.38 236.51,66.13 v1(236.51,65.37)
  BOTTOM w0.079: U9001.E31 176.94,122.67 176.94,122.52 177.12,122.34 179.03,122.34 179.21,122.51 182.68,122.51 183.4,123.23 183.56,123.23 183.59,123.21 183.6,123.21
  BOTTOM w0.102: 183.6,123.21 184.19,123.21 184.83,123.86 184.83,124.35 v1(185.01,124.52) ; v1(236.51,65.37) 236.51,65.66 236.84,65.99 237.22,65.99 238.24,67.01 U9002.D7
CLK_PCIE_GFXN: length 79.1
  IN3 w0.089: v1(247.3,74.56) 247.3,74.46 247.09,74.25 246.38,74.25 245.24,75.39 244.88,75.39 244.37,75.9 242.63,75.9 241.14,77.39 241.14,77.84 237.69,81.29 234.66,81.29 232.41,79.05 229.15,79.05 228.58,79.62 227.55,79.62 227.18,79.25 225.94,79.25 225.58,79.61 220.44,79.61 219.69,80.36 212.22,80.36 209.18,83.4 206.13,83.4 204.82,84.72 204.82,87.26 203.74,88.34 203.74,89.95 199.41,94.28 199.41,98.93 199.82,99.33 199.82,101.83 200.51,102.53 200.51,104.71 201.7,105.89 201.7,107.25 202.06,107.62 202.64,107.62 202.8,107.46 203.28,107.46 203.85,108.02 v1(204.08,108.02)
  BOTTOM w0.102: U2000.AK13 203.68,108.42 v1(204.08,108.02) ; v1(247.3,74.56) 247.48,74.74 U9002.AH9
CLK_PCIE_GFXP: length 79.1
  IN3 w0.089: v1(203.28,108.02) 203.28,107.72 203.2,107.65 202.88,107.65 202.72,107.81 201.98,107.81 201.5,107.33 201.5,105.97 200.32,104.79 200.32,102.61 199.63,101.91 199.63,99.41 199.22,99.01 199.22,94.2 203.55,89.87 203.55,88.26 204.63,87.18 204.63,84.64 206.06,83.21 209.1,83.21 212.14,80.17 219.61,80.17 220.36,79.42 225.5,79.42 225.86,79.06 227.26,79.06 227.63,79.43 228.5,79.43 229.07,78.86 232.49,78.86 234.74,81.1 237.61,81.1 240.95,77.76 240.95,77.31 242.55,75.71 244.3,75.71 244.8,75.2 245.16,75.2 246.3,74.06 247.31,74.06 v1(247.44,73.93)
  BOTTOM w0.102: U9002.AH10 247.87,74.36 247.45,73.93 v1(247.44,73.93) ; U2000.AL13 203.28,108.05 v1(203.28,108.02)
CLK_PCIE_LANN: length 290.6
  IN3 w0.089: v1(26.96,113.63) 27.09,113.76 27.45,113.76 28.34,112.87 28.34,104.03 28.79,103.57 28.79,97.03 29.17,96.66 29.17,93.34 33.92,88.58 33.92,82.86 38.07,78.72 38.07,74.09 39.4,72.76 39.4,71.66 40.61,70.45 40.61,69.73 41.99,68.35 45.41,68.35 49.92,63.84 54.43,63.84 57.1,61.18 58.13,61.18 60.01,59.3 72.9,59.3 76.76,55.44 78.38,55.44 79.03,56.09 83.86,56.09 84.5,55.44 88.67,55.44 89.19,55.96 89.19,56.95 91.58,59.34 96.91,59.34 102.66,65.09 107.27,65.09 107.7,64.66 115.56,64.66 120.02,69.12 168.16,69.12 175.14,76.1 209.07,76.1 209.88,75.29 216.31,75.29 216.97,74.63 216.97,73.08 220.02,70.03 224.98,70.03 226.77,68.24 231.5,68.24 233.5,70.23 235.31,70.23 235.73,69.81 238.13,69.81 238.35,70.03 241.74,70.03 241.89,69.88 242.4,69.88 242.92,69.36 246.99,69.36 248.62,70.98 248.62,71.77 248.54,71.85 v1(248.54,72.22)
  BOTTOM w0.102: v1(248.54,72.22) U9002.AE14 ; v1(26.96,113.63) 26.19,113.63 25.04,114.78 25.04,120.21 24.94,120.31 U4000.45
CLK_PCIE_LANP: length 290.4
  IN3 w0.089: v1(248.01,71.68) 248.12,71.8 248.32,71.8 248.43,71.68 248.43,71.06 246.91,69.55 243,69.55 242.48,70.07 241.97,70.07 241.81,70.22 238.27,70.22 238.05,70 235.81,70 235.39,70.42 233.42,70.42 231.43,68.43 226.85,68.43 225.06,70.22 220.1,70.22 217.16,73.16 217.16,74.71 216.39,75.48 209.96,75.48 209.15,76.29 175.06,76.29 168.08,69.31 119.94,69.31 115.48,64.85 107.77,64.85 107.35,65.28 102.58,65.28 96.83,59.53 91.5,59.53 89,57.03 89,56.03 88.6,55.63 84.58,55.63 83.94,56.28 78.95,56.28 78.31,55.63 76.84,55.63 72.98,59.5 60.09,59.5 58.21,61.37 57.18,61.37 54.51,64.04 50,64.04 45.49,68.54 42.07,68.54 40.8,69.81 40.8,70.53 39.59,71.73 39.59,72.83 38.26,74.17 38.26,78.8 34.11,82.94 34.11,88.66 29.36,93.42 29.36,96.74 28.98,97.11 28.98,103.65 28.53,104.11 28.53,112.95 27.53,113.95 27.21,113.95 26.96,114.21 v1(26.96,114.39)
  BOTTOM w0.102: U9002.AE15 v1(248.01,71.68) ; v1(26.96,114.39) 26.96,114.22 26.57,113.83 26.28,113.83 25.24,114.87 25.24,120.21 25.34,120.31 U4000.44
CLK_PCIE_SDN: length 236.9
  IN3 w0.089: v1(40.8,72.86) 41.01,72.65 41.01,72.25 42.24,71.02 43.28,71.02 43.91,70.39 45.7,70.39 49.83,66.26 55.4,66.26 56.67,64.99 56.67,64.34 58.67,62.35 62.6,62.35 63.58,61.37 65.9,61.37 66.79,62.26 71.96,62.26 75.46,58.76 81.12,58.76 84.54,62.18 92.68,62.18 94.09,63.59 95.85,63.59 96.53,64.27 98.01,64.27 100.58,66.84 113.96,66.84 118.01,70.9 167.42,70.9 174.4,77.87 209.89,77.87 210.68,77.09 217.07,77.09 218.73,75.43 218.73,73.81 220.75,71.79 226.2,71.79 227.01,70.98 228.9,70.98 229.04,70.84 229.98,70.84 231.75,72.61 234.7,72.61 235.72,73.62 241.89,73.62 242.98,74.72 243.82,74.72 244,74.54 244,74.36 243.9,74.26 v1(243.62,74.26)
  BOTTOM w0.089: U9002.AC2 243.3,75.35 243.3,74.77 243.35,74.72 243.35,74.71 243.62,74.44 v1(243.62,74.26)
  BOTTOM w0.102: v1(40.8,72.86) 40.57,73.09 40.21,73.09 37.24,70.12 35.24,70.12 33.97,68.85 32.06,68.85 31.97,68.76 U7301.6
CLK_PCIE_SDP: length 236.7
  IN3 w0.089: v1(40.8,73.5) 41.21,73.09 41.21,72.33 42.32,71.21 43.35,71.21 43.99,70.58 45.78,70.58 49.91,66.45 55.48,66.45 56.86,65.07 56.86,64.42 58.74,62.54 62.68,62.54 63.66,61.56 65.82,61.56 66.71,62.45 72.04,62.45 75.54,58.95 81.04,58.95 84.46,62.37 92.6,62.37 94.01,63.78 95.77,63.78 96.45,64.46 97.93,64.46 100.5,67.03 113.88,67.03 117.93,71.09 167.34,71.09 174.32,78.06 209.97,78.06 210.76,77.28 217.15,77.28 218.92,75.51 218.92,73.89 220.83,71.98 226.28,71.98 227.09,71.17 228.97,71.17 229.11,71.03 229.9,71.03 231.67,72.8 234.62,72.8 235.64,73.81 241.81,73.81 242.9,74.91 243.99,74.91 v1(244.13,75.05)
  BOTTOM w0.102: U9002.AC3 243.5,74.92 243.5,75.15 243.59,75.25 243.93,75.25 v1(244.13,75.05) ; v1(40.8,73.5) 40.6,73.29 40.13,73.29 37.16,70.32 35.16,70.32 33.89,69.05 32.09,69.05 31.98,69.16 U7301.5
CLK_PCIE_SSD1N: length 101.4
  IN1 w0.076: v1(319.84,36.74) 319.63,36.96 319.63,37.11 319.31,37.43 312.2,37.43 310.25,39.37 306.83,39.37 305.95,40.25 295.54,40.25 294.66,41.12 288.49,41.12 286.72,42.89 281.21,42.89 279.22,44.88 278.18,44.88 275.4,47.66 271.99,47.66 266.18,53.47 265.15,53.47 263.75,54.87 262.67,54.87 262.16,55.37 262.16,57.88 261.02,59.02 261.02,62.07 258.52,64.57 257.3,64.57 253.24,68.63 253.24,71.11 252.84,71.51 251.7,71.51 251.33,71.88 251.08,71.88 248.77,74.2 248.58,74.2 246.99,75.78 246.53,75.78 v1(246.44,75.88)
  BOTTOM w0.102: v1(319.84,36.74) 319.59,37 319.59,38.98 320.91,40.3 322.08,40.3 322.23,40.15 CON5100.53 ; 246.71,76.35 246.71,76.15 v1(246.44,75.88)
CLK_PCIE_SSD1P: length 101.4
  IN1 w0.076: v1(319.21,36.74) 319.46,37 319.46,37.04 319.24,37.26 312.13,37.26 310.19,39.21 306.76,39.21 305.88,40.08 295.47,40.08 294.6,40.96 288.42,40.96 286.65,42.72 281.14,42.72 279.15,44.71 278.11,44.71 275.33,47.49 271.92,47.49 266.11,53.3 265.08,53.3 263.68,54.7 262.6,54.7 261.99,55.31 261.99,57.81 260.85,58.95 260.85,62 258.45,64.4 257.23,64.4 253.07,68.56 253.07,71.05 252.77,71.35 251.63,71.35 251.26,71.72 251.01,71.72 248.7,74.03 248.51,74.03 246.92,75.62 246.85,75.62 246.68,75.45 v1(246.68,75.28)
  BOTTOM w0.102: CON5100.55 322.26,40.65 322.11,40.5 320.83,40.5 319.39,39.06 319.39,36.92 v1(319.21,36.74) ; U9002.AJ7 v1(246.68,75.28)
CLK_PCIE_SSD2N: length 171.3
  IN4 w0.076: v1(241.71,74.64) 241.71,74.77 242.01,75.06 242.01,76.63 240.9,77.74 239.38,77.74 236.89,80.23 236.89,80.63 235.99,81.54 234.79,81.54 232.44,79.19 232.44,76.42 231.17,75.15 231.17,71.85 229.53,70.21 229.53,52.27 229.97,51.84 229.97,36.5 234.02,32.44 244.75,32.44 247.05,34.73 255.02,34.73 255.81,35.52 258.12,35.52 258.97,34.67 270.38,34.67 271.19,33.86 281.96,33.86 282.54,34.44 287.2,34.44 288.48,33.16 294.62,33.16 295.19,32.59 297.54,32.59 297.91,32.22 311.18,32.22 312.3,31.1 317.3,31.1 317.41,31 v1(317.41,30.7)
  BOTTOM w0.102: CON5101.53 321.39,17.15 320.2,18.35 320.2,21.93 319.61,22.52 319.61,24.14 319.11,24.64 319.11,28.07 317.41,29.78 v1(317.41,30.7) ; v1(241.71,74.64) 241.61,74.54 241.61,74.41 241.74,74.28 242.09,74.28 242.77,73.6 U9002.W4
CLK_PCIE_SSD2P: length 171.3
  IN4 w0.076: v1(318.04,30.7) 317.94,30.7 317.37,31.27 312.37,31.27 311.25,32.39 297.97,32.39 297.61,32.76 295.26,32.76 294.68,33.33 288.55,33.33 287.27,34.61 282.47,34.61 281.89,34.03 271.26,34.03 270.45,34.84 259.04,34.84 258.18,35.69 255.74,35.69 254.95,34.9 246.98,34.9 244.68,32.6 234.09,32.6 230.13,36.57 230.13,51.91 229.7,52.34 229.7,70.14 231.34,71.78 231.34,75.08 232.61,76.35 232.61,79.12 234.86,81.37 235.92,81.37 236.72,80.57 236.72,80.16 239.31,77.57 240.83,77.57 241.84,76.57 241.84,75.13 241.72,75.01 241.56,75.01 241.47,74.91 241.31,74.91 v1(241.21,75.02)
  BOTTOM w0.102: CON5101.55 322.62,17.65 322.47,17.5 322.47,17.45 322.38,17.35 321.48,17.35 320.4,18.43 320.4,22.02 319.82,22.6 319.82,24.22 319.31,24.73 319.31,28.16 317.61,29.86 317.61,30.29 318.01,30.7 v1(318.04,30.7) ; v1(241.21,75.02) 241.08,74.89 241.08,74.64 241.64,74.08 242.01,74.08 242.34,73.75 U9002.W3
CLK_PCIE_TBTN: length 215.1
  IN1 w0.076: v1(240.95,76.67) 240.58,76.67 240.41,76.83 240.25,76.83 239.97,77.11 239.97,77.71 240.35,78.08 242.06,78.08 242.67,77.47 245.02,77.47 245.61,78.06 247.8,78.06 248.92,76.94 249.45,76.94 249.68,76.71 250.67,76.71 252.23,75.15 252.7,75.15 252.96,74.89 253.49,74.89 254.76,76.16 254.76,76.32 255.27,76.84 255.59,76.84 257.92,74.51 259.32,74.51 259.79,74.04 259.79,72.7 264.2,68.28 264.2,67.01 266.35,64.86 266.35,63.34 266.64,63.04 266.64,61.47 270.78,57.33 270.78,55.97 271.14,55.61 274.17,52.58 275.74,52.58 276.64,51.68 277.46,51.68 280.39,48.75 282.34,48.75 285.03,46.06 288.08,46.06 289.06,45.09 293.29,45.09 293.67,44.71 296.04,44.71 296.76,43.98 300.84,43.98 301,44.15 306.85,44.15 307.16,44.45 307.16,45.06 307.88,45.79 309.94,45.79 314.38,41.34 323.12,41.34 323.95,40.52 326.08,40.52 326.67,41.11 333.53,41.11 335.02,42.6 335.02,45.61 337.73,48.32 337.73,49.21 339.48,50.96 341.13,50.96 341.38,51.21 341.57,51.21 344.5,54.14 346.28,54.14 347.55,55.42 347.55,57.09 347.93,57.46 347.93,58.1 348.46,58.63 348.46,62.03 350.01,63.58 350.01,65.79 349.37,66.42 349.37,71.53 349.8,71.97 349.8,73.94 348.28,75.46 348.28,76.3 346.93,77.65 339.94,77.65 336.67,80.92 336.67,89.57 338.07,90.96 338.07,100.89 340.28,103.1 340.28,105.37 340.99,106.08 340.99,109.24 340.46,109.78 340.46,111.01 340.94,111.49 341.28,111.49 341.59,111.8 v3(341.59,111.98)
  BOTTOM w0.102: U9002.AB2 242.77,75.19 241.28,76.67 v1(240.95,76.67)
  BOTTOM w0.114: U8001.T19 v3(341.59,111.98)
CLK_PCIE_TBTP: length 215.1
  IN1 w0.076: v3(341.59,111.33) 341.01,111.33 340.62,110.94 340.62,109.84 341.15,109.31 341.15,106.01 340.44,105.3 340.44,103.03 338.23,100.82 338.23,90.9 336.84,89.5 336.84,80.99 340.01,77.81 347,77.81 348.44,76.37 348.44,75.53 349.97,74 349.97,71.9 349.54,71.46 349.54,66.49 350.17,65.86 350.17,63.51 348.62,61.96 348.62,58.56 348.09,58.03 348.09,57.4 347.72,57.02 347.72,55.35 346.35,53.98 344.57,53.98 341.64,51.05 341.45,51.05 341.2,50.8 339.55,50.8 337.89,49.14 337.89,48.25 335.19,45.55 335.19,42.53 333.6,40.94 326.74,40.94 326.15,40.35 323.88,40.35 323.05,41.18 314.31,41.18 309.87,45.62 307.95,45.62 307.32,44.99 307.32,44.38 306.92,43.98 301.07,43.98 300.91,43.82 296.69,43.82 295.97,44.54 293.6,44.54 293.22,44.92 288.99,44.92 288.01,45.9 284.96,45.9 282.27,48.58 280.32,48.58 277.39,51.51 276.57,51.51 275.67,52.41 274.1,52.41 271.03,55.49 270.62,55.9 270.62,57.26 266.48,61.4 266.48,62.98 266.19,63.27 266.19,64.79 264.04,66.94 264.04,68.21 259.62,72.63 259.62,73.97 259.25,74.35 257.85,74.35 255.53,76.67 255.34,76.67 254.92,76.25 254.92,76.1 253.55,74.73 252.89,74.73 252.64,74.98 252.17,74.98 250.6,76.54 249.61,76.54 249.38,76.77 248.85,76.77 247.73,77.89 245.68,77.89 245.09,77.31 242.6,77.31 241.99,77.92 240.42,77.92 240.14,77.64 240.14,77.18 240.32,77 240.39,77 v1(240.57,77.18)
  BOTTOM w0.102: v1(240.57,77.18) 241.06,77.18 243.03,75.21 243.03,74.68 U9002.AB3
  BOTTOM w0.114: U8001.V19 v3(341.59,111.33)
CLK_PCIE_WLANN: length 158.7
  IN1 w0.076: v1(350.43,70.7) 350.01,70.28 350.01,68.25 351.19,67.07 351.19,62.51 349.38,60.71 349.38,58.24 348.85,57.71 348.85,57.08 348.48,56.71 348.48,55.03 343.91,50.46 343.91,49.96 336.84,42.88 336.84,38.55 333.81,35.52 329.14,35.52 327.16,37.51 320.12,37.51 319.65,37.98 312.67,37.98 310.25,40.39 306.6,40.39 306.2,40.79 295.8,40.79 294.7,41.9 291.5,41.9 291.34,42.05 288.45,42.05 287.02,43.48 283.93,43.48 283.51,43.91 281.08,43.91 279.56,45.42 278.41,45.42 275.63,48.2 272.22,48.2 265,55.41 263.64,55.41 262.96,56.09 262.96,58.6 262.29,59.27 262.29,60.03 261.82,60.5 261.82,62.97 260.02,64.77 259.69,64.77 259.18,65.28 258.8,65.28 255.05,69.03 255.05,70.14 253.08,72.1 252.15,72.1 251.03,73.22 250.52,73.22 247.85,75.88 247.46,75.88 246.92,76.42 246.16,76.42 245.84,76.11 245.84,74.51 245.66,74.32 v1(245.32,74.32)
  BOTTOM w0.102: v1(245.32,74.32) 245.3,74.34 U9002.AE6 ; v1(350.43,70.7) 350.27,70.55 349.82,70.55 349.49,70.88 349.49,71.19 349.28,71.4 TP4104.1 348.95,71.72 348.69,71.98 348.33,71.98 348.13,72.18 U4100.33
CLK_PCIE_WLANP: length 158.6
  IN1 w0.076: v1(350.43,70.07) 350.3,70.07 350.17,69.94 350.17,68.32 351.35,67.13 351.35,62.44 349.55,60.64 349.55,58.18 349.02,57.64 349.02,57.01 348.65,56.64 348.65,54.96 344.08,50.39 344.08,49.89 337,42.81 337,38.48 333.88,35.36 329.07,35.36 327.09,37.34 320.05,37.34 319.58,37.81 312.6,37.81 310.19,40.22 306.53,40.22 306.13,40.63 295.73,40.63 294.63,41.73 291.43,41.73 291.28,41.89 288.38,41.89 286.95,43.32 283.86,43.32 283.44,43.74 281.01,43.74 279.5,45.26 278.34,45.26 275.56,48.04 272.15,48.04 264.94,55.25 263.57,55.25 262.8,56.02 262.8,58.53 262.12,59.2 262.12,59.97 261.65,60.44 261.65,62.9 259.95,64.61 259.62,64.61 259.11,65.11 258.73,65.11 254.88,68.96 254.88,70.07 253.02,71.93 252.08,71.93 250.96,73.05 250.45,73.05 247.78,75.72 247.39,75.72 246.85,76.26 246.23,76.26 246.01,76.04 246.01,74.44 245.65,74.08 245.65,73.82 v1(245.77,73.69)
  BOTTOM w0.102: v1(245.77,73.69) 245.84,73.76 U9002.AE7 ; v1(350.43,70.07) 350.15,70.35 349.38,70.35 TP4105.1 349.28,71.11 348.88,71.52 348.87,71.52 348.6,71.78 348.24,71.78 348.23,71.79 348.13,71.68 U4100.34
CLK_PCIE_WWANN: length 211.5
  IN4 w0.076: v1(333.97,15.35) 334.15,15.35 334.51,14.98 334.51,14.73 334.35,14.57 333.66,14.57 333.15,15.08 333.15,16.47 333.66,16.98 333.66,19.66 334.66,20.66 334.66,25.76 334.14,26.29 332.21,26.29 331.11,27.38 331.11,27.38 328.03,30.46 323.32,30.46 322.59,29.73 310.87,29.73 308.85,31.75 295.47,31.75 294.46,32.77 288.34,32.77 287.11,34 284.41,34 282.26,31.85 280.69,31.85 279.9,32.64 276.83,32.64 276.15,33.33 271.18,33.33 270.26,34.24 258.54,34.24 258.08,33.78 255.12,33.78 254.66,34.24 250.39,34.24 247.85,31.7 245.54,31.7 245.21,32.03 233.85,32.03 229.18,36.71 229.18,51.09 228.56,51.71 228.56,52.64 229.14,53.23 229.14,70.39 230.58,71.82 230.58,75.19 231.97,76.58 231.97,79.38 234.6,82.01 236.18,82.01 239.99,78.2 241.71,78.2 243.34,76.57 243.34,75.06 243.77,74.63 243.87,74.53 247.3,71.1 247.3,71.01 247.19,70.89 v1(246.79,70.89)
  BOTTOM w0.102: U9002.AC14 247.36,71.22 247.36,71.09 247.16,70.89 v1(246.79,70.89) ; CON4201.53 343.75,9.49 344.05,9.78 344.05,11.78 342.75,13.08 336.34,13.08 334.07,15.35 v1(333.97,15.35)
CLK_PCIE_WWANP: length 211.5
  IN4 w0.076: v1(334.68,15.35) 334.68,14.66 334.42,14.4 333.59,14.4 332.99,15.01 332.99,16.54 333.5,17.05 333.5,19.73 334.5,20.73 334.5,25.69 334.07,26.13 332.14,26.13 331.04,27.22 331.04,27.22 327.97,30.29 323.39,30.29 322.66,29.57 310.8,29.57 308.78,31.59 295.4,31.59 294.39,32.6 288.27,32.6 287.04,33.83 284.47,33.83 282.33,31.69 280.62,31.69 279.83,32.48 276.77,32.48 276.08,33.16 271.11,33.16 270.19,34.08 258.6,34.08 258.15,33.62 255.05,33.62 254.59,34.08 250.46,34.08 247.92,31.54 245.47,31.54 245.14,31.87 233.78,31.87 229.01,36.64 229.01,51.02 228.39,51.64 228.39,52.71 228.97,53.3 228.97,70.45 230.41,71.89 230.41,75.25 231.81,76.65 231.81,79.45 234.53,82.17 236.24,82.17 240.05,78.36 241.78,78.36 243.5,76.64 243.5,75.13 243.84,74.79 243.98,74.65 247.47,71.17 247.47,70.94 247.3,70.77 v1(247.3,70.51)
  BOTTOM w0.102: U9002.AC15 247.41,70.86 247.3,70.75 v1(247.3,70.51) ; CON4201.55 344.25,11.87 342.84,13.28 336.42,13.28 334.68,15.02 v1(334.68,15.35)
CLKIN_XTAL_LCP: length 118.8
  TOP w0.114: v1(332.98,31) 332.75,30.77 332.75,29.83 R17963.1 334.03,28.49 334.81,27.71 R4121.2 334.81,27.23 334.15,26.57 C12042.2
  IN1 w0.076: v1(332.98,31) 332.98,31.99 331.35,33.62 324.77,33.62 323.63,32.48 315.02,32.48 310.67,36.82 307.09,36.82 304.73,39.18 296.04,39.18 295.84,38.98 294.77,38.98 294.04,39.71 287.89,39.71 286.39,41.21 284.92,41.21 284.63,41.51 280.65,41.51 278.75,43.4 277.34,43.4 275.13,45.61 274.53,45.61 273.84,46.29 271.18,46.29 266.86,50.61 265.61,50.61 264.19,52.03 263.66,52.03 260.74,54.95 259.44,54.95 258.99,55.41 258.99,59.76 253.71,65.03 252.89,65.03 251.24,66.68 251.24,67.09 249.15,69.18 243.24,69.18 242.4,70.02 v1(242.4,70.47)
  BOTTOM w0.102: U9002.R6 242.4,71.03 v1(242.4,70.47)
CLKIN_XTAL_LCP_R: length 45.4
  TOP w0.114: v1(339.91,64.71) 339.22,64.02 336.66,64.02 334.6,61.97 334.6,57.27 333.7,56.36 333.7,51.76 333.24,51.3 333.24,50.14 334.91,48.48 334.91,47.18 335.39,46.7 335.39,35.85 334.19,34.66 333.18,34.66 332.19,33.67 332.19,32.63 333.53,31.28 333.53,29.94 334.84,28.63 R17963.2
  BOTTOM w0.114: v1(339.91,64.71) 340.27,65.06 340.27,65.12 340.39,65.24 U4100.A44
CLKOUT_SRC_N15: length 11.1
  BOTTOM w0.102: 237.78,74.13 238.44,74.13 239.74,75.43 239.85,75.43 239.94,75.35 239.94,75.18 239.19,74.43 239.19,74.29 239.3,74.18 239.45,74.18 239.86,74.59 240.01,74.59 240.08,74.52 240.08,74.38 240,74.3 240,74.2 240.06,74.13 241.09,74.13 241.53,73.68 241.63,73.68 241.74,73.8
  BOTTOM w0.114: R9345.2 v1(236.28,74.84) 236.6,75.17 236.73,75.17 236.79,75.11 236.79,74.61 236.63,74.46 236.63,74.26 236.76,74.13 237.78,74.13
CLKOUT_SRC_P15: length 10.9
  BOTTOM w0.102: U9002.V3 241.63,73.3 241.05,73.88 237.52,73.88
  BOTTOM w0.114: R9348.1 234.19,76.7 v1(234.5,76.39) 234.91,75.99 234.91,75 234.85,74.94 234.85,74.57 235.54,73.88 235.68,73.88 R9346.2 236.13,73.88 237.52,73.88
CNV_BRI_DT: length 127.8
  TOP w0.114: R9372.2 248.47,80.79 248.72,81.04 248.72,81.47 249.15,81.9 249.76,81.9 249.76,82.1 R9545.2 249.18,83.05 v1(248.72,83.5)
  IN2 w0.089: v1(248.72,83.5) 249.13,83.91 251.38,83.91 252.45,84.98 254.69,84.98 255.02,85.3 257.12,85.3 258.13,84.29 258.52,84.29 259.51,83.3 260.82,83.3 263.38,80.75 263.38,80.25 266.58,77.05 267.22,77.05 271.31,72.96 271.7,72.96 273.26,71.4 274.26,71.4 275.27,70.4 277.13,70.4 280.32,67.21 280.32,65.7 280.96,65.06 280.96,64.29 281.58,63.67 282.73,63.67 283.01,63.95 285.45,63.95 290.18,59.22 290.18,59.02 292.13,57.06 298.12,57.06 301.56,53.63 309.85,53.63 310.18,53.95 315.89,53.95 v1(315.96,54.02)
  IN3 w0.089: v3(343.55,64.9) 343.55,64.59 342.17,63.21 341.74,63.21 341.18,62.65 341.18,62.19 339.86,60.87 338.87,60.87 337.22,59.22 337.22,57.74 335.74,56.27 335.74,54.68 334.65,53.59 334.65,53.02 333.34,51.7 332.47,51.7 331.94,52.24 329.52,52.24 328.76,53 328.76,53.76 328.1,54.42 320.61,54.42 320.33,54.14 317.3,54.14 317,54.45 316.39,54.45 v1(315.96,54.02)
  BOTTOM w0.114: U4100.A38 343.39,65.07 v3(343.55,64.9) 344.39,64.07 U4100.54
CNV_BRI_RSP: length 127.9
  TOP w0.114: 247.86,82.72 247.86,82.14 v1(247.94,82.05)
  IN2 w0.089: v1(247.94,82.05) 248.99,82.05 250.09,83.15 252.55,83.15 253,83.6 253.63,83.6 254.32,84.29 254.76,84.29 255.24,84.77 256.9,84.77 257.46,84.21 257.46,83.65 257.66,83.45 257.66,82.86 258.44,82.08 259.35,82.08 259.74,81.69 260.67,81.69 262.14,80.23 262.14,79.14 262.74,78.54 262.74,78.16 265.43,75.47 265.79,75.47 265.98,75.27 266.35,75.27 268.13,73.5 268.71,73.5 270.47,71.74 271.41,71.74 273.49,69.66 274.04,69.66 274.81,68.89 275.26,68.89 275.75,68.41 277.42,68.41 278.4,67.43 279.18,66.66 279.18,65.29 279.84,64.63 279.84,63.72 281.64,61.92 285.95,61.92 287.59,60.29 287.59,58.72 292.24,54.07 293.94,54.07 294.23,53.77 298.27,53.77 300.03,52.01 316.24,52.01 v1(317.39,53.16)
  IN3 w0.089: v1(317.39,53.16) 317.91,53.68 320.83,53.68 321.16,54.02 327.87,54.02 328.25,53.63 328.25,52.77 329.88,51.14 333.28,51.14 335.16,53.02 335.16,53.48 336.1,54.42 336.1,56.12 337.57,57.6 337.57,59.07 339,60.49 340.09,60.49 340.46,60.87 344.65,60.87 v1(345.22,61.43)
  BOTTOM w0.102: U9002.AY2 249.12,81.39 248.55,81.96 248.04,81.96 v1(247.94,82.05)
  BOTTOM w0.114: v1(345.22,61.43) 344.96,61.69 R4129.2
CNV_BRI_RSP_R: length 6.1
  BOTTOM w0.114: v1(345.98,61.43) 345.73,61.68 R4129.1 345.73,62.69 345.47,62.96 344.38,62.96 343.89,63.45 U4100.55 343.89,64.01 343.21,64.69 343.21,64.74 342.89,65.05 U4100.A39
CNV_RCOMP: length 5.4
  BOTTOM w0.203: U9002.BA1 248.89,82.28 248.87,82.28 248.71,82.44 248.56,82.44 248.18,82.82 248.06,82.82
  BOTTOM w0.254: 248.06,82.82 247.33,83.56 247.33,85.24 R9299.1 v1(246.37,86.19)
CNV_RF_RESET#: length 175.7
  TOP w0.114: v3(338.77,64.78) 338.77,65.5 338.39,65.88 337.12,65.88 336.73,66.26 336.73,67.88 335.64,68.98 335.64,72.75 R4131.1 ; v3(257.29,81.81) 257.29,81.84 257.64,82.19 R9606.1 ; v1(335.62,26.33) 335.94,26.65 335.94,29.29 336.94,30.29 336.94,30.94 336.52,31.35 336.17,31.35 335.45,32.07 335.45,33.6 336.94,35.1 336.94,43.54 338.84,45.44 338.84,46.09 336.82,48.12 336.82,49.67 336.01,50.48 336.01,51.08 335.01,52.08 335.01,54.27 338.69,57.95 341.81,57.95 342.47,58.61 342.47,59.01 340.34,61.14 v1(340.34,62.52)
  IN2 w0.089: v1(335.62,26.33) 334.8,27.14 330.28,27.14 329.84,26.7 328.1,26.7 326.63,28.17 323.89,28.17 322.94,29.12 322.94,30.12 321.34,31.71 320.58,31.71 318.55,33.75 316.54,33.75 315.14,35.14 315.14,41.66 311.33,45.48 311.33,46.72 309.13,48.92 306.77,48.92 304.7,50.99 299.65,50.99 297.85,52.8 293.71,52.8 293.57,52.93 291.97,52.93 290.71,54.19 289.46,54.19 287.64,56.02 284.29,56.02 284.24,56.07 283.98,56.07 283.84,56.21 283.79,56.23 283.79,56.23 283.31,56.43 283.24,56.48 283.15,56.54 283.14,56.54 282.81,56.77 282.38,57.2 281.94,57.84 281.94,57.93 281.82,58.23 281.28,58.77 281.28,60.93 278.28,63.94 278.28,66.3 277.05,67.52 275.35,67.52 274.86,68 272.93,68 272.34,68.59 272.34,68.81 268.6,72.55 268.04,72.55 266.13,74.46 265.79,74.46 265.5,74.75 265.14,74.75 262.03,77.86 262.03,78.25 261.43,78.85 261.43,79.93 260.38,80.98 259.35,80.98 258.96,81.37 258.15,81.37 257.71,81.81 v3(257.29,81.81) ; v3(338.77,64.78) 339.86,63.69 339.86,63.01 v1(340.34,62.52)
  BOTTOM w0.102: v3(257.29,81.81) 257.27,81.79 257.27,80.72 255.83,79.28 255.83,78.64 U9002.BE16
CNV_RF_RESET#_R: length 6.8
  TOP w0.114: U4103.4 341.64,73.02 R4133.1 343.2,72.64 343.72,72.13 v1(343.72,69.38)
CNV_RGI_DT: length 131.9
  TOP w0.114: v1(246.49,84.85) 246.37,84.97 246.37,85.94
  IN2 w0.089: v1(316.11,53.2) 315.37,52.47 300.12,52.47 298.46,54.13 294.49,54.13 294.13,54.49 292.34,54.49 288.04,58.79 288.04,60.33 286.1,62.28 281.79,62.28 280.2,63.87 280.2,64.77 279.53,65.44 279.53,66.8 278.65,67.69 278.17,68.17 277.57,68.77 275.89,68.77 275.41,69.25 274.99,69.25 274.2,70.04 273.62,70.04 271.48,72.18 270.97,72.18 266.93,76.21 266.44,76.21 266.05,75.82 265.58,75.82 265.08,76.32 265.08,77.05 265.23,77.21 265.23,77.56 262.84,79.95 262.84,80.52 260.71,82.65 259.82,82.65 259.61,82.44 258.59,82.44 258.02,83.01 258.02,83.6 257.84,83.78 257.84,84.33 257.05,85.12 255.09,85.12 254.69,84.72 252.44,84.72 251.23,83.5 249.69,83.5 249.21,83.02 248.32,83.02 v1(246.49,84.85)
  IN3 w0.089: v3(342.83,64.58) 342.83,64.48 342.28,63.93 340.4,63.93 339.78,63.31 339.78,63.06 338.95,62.22 338.95,61.2 337.04,59.29 337.04,57.82 335.57,56.34 335.57,54.78 334.35,53.56 334.35,52.97 333.26,51.88 332.54,51.88 331.93,52.49 329.65,52.49 329.09,53.05 329.09,53.81 328.3,54.6 320.63,54.6 320.28,54.95 318.55,54.95 318.29,54.7 315.91,54.7 315.5,54.29 315.5,53.81 v1(316.11,53.2)
  BOTTOM w0.114: U4100.56 343.39,64.02 v3(342.83,64.58) 342.39,65.02 U4100.A40
CNV_RGI_RSP: length 131
  TOP w0.114: v1(248.29,81.24) 248.32,81.24 248.06,81.5 v1(247.64,81.5) 247.52,81.62 247.52,82.38 246.29,83.61 R17947.2
  IN2 w0.089: v1(316.74,53.13) 315.8,52.19 300.15,52.19 298.39,53.95 294.37,53.95 294.05,54.27 292.31,54.27 287.76,58.82 287.76,60.36 286.03,62.1 281.72,62.1 280.02,63.79 280.02,64.7 279.35,65.37 279.35,66.73 278.52,67.56 278.04,68.04 277.5,68.59 275.82,68.59 275.34,69.07 274.89,69.07 274.86,69.1 274.11,69.85 273.56,69.85 271.43,71.97 270.9,71.97 266.84,76.03 266.51,76.03 266.12,75.64 265.51,75.64 262.92,78.23 262.92,78.62 262.32,79.22 262.32,80.3 260.75,81.87 259.82,81.87 259.43,82.26 258.52,82.26 257.84,82.93 257.84,83.52 257.66,83.71 257.66,84.26 256.97,84.95 255.17,84.95 254.68,84.46 254.24,84.46 253.56,83.78 252.92,83.78 252.47,83.33 249.98,83.33 249.35,82.69 247.89,82.69 247.56,82.36 247.56,81.83 248.14,81.24 v1(248.29,81.24)
  IN3 w0.089: v1(343.57,61.43) 343.18,61.04 340.28,61.04 339.93,60.7 338.95,60.7 337.39,59.14 337.39,57.67 335.92,56.2 335.92,54.6 334.91,53.58 334.91,53.02 333.23,51.35 330.03,51.35 328.58,52.8 328.58,53.63 328,54.22 320.94,54.22 320.62,53.9 317.52,53.9 v1(316.74,53.13)
  BOTTOM w0.102: v1(248.29,81.24) 248.32,81.22 248.32,80.81 248.79,80.34 U9002.AV3
  BOTTOM w0.114: v1(343.57,61.43) 343.2,61.8 R4130.2
CNV_RGI_RSP_R: length 4.4
  BOTTOM w0.114: U4100.A41 341.89,64.99 342.89,63.99 U4100.57 342.89,63.43 343.36,62.96 343.82,62.96 343.98,62.79 R4130.1
CNV_WR_CLKN: length 139
  IN3 w0.089: v3(346.18,64.48) 346.36,64.3 346.36,63.07 346.96,62.47 346.96,60.76 343.47,57.27 343.47,52.71 340.9,50.13 340.9,47.58 340.55,47.23 336.08,47.23 333.14,44.29 332.54,44.29 331.97,43.72 324.66,43.72 323.97,44.4 320.59,44.4 319.97,45.02 316.18,45.02 313.1,48.1 312.15,48.1 308.35,51.89 306.7,51.89 305.96,52.64 302.97,52.64 302.37,53.24 299.51,53.24 299.3,53.46 294.67,53.46 294.2,53.93 292.1,53.93 292.09,53.93 291.77,53.93 290.37,55.34 289.23,55.34 288.93,55.03 283.38,55.03 280.69,57.72 280.69,60.73 277.37,64.04 277.37,65.56 276.39,66.54 274.71,66.54 273.81,67.44 271.85,67.44 269.73,69.56 268.02,69.56 267.76,69.82 267.63,69.82 264.71,72.73 264.19,72.73 262.36,74.56 262.36,75.41 260.6,77.18 259.76,77.18 258.59,78.35 258.59,79.32 257.21,80.7 257.21,81.11 255.93,82.38 255.93,82.67 255.33,83.27 253.75,84.85 252.26,84.85 250.78,83.36 250.03,83.36 249.63,82.96 249.63,82.23 250.17,81.69 250.6,81.69 v1(250.67,81.63)
  BOTTOM w0.102: v3(346.18,64.48) 346.18,64.59 346.25,64.66 346.25,65.06 345.89,65.42 U4100.A33 ; U9002.BD4 251.17,82.18 250.67,81.68 v1(250.67,81.63)
CNV_WR_CLKP: length 139
  IN3 w0.089: v3(346.74,64.48) 346.55,64.29 346.55,63.15 347.15,62.55 347.15,60.68 343.66,57.2 343.66,52.63 341.09,50.06 341.09,47.5 340.63,47.04 336.16,47.04 333.21,44.09 332.62,44.09 332.05,43.52 324.58,43.52 323.89,44.21 320.51,44.21 319.89,44.83 316.1,44.83 313.02,47.91 312.07,47.91 308.27,51.7 306.62,51.7 305.88,52.45 302.9,52.45 302.29,53.05 299.43,53.05 299.22,53.27 294.59,53.27 294.12,53.74 292.02,53.74 292.02,53.74 291.7,53.74 290.29,55.15 289.31,55.15 289.01,54.84 283.3,54.84 280.5,57.64 280.5,60.65 277.18,63.96 277.18,65.48 276.31,66.35 274.63,66.35 273.73,67.25 271.77,67.25 269.65,69.37 267.94,69.37 267.68,69.63 267.55,69.63 264.63,72.54 264.11,72.54 262.17,74.48 262.17,75.33 260.52,76.99 259.68,76.99 258.4,78.27 258.4,79.24 257.02,80.62 257.02,81.03 255.74,82.3 255.74,82.59 254.65,83.68 253.67,84.66 252.34,84.66 250.86,83.17 250.11,83.17 249.82,82.88 249.82,82.31 250.25,81.88 250.37,81.88 250.51,82.01 250.6,82.01 250.67,82.08 v1(250.67,82.33)
  BOTTOM w0.102: v3(346.74,64.48) 346.62,64.48 346.55,64.54 346.55,64.63 346.45,64.73 346.45,65.15 346.39,65.21 U4100.A32 ; v1(250.67,82.33) 250.67,82.67 250.84,82.85 U9002.BE3
CNV_WRXN0: length 139.2
  IN3 w0.089: v1(249.43,84.8) 249.28,84.8 249,84.52 249,84.14 249.09,84.05 249.87,84.05 251.32,85.51 254.03,85.51 256.08,83.46 256.6,83.46 256.96,83.1 256.96,82.9 259.82,80.04 259.82,79.29 260.39,78.72 260.39,78.46 267.83,71.01 268.47,71.01 269.24,70.25 270.14,70.25 272.28,68.11 274.74,68.11 275.53,67.32 276.64,67.32 278.16,65.79 278.16,64.19 281.38,60.98 281.38,58.09 283.71,55.76 287.43,55.76 287.68,56.02 290.94,56.02 292.37,54.59 294.47,54.59 294.94,54.12 299.57,54.12 299.77,54.32 302.31,54.32 303.33,53.3 306.31,53.3 306.6,53.01 308.32,53.01 311.39,49.94 312.28,49.94 314.33,47.88 318.38,47.88 319.82,46.45 320.62,46.45 320.96,46.1 320.96,45.43 321.33,45.06 324.26,45.06 324.57,44.76 331.13,44.76 333.34,46.97 333.34,47.09 332.95,47.49 332.95,47.77 333.36,48.18 333.64,48.18 334.04,47.79 334.16,47.79 334.89,48.52 334.95,48.57 335.66,48.57 337.59,50.5 340.33,50.5 342.81,52.98 342.81,57.55 346.3,61.04 346.3,62.2 345.52,62.97 345.52,64.57 v3(345.23,64.86)
  BOTTOM w0.089: 249.41,82.97 249.47,82.91 249.47,82.91 249.57,82.81 249.57,82.8 249.74,82.63 250.04,82.63 250.11,82.57 U9002.BB3
  BOTTOM w0.102: U4100.A35 344.89,65.29 345.01,65.17 345.17,65.17 345.17,65.17 345.31,65.03 345.31,64.94 v3(345.23,64.86) ; v1(249.43,84.8) 249.33,84.8 249.08,84.55 249.08,84.55 248.98,84.44 248.98,84.38 248.91,84.31 248.91,84.18 249.41,83.68 249.41,82.98 249.41,82.97
CNV_WRXN1: length 139.8
  IN3 w0.089: v3(344.13,64.86) 344.33,64.66 344.33,63.34 345.66,62.01 345.66,61.24 344.84,60.42 342.79,60.42 342.15,59.77 340.75,59.77 336.84,55.86 336.84,52.85 335.97,51.98 335.97,50.6 335.06,49.68 333.53,49.68 329.23,45.38 324.8,45.38 324.44,45.73 322.79,45.73 321.06,47.46 320.07,47.46 319.41,48.12 318.92,48.12 318.56,48.48 317.11,48.48 316.39,49.2 313.84,49.2 312.41,50.64 311.56,50.64 308.61,53.59 306.91,53.59 306.05,54.45 303.32,54.45 302.87,54.9 299.45,54.9 299.24,54.7 295.25,54.7 294.39,55.56 294.39,56 293.63,56.76 287.21,56.76 286.99,56.54 283.75,56.54 282,58.3 282,61.18 278.91,64.27 278.91,65.87 276.88,67.9 275.82,67.9 274.16,69.55 273.49,69.55 272.39,70.65 270.86,70.65 270.62,70.89 269.48,70.89 268.63,71.75 267.95,71.75 261.93,77.77 261.93,78.58 261.44,79.07 261.44,80 260.41,81.03 259.67,81.03 257.59,83.11 257.59,83.33 257.21,83.71 257.21,83.83 257.21,83.91 256.68,84.44 255.96,84.44 254.29,86.11 250.77,86.11 250.45,85.79 247.91,85.79 247.2,85.08 247.05,84.93 247.05,84.47 247.4,84.11 248.01,84.11 v1(248.09,84.04)
  BOTTOM w0.089: U9002.BA3 249.96,81.89 249.66,82.18 249.61,82.18 249.12,82.68
  BOTTOM w0.102: v3(344.13,64.86) 344.13,65.06 343.89,65.3 U4100.A37 ; 249.12,82.68 248.9,82.89 248.75,82.89 247.94,83.71 247.94,83.89 v1(248.09,84.04)
CNV_WRXP0: length 139.3
  IN3 w0.089: v3(345.77,64.86) 345.71,64.81 345.71,64.67 345.71,63.05 346.49,62.28 346.49,60.96 343,57.47 343,52.91 340.4,50.31 337.67,50.31 335.74,48.38 335.03,48.38 334.24,47.6 333.96,47.6 333.57,47.99 333.44,47.99 333.14,47.69 333.14,47.56 333.53,47.17 333.53,46.89 331.21,44.57 324.49,44.57 324.18,44.87 321.25,44.87 320.77,45.35 320.77,46.02 320.54,46.26 319.74,46.26 318.3,47.69 314.26,47.69 312.2,49.75 311.31,49.75 308.24,52.81 306.52,52.81 306.23,53.11 303.25,53.11 302.23,54.13 299.85,54.13 299.65,53.93 294.87,53.93 294.4,54.4 292.29,54.4 290.87,55.82 287.76,55.82 287.51,55.57 283.63,55.57 281.18,58.01 281.18,60.9 277.97,64.11 277.97,65.71 276.56,67.13 275.45,67.13 274.66,67.92 272.2,67.92 270.06,70.06 269.16,70.06 268.39,70.82 267.76,70.82 260.2,78.38 260.2,78.64 259.63,79.21 259.63,79.96 256.77,82.82 256.77,83.02 256.52,83.27 256,83.27 253.95,85.32 251.4,85.32 249.94,83.86 249.01,83.86 248.81,84.06 248.81,84.31 v1(248.57,84.55)
  BOTTOM w0.089: U9002.BB4 250.14,81.98 249.74,82.39 249.71,82.39 249.64,82.46 249.27,82.83
  BOTTOM w0.102: v1(248.57,84.55) 248.71,84.41 248.71,84.1 249.2,83.6 249.2,82.89 249.27,82.83 ; U4100.A34 345.39,65.24 345.77,64.86 v3(345.77,64.86)
CNV_WRXP1: length 139.8
  IN3 w0.089: v3(344.69,64.86) 344.52,64.69 344.52,63.42 345.85,62.08 345.85,61.16 344.92,60.23 342.87,60.23 342.23,59.58 340.83,59.58 337.03,55.78 337.03,52.77 336.16,51.9 336.16,50.52 335.14,49.49 333.61,49.49 329.3,45.19 324.72,45.19 324.36,45.54 322.71,45.54 320.98,47.27 319.99,47.27 319.33,47.93 318.84,47.93 318.48,48.29 317.03,48.29 316.31,49.01 313.76,49.01 312.33,50.45 311.48,50.45 308.53,53.4 306.83,53.4 305.97,54.26 303.24,54.26 302.79,54.71 299.53,54.71 299.32,54.51 295.17,54.51 294.2,55.48 294.2,55.92 293.55,56.57 287.29,56.57 287.07,56.35 283.67,56.35 281.81,58.22 281.81,61.1 278.72,64.19 278.72,65.79 276.8,67.71 275.74,67.71 274.09,69.36 273.41,69.36 272.31,70.46 270.78,70.46 270.54,70.7 269.4,70.7 268.55,71.56 267.88,71.56 261.74,77.69 261.74,78.5 261.25,78.99 261.25,79.92 260.33,80.84 259.59,80.84 257.4,83.03 257.4,83.25 257.02,83.63 257.02,83.83 256.6,84.25 255.88,84.25 254.99,85.14 254.21,85.92 250.85,85.92 250.53,85.6 247.99,85.6 247.24,84.85 247.24,84.55 247.48,84.3 247.75,84.3 247.84,84.39 247.84,84.64 v1(247.81,84.67)
  BOTTOM w0.089: U9002.BA2 249.55,81.98 249.23,82.3 249.04,82.48 249.04,82.48 248.99,82.52 248.98,82.52 248.97,82.54
  BOTTOM w0.102: v1(247.81,84.67) 247.81,84.66 247.68,84.54 247.68,83.67 248.66,82.69 248.82,82.69 248.97,82.54 ; v3(344.69,64.86) 344.65,64.86 344.39,65.13 U4100.A36
CNV_WT_CLKN: length 157.5
  IN3 w0.089: v1(343.41,74.13) 343.19,74.36 343.19,74.77 343.62,75.2 344.68,75.2 345.09,75.61 345.09,75.91 345.47,76.29 347.53,76.29 349.8,74.02 349.8,72.1 349.28,71.59 349.28,69.19 349.54,68.92 349.54,63.81 349.14,63.41 349.14,55.28 344.59,50.72 344.59,47.72 341.41,44.54 337.46,44.54 333.89,40.98 326.65,40.98 325.86,41.77 323.86,41.77 323.13,42.5 318.07,42.5 317.55,43.02 313.09,43.02 310.71,45.4 310.71,46.8 309.01,48.5 307.77,48.5 306.3,49.98 304.5,49.98 304.17,50.31 302.11,50.31 301.32,51.1 298.96,51.1 298.51,51.55 294.52,51.55 293.43,50.46 291.03,50.46 290.63,50.86 289.49,50.86 287.86,52.48 282.22,52.48 277.95,56.76 277.42,56.76 274.08,60.1 273.51,60.1 273.26,59.84 270.02,59.84 266.5,63.36 266.5,64.63 264.18,66.95 264.18,68.33 258.5,74.01 258.5,75.36 256.27,77.59 255.94,77.59 255.04,78.5 255.04,78.9 252.64,81.29 251.5,81.29 251.26,81.06 251.26,81.02 251.09,80.84 250.94,80.84 v1(250.79,80.99)
  BOTTOM w0.102: v1(250.79,80.99) 251.03,81.23 U9002.BC5 ; U4100.A20 343.89,73.56 343.41,74.03 v1(343.41,74.13)
CNV_WT_CLKP: length 157.4
  IN3 w0.089: v1(251.65,80.89) 251.86,81.1 252.56,81.1 254.84,78.82 254.84,78.42 255.86,77.4 256.19,77.4 258.31,75.28 258.31,73.93 263.99,68.25 263.99,66.88 266.31,64.55 266.31,63.28 269.94,59.65 273.34,59.65 273.59,59.91 274,59.91 277.34,56.57 277.87,56.57 282.14,52.29 287.78,52.29 289.41,50.66 290.55,50.66 290.95,50.27 293.51,50.27 294.11,50.87 294.6,51.36 298.43,51.36 298.88,50.91 301.24,50.91 302.04,50.12 304.09,50.12 304.42,49.79 306.22,49.79 307.69,48.31 308.93,48.31 310.52,46.72 310.52,45.32 313.01,42.83 317.47,42.83 317.99,42.31 323.05,42.31 323.78,41.58 325.78,41.58 326.57,40.79 333.97,40.79 337.53,44.35 341.49,44.35 344.78,47.64 344.78,50.65 349.34,55.2 349.34,63.33 349.73,63.73 349.73,69 349.47,69.26 349.47,71.51 349.99,72.02 349.99,74.1 347.61,76.48 345.39,76.48 344.9,75.99 344.9,75.68 344.61,75.39 343.54,75.39 343,74.85 343,74.35 v1(342.78,74.13)
  BOTTOM w0.102: U9002.BB6 251.65,80.86 v1(251.65,80.89) ; U4100.A19 343.39,73.52 v1(342.78,74.13)
CNV_WTXN0: length 157.2
  IN3 w0.089: v1(344.68,74.13) 344.54,74.13 344.42,74.26 344.42,74.4 344.56,74.54 344.96,74.54 345.62,75.2 347.45,75.2 348.14,74.5 348.14,63.7 348.48,63.35 348.48,55.55 348.36,55.43 347.92,55.43 347.79,55.55 347.79,55.94 347.58,56.15 347.05,56.15 345.47,54.58 345.47,52.54 343.93,51 343.93,49.86 343.69,49.62 343.31,49.62 342.83,49.14 342.83,47.01 341.12,45.3 337.07,45.3 334.2,42.43 324.14,42.43 323.41,43.16 318.35,43.16 317.79,43.72 313.88,43.72 311.69,45.91 311.69,46.78 308.45,50.02 307.19,50.02 306.56,50.65 305.85,50.65 305.37,51.13 304.3,51.13 304.13,50.97 302.49,50.97 301.66,51.79 299.2,51.79 298.78,52.21 294.1,52.21 293.68,52.63 291.81,52.63 291.61,52.43 291.61,52.2 291.52,52.11 291.1,52.11 291.01,52.2 291.01,52.43 290.81,52.63 290.19,52.63 289.98,52.43 289.98,51.93 289.9,51.84 289.48,51.84 289.39,51.93 289.39,52.43 289.19,52.63 288.81,52.63 288.23,53.21 282.6,53.21 281.67,54.14 281.67,54.85 279.03,57.49 279.03,58 278.61,58.42 276.75,58.42 275.55,59.63 275.55,63.05 272.4,66.19 271.23,66.19 270.09,65.06 268.37,65.06 267.28,66.15 267.28,66.97 260.48,73.77 260.48,74.4 259.38,75.5 259.32,75.5 256.53,78.29 256.24,78.29 255.81,78.72 255.81,79.59 254.48,80.93 254.48,82.35 253.99,82.83 253.86,82.83 253.62,83.07 v1(253.62,83.16)
  BOTTOM w0.102: v1(344.68,74.13) 344.89,73.93 U4100.A22 ; v1(253.62,83.16) 253.62,83.35 253.52,83.45 253.29,83.45 253.19,83.35 253.19,82.44 252.61,81.85 252.61,81.7 252.54,81.63 U9002.BE6
CNV_WTXN1: length 156.1
  IN3 w0.089: v1(253.4,84.22) 253.08,83.9 253.08,83.82 253.13,83.76 253.89,83.76 255.26,82.39 255.26,82.03 256.55,80.74 256.55,80.33 257.88,79 257.88,78.1 259.47,76.51 260.33,76.51 260.6,76.24 260.6,75.96 260.49,75.85 260.49,75.73 260.79,75.43 260.91,75.43 261.02,75.54 261.3,75.54 261.69,75.15 261.69,73.41 262.39,72.7 263.15,72.7 263.53,72.32 263.53,71.56 263.76,71.33 264.25,71.33 264.56,71.02 264.56,70.53 267.87,67.22 267.87,66.77 268.7,65.93 269.82,65.93 270.67,66.78 272.7,66.78 275.39,64.09 276.39,64.09 277.83,62.65 277.83,62.37 276.97,61.51 276.97,61.38 277.26,61.08 277.39,61.08 278.25,61.95 278.53,61.95 278.81,61.67 278.81,60.93 278.9,60.84 279.64,60.84 279.99,60.49 279.99,60.04 279.79,59.84 278.92,59.84 278.83,59.75 278.83,59.34 278.92,59.25 279.79,59.25 279.99,59.05 279.99,57.45 283.18,54.26 290.43,54.26 291.42,53.27 293.9,53.27 294.37,52.8 299.02,52.8 299.27,52.55 301.92,52.55 302.9,51.56 303.89,51.56 304.27,51.95 305.53,51.95 306.24,51.23 308.07,51.23 311.98,47.32 312.92,47.32 315.89,44.36 319.62,44.36 320.24,43.74 323.68,43.74 324.39,43.03 332.24,43.03 332.82,43.61 333.48,43.61 336.43,46.57 339.02,46.57 339.42,46.17 341.08,46.17 342.16,47.25 342.16,50.46 344.13,52.43 344.13,54.07 347.9,57.83 347.9,63.11 347.52,63.49 347.52,74.28 347.22,74.58 345.83,74.58 345.75,74.5 345.69,74.43 345.69,74.27 345.83,74.13 v1(345.95,74.13)
  BOTTOM w0.102: U9002.BG6 252.88,82.59 252.99,82.71 252.99,83.59 253.14,83.74 253.71,83.74 253.78,83.8 253.78,84.15 253.71,84.22 253.4,84.22 v1(253.4,84.22) ; U4100.A24 345.89,73.6 345.84,73.66 345.66,73.66 345.59,73.72 345.59,73.81 345.74,73.96 345.74,74.02 345.85,74.13 v1(345.95,74.13)
CNV_WTXP0: length 157.2
  IN3 w0.089: v1(253.62,82.52) 253.74,82.64 253.91,82.64 254.29,82.27 254.29,80.85 255.62,79.51 255.62,78.64 256.16,78.1 256.45,78.1 259.24,75.31 259.3,75.31 260.29,74.32 260.29,73.7 267.09,66.89 267.09,66.07 268.29,64.87 270.17,64.87 271.3,66 272.32,66 275.36,62.97 275.36,59.55 276.67,58.23 278.53,58.23 278.84,57.92 278.84,57.42 281.48,54.77 281.48,54.06 282.52,53.02 288.15,53.02 288.73,52.44 289.11,52.44 289.2,52.35 289.2,51.85 289.4,51.65 289.97,51.65 290.18,51.85 290.18,52.35 290.26,52.44 290.73,52.44 290.82,52.35 290.82,52.12 291.02,51.92 291.6,51.92 291.8,52.12 291.8,52.35 291.89,52.44 293.6,52.44 294.02,52.02 298.7,52.02 299.12,51.6 301.58,51.6 302.41,50.78 304.21,50.78 304.37,50.94 305.29,50.94 305.77,50.46 306.48,50.46 307.11,49.83 308.37,49.83 311.5,46.7 311.5,45.83 313.8,43.52 317.71,43.52 318.05,43.18 318.27,42.97 323.33,42.97 324.06,42.24 334.28,42.24 337.15,45.11 341.2,45.11 343.02,46.93 343.02,49.06 343.39,49.43 343.77,49.43 344.12,49.78 344.12,50.92 345.66,52.46 345.66,54.5 347.13,55.96 347.5,55.96 347.6,55.86 347.6,55.48 347.84,55.24 348.44,55.24 348.67,55.48 348.67,63.43 348.33,63.77 348.33,74.58 347.52,75.39 345.54,75.39 344.88,74.73 344.48,74.73 344.23,74.48 344.23,74.31 v1(344.05,74.13)
  BOTTOM w0.102: U9002.BD7 252.4,81.16 252.73,81.48 252.81,81.65 252.81,81.77 253.57,82.52 v1(253.62,82.52) ; U4100.A21 344.39,73.79 v1(344.05,74.13)
CNV_WTXP1: length 156.2
  IN3 w0.089: v1(345.32,74.13) 345.5,74.31 345.5,74.51 345.62,74.63 345.75,74.77 347.3,74.77 347.71,74.36 347.71,63.57 348.09,63.19 348.09,57.75 344.32,53.99 344.32,52.36 342.35,50.38 342.35,47.17 341.16,45.98 339.34,45.98 338.94,46.38 336.51,46.38 333.56,43.42 332.9,43.42 332.31,42.84 324.31,42.84 323.6,43.55 320.16,43.55 319.54,44.17 315.81,44.17 312.84,47.13 311.9,47.13 307.99,51.04 306.16,51.04 305.45,51.75 304.35,51.75 303.97,51.37 302.83,51.37 301.84,52.36 299.19,52.36 298.94,52.61 294.29,52.61 293.82,53.08 291.34,53.08 290.35,54.07 283.1,54.07 279.8,57.37 279.8,58.97 279.71,59.06 278.84,59.06 278.64,59.26 278.64,59.83 278.84,60.03 279.71,60.03 279.8,60.12 279.8,60.41 279.56,60.65 278.82,60.65 278.62,60.85 278.62,61.59 278.46,61.76 278.33,61.76 277.47,60.89 277.18,60.89 276.77,61.3 276.77,61.59 277.64,62.45 277.64,62.58 276.31,63.9 275.31,63.9 272.62,66.59 270.75,66.59 269.9,65.74 268.62,65.74 267.67,66.69 267.67,67.14 264.37,70.45 264.37,70.94 264.17,71.14 263.68,71.14 263.34,71.48 263.34,72.24 263.07,72.51 262.31,72.51 261.5,73.33 261.5,75.07 261.22,75.35 261.1,75.35 260.99,75.24 260.71,75.24 260.3,75.65 260.3,75.93 260.41,76.04 260.41,76.16 260.25,76.32 259.39,76.32 257.69,78.02 257.69,78.92 256.36,80.25 256.36,80.66 255.07,81.95 255.07,82.31 253.81,83.57 253.05,83.57 252.89,83.74 252.89,84.09 v1(252.76,84.22)
  BOTTOM w0.102: U4100.A23 345.39,74.06 v1(345.32,74.13) ; U9002.BF6 252.53,82.18 252.53,82.54 252.79,82.79 252.79,84.19 v1(252.76,84.22)
CNVI_EN#: length 128.4
  TOP w0.102: R18043.1 257.72,75.66 257.72,74.4 257.61,74.29 v1(257.61,73.95)
  TOP w0.114: R4135.2 332.25,65.63 330.71,64.1 326.93,64.1 325.48,62.64 325.48,59.48 324.97,58.98 324.97,51.92 325.81,51.08 325.81,49.77 327.08,48.5 327.08,47.34 326.35,46.6 325.07,46.6 323.93,45.47 323.93,40.53 v1(325.03,39.44)
  IN3 w0.089: v1(325.03,39.44) 325.01,39.44 322.79,41.66 317.72,41.66 317.23,42.15 312.4,42.15 308.34,46.21 308.34,46.73 305.93,49.14 302.01,49.14 301.02,50.13 295.18,50.13 293.99,48.94 292.89,48.94 292.84,48.88 289.77,48.88 287.64,51.02 284.89,51.02 284.11,51.81 281.92,51.81 281.02,52.71 280.13,52.71 278.85,53.99 278.85,54.7 277.5,56.05 277.1,56.05 v1(273.97,59.17)
  IN4 w0.076: v1(257.61,73.95) 257.61,73.19 256.6,72.18 256.6,71.54 257.92,70.22 257.92,69.68 260.57,67.03 260.57,66.07 262.03,64.61 262.03,64.48 262.8,63.72 263.68,63.72 265.08,62.32 266.71,62.32 267.47,61.56 267.72,61.56 270.39,58.89 273.69,58.89 v1(273.97,59.17)
  BOTTOM w0.079: 259.52,73.01 259.79,73.29 259.82,73.29 260.16,73.63 U9002.BE29
  BOTTOM w0.102: v1(257.61,73.95) 257.79,74.13 258.32,74.13 258.73,73.73 258.73,73.47 259.19,73.01 259.52,73.01
CNVI_EN#_R: length 8.5
  TOP w0.114: v1(329.6,70.7) 329.85,70.45 330.44,70.45 331.04,71.06 331.2,71.06 331.36,70.9 U12005.1 331.36,69.41 331.47,69.31 R4138.1 331.47,68.54 331.67,68.34 331.67,67.99 331.47,67.78 R4137.1 R4135.1
  BOTTOM w0.114: v1(329.6,70.7) 329.22,70.7 328.71,70.19 Q4106.2
COLOR_DET#: length 139.7
  TOP w0.114: v3(259.29,47.44) 259.13,47.6 R9379.1 259.13,49.27 258.48,49.93 R9381.1 258.97,50.15 v3(259.06,50.05)
  IN1 w0.076: v3(257.16,53.1) 257.16,51.65 258.32,50.48 258.63,50.48 v3(259.06,50.05)
  IN2 w0.089: v1(259.62,55.46) 257.26,53.1 v3(257.16,53.1)
  IN3 w0.089: v1(257.72,31.49) 257.57,31.63 251.66,31.63 250.24,30.22 239.38,30.22 233.59,24.42 218.14,24.42 211.36,17.64 v1(211.36,16.68)
  IN4 w0.076: v1(211.03,9.18) 211.72,8.5 215.84,8.5 217.79,6.56 234.35,6.56 235.45,5.45 237.13,5.45 237.71,6.03 238.7,6.03 239.32,6.66 239.95,6.66 240.57,7.28 245.24,7.28 245.4,7.13 245.4,6.69 246.01,6.09 v1(246.13,6.09)
  BOTTOM w0.102: U9002.AD48 259.52,59.44 260.05,58.91 260.05,56.78
  BOTTOM w0.114: v1(259.62,55.46) 260.3,56.14 260.3,56.3 260.05,56.55 260.05,56.78 ; v1(211.03,9.18) 210.67,9.18 210.45,9.41 210.45,16.35 210.78,16.68 v1(211.36,16.68) ; v1(257.72,31.49) v1(257.72,32.45) 259.34,34.08 259.34,35.42 260.04,36.11 260.22,36.11 261.02,36.11 261.6,36.69 261.6,37.91 262.24,38.55 262.24,40.15 261.5,40.88 261.5,41.72 257.61,45.61 257.61,46.27 257.94,46.6 258.45,46.6 v3(259.29,47.44) ; v1(246.13,6.09) 246.46,6.42 246.46,7.13 246.33,7.26 CON10002.2
CORE_PLLVDD: length 41.7
  TOP w0.381: C2051.1 220.98,119.6 v1(221.39,119.19)
  TOP w0.508: L2010.2 193.42,131.43 v1(192.79,130.8)
  IN3 w0.381: v1(231.05,121.14) 228.3,121.14 227.54,120.38 225.72,120.38 225.19,119.85 224.41,119.85 223.64,119.08 221.49,119.08 v1(221.39,119.19)
  IN3 w0.508: v1(208.06,118.33) 206.53,119.85 206.53,125.44 205.9,126.07 205.9,127.73 202.22,131.41 193.4,131.41 v1(192.79,130.8)
  BOTTOM w0.254: U2000.AB8 v1(210.84,103.79)
  BOTTOM w0.305: U2000.AD7 v1(208.38,103.8) 208.33,103.8 U2000.AE8 ; U2000.AD8 v1(209.18,103.8) ; U2000.AF7 v1(206.66,103.82)
  BOTTOM w0.381: v1(221.39,119.19) 221.5,119.3 U2000.H26
  vias: v1(231.93,126.2)
CP_VNEG: length 3.7
  TOP w0.203: 336.26,5.78 336.45,5.97 336.58,5.97 336.83,6.22 U3600.31
  TOP w0.254: 336.26,5.78 336.2,5.72 336.2,5.02 335.85,4.66 v1(335.85,4.36) 335.54,4.36 335.44,4.46 C3615.1
CP_VPOS: length 1.6
  TOP w0.203: U3600.32 337.23,6.1 336.96,5.84
  TOP w0.254: 336.96,5.84 336.71,5.58 C3614.1
CPPWR_EN: length 335.8
  TOP w0.114: v1(26.07,101.44) 25.93,101.3 U7005.8
  IN3 w0.089: v1(26.07,101.44) 22.28,97.65 22.28,92.74 22.54,92.49 22.54,85.79 25.27,83.05 25.27,55.11 27.72,52.67 29.22,52.67 34.94,46.95 49.38,46.95 53.75,51.32 57.39,51.32 58.25,50.46 60.48,50.46 61.47,49.47 61.83,49.47 62,49.63 65.4,49.63 66.36,50.6 89.67,50.6 89.79,50.48 91.04,50.48 94.65,46.88 94.65,46.04 99.82,40.87 99.82,25.9 102.95,22.78 105.02,22.78 109.53,18.26 178.67,18.26 181.92,21.52 196.72,21.52 196.93,21.73 205.33,21.73 206.55,22.94 212.88,22.94 215.39,25.45 233.36,25.45 239.16,31.26 247.32,31.26 248.39,32.32 250.43,32.32 251.12,33.01 253.49,33.01 253.71,33.23 258.29,33.23 258.81,33.75 261.98,33.75 262.28,34.06 263.64,34.06 264.03,33.66 265.24,33.66 265.6,33.3 267.84,33.3 269.05,32.09 272.07,32.09 v1(272.57,31.59)
  BOTTOM w0.114: v1(272.57,31.59) 272.57,31.46 272.15,31.04 272.15,30.52 271.82,30.19 U6001.L11
CPU_2_PCH_TRIG: length 129.3
  IN1 w0.076: v1(173.62,116.24) 174.15,115.71 174.15,113.6 174.4,113.34 180.12,113.34 183.29,116.52 183.29,120.9 v1(183.19,120.99)
  IN2 w0.089: v1(231.3,77.74) 232.35,78.79 232.35,80.38 234.27,82.31 236.96,82.31 237.14,82.13 241.27,82.13 242.91,80.5 v1(242.91,79.75)
  IN3 w0.089: v1(231.3,77.74) 230.99,78.04 228.2,78.04 228.1,78.15 227.44,78.15 226.9,77.61 226.9,77.28 226.63,77 225.52,77 223.82,78.7 220.06,78.7 219.32,79.43 211.8,79.43 209.15,82.08 202.99,82.08 202.29,82.78 202.29,85.62 196.25,91.66 196.25,92.35 192.97,95.63 192.85,95.63 189.96,98.51 189.96,102.01 186.82,105.15 186.69,105.15 186.24,105.59 186.24,121.12 186.59,121.47 187.89,121.47 189.4,122.99 v1(190.64,122.99)
  BOTTOM w0.102: U9002.AK2 244.21,79.04
  BOTTOM w0.114: v1(242.91,79.75) 243.51,79.75 244.21,79.04 ; v1(183.19,120.99) 183.42,121.22 186.54,121.22 186.95,121.63 188.4,121.63 188.58,121.81 188.58,122.46 189.11,122.99 v1(190.64,122.99)
  BOTTOM w0.14: U9001.J23 173.9,116.51 v1(173.62,116.24)
CPU_EDP_HPD: length 263.7
  TOP w0.114: v1(247.08,76.98) 246.46,76.98 245.92,76.43 245.92,74.37 246.66,73.63 246.66,72.86 246.41,72.61 245.76,72.61 244.34,71.19 244.34,70.71 244.48,70.57 244.48,69.59 243.59,68.7 243.59,66.29 242.69,65.39 239.57,65.39 238.92,64.73 238.92,63.08 238.41,62.57 237.88,62.57 v1(236.85,61.55)
  IN2 w0.089: v1(236.85,61.55) 236.85,61.16 237.19,60.82 237.19,58.22 236.57,57.6 236.57,57.13 236.96,56.75 236.96,38.5 236.09,37.63 236.09,34.73 234.15,32.78 232.9,32.78 230.57,30.44 221.38,30.44 217.63,26.7 214.09,26.7 212.88,25.49 206.23,25.49 205.53,26.19 190.16,26.19 189.61,25.64 179.46,25.64 178.93,26.18 170.92,26.18 169.44,24.7 137.87,24.7 136.94,25.62 116.3,25.62 115.86,25.18 105.88,25.18 104.43,26.63 104.43,29.17 102.57,31.03 102.57,40.67 96.15,47.09 96.15,49.21 93.79,51.58 90.92,51.58 88.59,53.9 87.06,53.9 86.23,54.74 84.06,54.74 83.21,55.59 79.92,55.59 79.2,54.87 77.55,54.87 75.87,53.2 70.81,53.2 69.12,54.88 69.12,59.25 v1(69.76,59.88)
  BOTTOM w0.102: v1(247.08,76.98) 247.54,77.44 U9002.AN6
  BOTTOM w0.114: v1(69.76,59.88) 70.01,59.63 71.33,59.63 71.66,59.96 71.66,61.18 68.99,63.84 67.22,63.84 66.7,64.36 R3041.1 R3055.2
CPU_PCI_BCLKN: length 103.7
  IN1 w0.076: v1(233.96,66.64) 233.71,66.38 233.59,66.38 233.46,66.51 233.46,67.99 234.47,69 234.47,70.8 231.34,73.94 231.34,75.85 230.84,76.34 230.84,79.72 228.39,82.17 226.87,82.17 225.5,83.54 221.24,83.54 220.32,84.46 211.89,84.46 211.25,85.1 206.26,85.1 204.61,86.74 202.67,86.74 201.28,88.13 200.36,88.13 199.85,88.64 199.05,88.64 197.89,89.81 197.89,90.14 194.47,93.56 194.47,94.45 193.2,95.72 193.2,96.61 188.11,101.7 186.24,101.7 185.07,102.87 185.07,104.61 184.06,105.63 184.06,121.1 181.87,123.28 179.12,123.28 177.79,124.61 177.79,124.9 177.91,125.01 v1(178.19,125.01)
  BOTTOM w0.079: U9001.C36 178.01,125.19 v1(178.19,125.01)
  BOTTOM w0.102: U9002.B6 236.85,66.88 236.31,66.33 234.26,66.33 v1(233.96,66.64)
CPU_PCI_BCLKP: length 103.8
  IN1 w0.076: v1(177.33,125.49) 177.63,125.19 177.63,124.54 179.05,123.12 181.8,123.12 183.89,121.03 183.89,105.56 184.91,104.54 184.91,102.8 186.17,101.54 188.04,101.54 193.03,96.54 193.03,95.65 194.3,94.38 194.3,93.49 197.72,90.08 197.72,89.74 198.99,88.48 199.78,88.48 200.29,87.96 201.21,87.96 202.6,86.58 204.54,86.58 206.19,84.93 211.18,84.93 211.82,84.29 220.25,84.29 221.17,83.37 225.43,83.37 226.8,82.01 228.32,82.01 230.68,79.65 230.68,76.27 231.17,75.78 231.17,73.87 234.31,70.74 234.31,69.07 233.29,68.05 233.29,66.44 233.52,66.22 233.62,66.22 v1(233.96,65.88)
  BOTTOM w0.079: U9001.D35 177.53,125.28 v1(177.33,125.49)
  BOTTOM w0.102: U9002.A6 236.79,66.52 236.4,66.13 234.21,66.13 v1(233.96,65.88)
CPU_PLTRST#: length 1.9
  TOP w0.114: v1(245.14,75.85) 244.95,76.04 244.23,76.04 R9165.1
  BOTTOM w0.102: v1(245.14,75.85) 245.27,75.98 U9002.AG5
CPU_PLTRST#R: length 367.8
  TOP w0.127: R9165.2 242.98,76.86 242.98,77.09 238.63,81.45 234.82,81.45 232.68,79.31 232.68,74.22 232.09,73.63 232.09,73.3 231.1,72.32 231.1,71.26 230.1,70.26 230.1,62.54 229.56,62 229.56,60.02 230.93,58.65 230.93,37.72 232.04,36.62 232.04,32.49 226.6,27.06 221.29,27.06 220.64,27.06 212.1,18.52 206.12,18.52 203.38,15.79 203.38,14.77 203.11,14.5 v1(202.44,13.82)
  IN1 w0.127: v1(102.78,19.75) 104.61,19.75 112.88,11.47 176.81,11.47 182.66,17.32 199.59,17.32 201.63,15.29 201.63,14.63 v1(202.44,13.82) ; v1(139.99,125.53) 139.99,124.86 139.07,123.95 139.07,123.54 138.31,122.77 136.91,122.77 135.91,121.77 135.84,121.77 135.17,121.1 134.95,121.1 132.15,118.31 129.78,118.31 129,117.53 124.97,117.53 122.89,115.45 122.89,115.33 117.94,110.38 117.94,106.42 109.83,98.31 109.14,98.31 108.79,97.96 108.79,94.92 107.65,93.77 107.65,92.49 106.15,90.99 106.15,90.51 104.9,89.25 104.9,85.15 102.22,82.46 102.22,80.97 99.59,78.35 96.15,78.35 94.23,76.43 93.66,76.43 91.92,74.69 91.18,74.69 87.15,70.67 87.15,69.97 84.54,67.36 84.54,64.09 83.22,62.77 83.22,60.67 83.93,59.96 83.93,59.22 83.6,58.89 v1(83.55,58.89)
  BOTTOM w0.127: U9001.BP35 140.07,125.45 v1(139.99,125.53) ; v1(83.55,58.89) 84.42,58.02 84.42,57.76 85.12,57.06 87.48,57.06 88.17,57.75 88.17,58 88.54,58.38 88.54,59.06 90.03,60.55 90.58,60.55 91.81,61.77 92.45,61.77 92.77,61.45 94.88,61.45 96.87,59.46 96.87,55.08 96.3,54.51 96.3,42.78 101.2,37.87 101.2,32.92 101.97,32.15 101.97,21.72 102.78,20.92 v1(102.78,19.75)

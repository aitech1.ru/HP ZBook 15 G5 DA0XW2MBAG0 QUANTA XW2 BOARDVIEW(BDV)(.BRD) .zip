# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_TXN5: length 68.7
  IN3 w0.089: v1(198.23,111.89) 198.5,111.89 198.59,111.98 198.59,112.43 198.85,112.69 199.38,112.69 199.54,112.84 199.54,113.1 199.38,113.25 198.15,113.25 197.14,112.23 197.14,111.5 197.29,111.34 199.36,111.34 199.61,111.09 199.61,110.74 199.36,110.49 197.32,110.49 197.23,110.41 197.23,109.44 196.62,108.82 196.62,107.41 195.75,106.54 195.75,105.98 195.5,105.73 192.41,105.73 192.27,105.59 192.27,105.4 192.41,105.26 195.05,105.26 195.29,105.01 195.29,104.66 195.05,104.41 192.28,104.41 192.14,104.27 192.14,104.08 192.28,103.94 194.85,103.94 195.11,103.67 195.11,103.35 194.85,103.09 192.65,103.09 192.51,102.95 192.51,102.76 192.65,102.62 194.46,102.62 194.71,102.37 194.71,102.02 194.46,101.77 191.86,101.77 191.6,102.03 191.6,102.91 190.34,104.17 190.34,104.79 190.22,104.9 189.38,104.9 189.13,105.15 189.13,105.51 189.38,105.75 190.39,105.75 190.53,105.89 190.53,106.09 190.39,106.22 189.22,106.22 188.97,106.47 188.97,106.83 189.22,107.08 190.37,107.08 190.51,107.21 190.51,107.41 190.37,107.55 188.95,107.55 188.7,107.79 188.7,108.15 188.95,108.4 190.27,108.4 190.41,108.53 190.41,108.73 190.27,108.87 188.05,108.87 187.8,109.12 187.8,109.47 188.05,109.72 190.26,109.72 190.41,109.86 190.41,110.06 190.26,110.2 186.85,110.2 186.72,110.07 v1(186.72,109.91)
  BOTTOM w0.095: v1(186.72,109.91) 186.43,110.21 186.14,110.21 C9015.1 ; U2000.AP18 198.8,112.6 198.53,112.33 198.53,112 198.42,111.89 v1(198.23,111.89)
PEG_TXN6: length 69.2
  BOTTOM w0.095: U2000.AM18 201.62,113.06 201.05,113.06 200.82,113.29 197.33,113.29 197.06,113.02 197.06,112.25 196.92,112.1 196.72,112.1 196.58,112.25 196.58,114.09 196.46,114.21 196.46,115.53 196.11,115.89 192.96,115.89 192.7,115.63 192.7,115.26 192.96,115 195.45,115 195.57,114.87 195.57,114.65 195.45,114.52 192.37,114.52 192.11,114.26 192.11,113.89 192.37,113.63 195.55,113.63 195.69,113.49 195.69,113.29 195.55,113.15 191.96,113.15 191.7,112.89 191.7,112.52 191.96,112.26 195.43,112.26 195.57,112.12 195.57,111.92 195.43,111.77 192.35,111.77 192.09,111.51 192.09,111.15 192.35,110.89 195.54,110.89 195.69,110.73 195.69,110.56 195.51,110.38 194.44,110.38 194.16,110.11 194.16,108.92 194.02,108.78 193.82,108.78 193.68,108.92 193.68,110.14 193.42,110.4 193.05,110.4 192.79,110.14 192.79,108.93 192.64,108.78 192.45,108.78 192.3,108.93 192.3,110.25 191.89,110.66 191.06,110.66 190.39,110 189.44,110 189.29,110.15 189.29,110.36 189.44,110.5 190.22,110.5 190.48,110.77 190.48,111.12 190.21,111.39 188.81,111.39 188.67,111.53 188.67,111.74 188.81,111.88 190.36,111.88 190.62,112.14 190.62,112.51 190.36,112.77 188.06,112.77 187.78,112.49 187.78,111.56 187.62,111.41 185.13,111.41 185.02,111.52 184.5,111.52 C9017.1
PEG_TXN7: length 68.7
  IN3 w0.089: v1(186.72,112.71) 187.01,112.42 187.67,112.42 188.06,112.04 188.06,111.41 188.44,111.03 190.24,111.03 190.38,111.16 190.38,111.36 190.24,111.5 188.82,111.5 188.56,111.75 188.56,112.11 188.82,112.36 189.63,112.36 189.77,112.5 189.77,112.69 189.63,112.83 188.07,112.83 187.8,113.09 187.8,113.49 188.07,113.76 190.04,113.76 190.9,112.9 191.66,112.9 191.87,113.11 193.52,113.11 193.77,112.86 193.77,112.51 193.52,112.26 192.53,112.26 192.4,112.12 192.4,111.93 192.53,111.79 195.55,111.79 195.8,111.54 195.8,111.19 195.55,110.94 192.28,110.94 192.14,110.8 192.14,110.6 192.28,110.47 195.54,110.47 195.79,110.22 195.79,109.86 195.54,109.62 192.41,109.62 192.27,109.48 192.27,109.28 192.41,109.15 195.12,109.15 195.37,108.9 195.37,108.54 195.12,108.29 192.41,108.29 192.25,108.14 192.25,106.66 192.41,106.5 194.84,106.5 194.97,106.64 194.97,106.84 194.84,106.97 192.98,106.97 192.73,107.22 192.73,107.58 192.98,107.83 195.72,107.83 195.84,107.94 195.84,109.14 196.36,109.67 196.36,114.25 196.75,114.64 198.08,114.64 198.33,114.39 198.33,114.1 v1(198.51,113.93)
  BOTTOM w0.095: C9019.1 186.09,112.47 186.48,112.47 v1(186.72,112.71) ; v1(198.51,113.93) 198.28,114.16 198.28,114.26 198.41,114.39 199.27,114.39 199.92,113.74 200.87,113.74 201.06,113.93 201.71,113.93 U2000.AM20
PEG_TXN8: length 69.3
  BOTTOM w0.095: C9021.1 184.61,113.44 190.3,113.44 190.44,113.59 190.44,113.79 190.3,113.93 187.92,113.93 187.66,114.19 187.66,114.56 187.92,114.82 188.28,114.82 188.39,114.92 188.39,116.62 188.64,116.87 189.01,116.87 189.26,116.62 189.26,114.91 189.35,114.82 189.65,114.82 189.74,114.91 189.74,116.65 190,116.9 190.36,116.9 190.61,116.65 190.61,115.24 190.76,115.08 191.94,115.08 192.09,115.24 192.09,117.13 192.7,117.74 192.7,118.63 193.31,119.24 193.31,121.59 193.61,121.89 193.61,124.48 193.88,124.75 195.17,124.75 195.43,124.49 195.43,124.13 195.17,123.87 194.64,123.87 194.5,123.72 194.5,123.52 194.64,123.38 195.4,123.38 195.66,123.12 195.66,122.75 195.4,122.49 194.64,122.49 194.5,122.35 194.5,122.15 194.64,122.01 195.39,122.01 195.66,121.74 195.66,121.39 195.39,121.12 194.31,121.12 194.22,121.03 194.22,120.7 194.28,120.64 195.87,120.64 196.13,120.38 196.13,120.01 195.87,119.75 194.36,119.75 194.22,119.61 194.22,119.41 194.36,119.27 195.92,119.27 196.13,119.06 196.13,118.59 195.92,118.38 193.73,118.38 193.59,118.24 193.59,118.01 193.71,117.9 196.44,117.9 196.7,117.64 196.7,117.27 196.44,117.01 193.22,117.01 193.07,116.86 193.07,116.65 193.22,116.5 196.55,116.5 197.07,115.98 197.07,114.7 197.19,114.58 197.42,114.58 198.04,115.2 199.59,115.2 199.98,114.81 200.19,114.81 U2000.AP21
PEG_TXN9: length 69.2
  IN3 w0.089: v1(186.72,113.98) 187.01,114.26 190.09,114.26 190.32,114.49 190.32,114.87 190.06,115.13 188.01,115.13 187.87,115.27 187.87,115.47 188.01,115.61 190.27,115.61 190.81,115.07 191.74,115.07 192.06,114.75 192.06,113.75 192.31,113.5 193.52,113.5 193.77,113.75 193.77,114.1 193.52,114.35 193.08,114.35 192.95,114.49 192.95,114.69 193.08,114.82 193.52,114.82 193.77,115.07 193.77,115.42 193.52,115.67 192.45,115.67 192.31,115.81 192.31,116.01 192.45,116.14 193.78,116.14 194.02,116.39 194.02,116.75 193.78,116.99 192.99,116.99 192.84,117.15 192.84,118.71 193.25,119.12 193.74,119.12 193.99,119.37 193.99,119.86 194.44,120.32 196.41,120.32 196.55,120.18 196.55,119.98 196.41,119.85 194.74,119.85 194.49,119.6 194.49,119.24 194.74,118.99 196.43,118.99 196.57,118.86 196.57,118.66 196.43,118.52 193.56,118.52 193.31,118.28 193.31,117.71 193.55,117.46 194.34,117.46 194.55,117.67 196.43,117.67 196.57,117.54 196.57,117.34 196.43,117.2 194.78,117.2 194.53,116.95 194.53,116.6 194.78,116.35 196.49,116.35 196.67,116.18 196.67,116 196.55,115.88 194.56,115.88 194.16,115.48 194.16,112.45 194.43,112.18 195.7,112.18 195.97,112.45 195.97,112.77 195.7,113.03 195.24,113.03 195.1,113.17 195.1,113.36 195.24,113.5 195.7,113.5 195.97,113.77 195.97,114.09 195.7,114.35 195.13,114.35 194.98,114.51 194.98,114.88 195.13,115.03 198.3,115.03 198.47,115.2 198.47,115.39 v1(198.76,115.68)
  BOTTOM w0.095: v1(198.76,115.68) 198.71,115.73 198.71,116 198.83,116.12 199.57,116.12 200.21,115.48 200.62,115.48 200.92,115.17 200.92,114.94 201.13,114.73 201.71,114.73 U2000.AM21 ; C9023.1 185.86,113.98 186.15,114.27 186.43,114.27 v1(186.72,113.98)
PEG_TXN10: length 68.7
  BOTTOM w0.095: C9025.1 184.98,115.76 185.26,115.48 187.62,115.48 187.78,115.63 187.78,116.87 188.39,117.48 188.39,118.6 188.67,118.88 190.45,118.88 190.71,118.62 190.71,118.25 190.45,117.99 189.42,117.99 189.27,117.85 189.27,117.65 189.42,117.51 190.6,117.51 190.74,117.38 191.47,117.38 192.09,118 192.09,118.88 192.7,119.49 192.7,121.84 193,122.14 193,127.36 193.26,127.62 193.66,127.62 193.89,127.38 193.89,125.5 194.03,125.36 194.23,125.36 194.37,125.5 194.37,128.15 194.65,128.43 194.65,129.2 195.31,129.86 195.31,130.95 195.52,131.15 195.96,131.15 196.17,130.95 196.17,129.96 196.3,129.83 197.11,129.83 197.33,129.61 197.33,129.15 197.11,128.94 195.63,128.94 195.49,128.79 195.49,128.56 195.59,128.46 197.33,128.46 197.58,128.2 197.58,127.9 197.23,127.55 195.33,127.55 195.23,127.45 195.23,127.13 195.31,127.05 197.01,127.05 197.27,126.79 197.27,126.42 197.01,126.16 195.36,126.16 195.23,126.03 195.23,125.78 195.34,125.68 197.01,125.68 197.27,125.42 197.27,125.05 197.01,124.79 196.16,124.79 196.04,124.67 196.04,123.6 196.27,123.38 196.27,121.1 196.96,120.41 196.96,120 196.74,119.79 196.74,118.5 197.31,117.93 197.31,117.39 197.58,117.12 197.58,116.45 197.7,116.33 197.92,116.33 198.35,116.76 199.88,116.76 200.2,116.44 200.63,116.44 200.84,116.65 200.84,116.88 201.12,117.15 201.73,117.15 U2000.AM23
PEG_TXN11: length 68.8
  IN3 w0.089: v1(199.13,117.6) 199.05,117.6 198.8,117.35 198.8,117.18 198.93,117.06 200.02,117.06 200.17,117.21 200.17,118.65 200.42,118.9 200.77,118.9 201.02,118.65 201.02,117.93 201.17,117.78 201.43,117.78 201.58,117.93 201.58,118.26 201.84,118.52 202.21,118.52 202.79,117.94 202.79,117.18 202.54,116.93 201.29,116.93 201.14,116.78 201.14,115.73 201.3,115.57 202.54,115.57 202.79,115.32 202.79,114.97 202.54,114.72 201.13,114.72 201,114.58 201,114.39 201.13,114.25 201.78,114.25 202.03,114 202.03,113.65 201.78,113.4 201.13,113.4 201,113.26 201,113.07 201.13,112.93 201.78,112.93 202.03,112.68 202.03,112.33 201.78,112.08 201.13,112.08 201,111.94 201,111.75 201.13,111.61 202.64,111.61 202.89,111.36 202.89,111.01 202.64,110.76 201.13,110.76 201,110.62 201,110.43 201.13,110.29 202.79,110.29 203.04,110.04 203.04,109.69 202.79,109.44 201.13,109.44 201,109.3 201,109.11 201.13,108.97 201.57,108.97 201.84,108.7 201.84,108.38 201.57,108.12 200.38,108.12 200.12,108.38 200.12,114.15 199.97,114.3 199.23,114.3 198.98,114.55 198.98,114.9 199.23,115.15 199.97,115.15 200.12,115.31 200.12,115.84 199.79,116.17 198.26,116.17 197.16,117.28 197.16,117.94 197.42,118.2 198.01,118.2 198.15,118.34 198.15,118.53 198.01,118.67 197.42,118.67 197.16,118.93 197.16,120.56 196.82,120.9 194.2,120.9 192.25,118.96 192.25,117.51 191.9,117.15 190.88,117.15 190.02,116.3 186.85,116.3 186.72,116.17 v1(186.72,116.01)
  BOTTOM w0.095: U2000.AP24 200.48,117.41 200.25,117.19 199.27,117.19 199.13,117.33 v1(199.13,117.6) ; C9027.1 186.14,116.3 186.43,116.3 v1(186.72,116.01)
PEG_TXN12: length 69.6
  BOTTOM w0.095: C9029.1 184.49,117.62 184.83,117.62 184.94,117.51 187.55,117.51 187.78,117.73 187.78,118.85 188.39,119.46 188.39,120.25 188.65,120.51 189.01,120.51 189.27,120.25 189.27,119.6 189.38,119.49 189.65,119.49 189.76,119.59 189.76,121.31 190.02,121.57 190.39,121.57 190.65,121.31 190.65,119.64 190.77,119.52 191.84,119.52 192.09,119.77 192.09,121.31 191.93,121.48 191.93,121.93 192.39,122.39 192.39,125.4 192.23,125.57 191.13,125.57 190.87,125.83 190.87,126.2 191.13,126.46 192.24,126.46 192.39,126.61 192.39,126.79 192.24,126.94 191.58,126.94 191.32,127.2 191.32,127.73 191.57,127.98 192.56,127.98 192.82,128.23 193.55,128.23 194.04,128.72 194.04,129.45 194.7,130.11 194.7,132.9 194.93,133.14 195.3,133.14 195.56,132.88 195.56,131.91 195.7,131.76 195.9,131.76 196.04,131.91 196.04,132.89 196.32,133.16 197.92,133.16 198.18,132.9 198.18,132.53 197.92,132.27 197.07,132.27 196.93,132.13 196.93,131.93 197.07,131.79 198.55,131.79 198.81,131.53 198.81,131.16 198.55,130.9 196.92,130.9 196.78,130.76 196.78,130.56 196.92,130.42 198.54,130.42 198.81,130.15 198.81,128.29 197.88,127.36 197.88,124.4 197.64,124.17 196.76,124.17 196.65,124.06 196.65,123.86 196.88,123.63 196.88,121.38 197.62,120.64 198.55,120.64 198.81,120.38 198.81,120.01 198.55,119.75 197.54,119.75 197.35,119.56 197.35,118.78 197.91,118.23 200.88,118.23 201.14,117.97 201.55,117.97 201.92,117.6 U2000.AM24
PEG_TXN13: length 68.8
  IN3 w0.089: v1(186.72,118.04) 187.01,118.33 187.69,118.33 187.8,118.21 189.37,118.21 189.52,118.07 189.52,117.87 189.37,117.73 187.92,117.73 187.67,117.48 187.67,117.13 187.92,116.88 189.78,116.88 190.41,117.5 190.41,118.81 190.14,119.08 188,119.08 187.87,119.21 187.87,119.41 188,119.55 190.44,119.55 190.68,119.31 191.78,119.31 192.88,120.41 192.88,120.81 192.7,120.99 192.45,120.99 192.31,121.14 192.31,121.34 192.45,121.48 195.81,121.48 196.06,121.73 196.06,122.09 195.79,122.35 192.12,122.35 191.99,122.49 191.99,122.69 192.12,122.82 195.81,122.82 196.06,123.07 196.06,123.43 195.81,123.67 192.12,123.67 191.99,123.81 191.99,124.01 192.12,124.14 195.81,124.14 196.06,124.39 196.06,124.75 195.81,125 192.19,125 192.06,125.13 192.06,125.33 192.19,125.47 195.81,125.47 196.06,125.71 196.06,126.07 195.81,126.32 195.62,126.32 195.49,126.45 195.49,126.65 195.62,126.79 196.46,126.79 196.62,126.63 196.62,121.93 197.61,120.93 199.28,120.93 199.42,120.79 199.42,120.6 199.28,120.46 198.63,120.46 198.41,120.23 v1(198.41,119.31)
  BOTTOM w0.095: U2000.AM26 201.63,118.85 200.85,118.85 200.62,118.63 198.87,118.63 198.62,118.87 198.62,119.1 v1(198.41,119.31) ; v1(186.72,118.04) 186.52,118.24 186.05,118.24 C9031.1
PEG_TXN14: length 69.1
  BOTTOM w0.095: C9033.1 184.61,119.54 187.52,119.54 187.78,119.8 187.78,120.87 188.05,121.14 188.99,121.14 189.15,121.3 189.15,122.06 189.51,122.42 190.41,122.42 190.86,121.96 191.1,121.96 191.23,122.1 191.23,122.31 191.11,122.43 191.11,122.84 191.37,123.1 191.66,123.1 191.78,123.23 191.78,123.48 191.67,123.59 191.51,123.59 191.25,123.85 191.25,124.21 191.51,124.47 191.64,124.47 191.78,124.62 191.78,124.82 191.64,124.96 190.85,124.96 190.52,125.3 189.65,125.3 189.39,125.56 189.39,125.93 189.65,126.2 190.01,126.2 190.71,126.9 190.71,128.28 191.04,128.61 192.34,128.61 192.57,128.84 193.26,128.84 193.43,129.01 193.43,129.71 193.63,129.91 193.63,132.59 193.04,133.19 192.06,133.19 191.73,133.52 191.73,135.16 191.99,135.42 192.35,135.42 192.61,135.16 192.61,134.22 192.76,134.08 192.96,134.08 193.1,134.22 193.1,135.42 193.36,135.68 193.73,135.68 193.99,135.42 193.99,133.54 194.13,133.39 194.33,133.39 194.47,133.54 194.47,135.29 194.73,135.55 195.1,135.55 195.36,135.29 195.36,133.87 195.5,133.73 195.7,133.73 195.84,133.87 195.84,134.77 196.11,135.04 196.49,135.04 196.76,134.77 196.76,133.91 196.9,133.77 197.1,133.77 197.24,133.91 197.24,134.9 197.51,135.17 197.88,135.17 198.15,134.9 198.15,133.98 198.79,133.35 198.79,132.46 199.42,131.82 199.42,130.93 199.57,130.77 200.48,130.77 200.74,130.51 200.74,130.15 200.48,129.88 199.57,129.88 199.42,129.73 199.42,128.04 198.49,127.11 198.49,123.71 198.24,123.46 197.65,123.46 197.52,123.32 197.52,121.63 197.9,121.25 198.8,121.25 199.62,120.44 199.62,120.25 200.04,119.83 200.21,119.83 U2000.AP27
PEG_TXN15: length 68.2
  IN3 w0.089: v1(186.72,120.07) 187.01,120.36 190.47,120.36 190.72,120.61 190.72,120.96 190.47,121.21 189.29,121.21 189.14,121.36 189.14,121.6 189.29,121.76 191.04,121.76 191.4,122.12 191.4,125.05 191.04,125.42 191.04,125.82 191.27,126.05 194.65,126.05 194.9,126.3 194.9,126.65 194.65,126.9 190.54,126.9 190.41,127.04 190.41,127.23 190.54,127.37 194.16,127.37 194.41,127.62 194.41,127.97 194.16,128.22 191.05,128.22 190.91,128.36 190.91,128.55 191.05,128.69 196.19,128.69 196.44,128.94 196.44,129.29 196.19,129.54 193.59,129.54 193.45,129.68 193.45,129.87 193.59,130.01 196.86,130.01 197.01,129.86 197.01,129.01 197.27,128.74 197.87,128.74 198.03,128.59 198.03,128.37 197.87,128.22 195.16,128.22 194.91,127.97 194.91,127.62 195.16,127.37 197.89,127.37 198.03,127.23 198.03,127.04 197.89,126.9 197.45,126.9 197.2,126.65 197.2,126.3 197.45,126.05 197.89,126.05 198.03,125.91 198.03,125.72 197.89,125.58 197.45,125.58 197.2,125.33 197.2,124.98 197.45,124.73 197.89,124.73 198.03,124.59 198.03,124.4 197.89,124.26 197.46,124.26 197.2,123.99 197.2,122.17 197.46,121.91 197.87,121.91 v1(198.03,121.76)
  BOTTOM w0.095: C9035.1 186.09,120.32 186.48,120.32 v1(186.72,120.07) ; v1(198.03,121.76) 198.18,121.91 198.77,121.91 200.08,120.6 200.64,120.6 200.89,120.34 200.89,119.97 201.13,119.73 201.71,119.73 U2000.AM27
PEG_TXP0: length 68.6
  BOTTOM w0.095: C9004.1 184.33,105.09 184.48,105.25 186.26,105.25 186.45,105.06 187.33,105.06 187.42,104.96 187.42,104.8 187.1,104.48 187.1,104.09 187.42,103.77 187.42,102.07 187.29,101.93 185.75,101.93 185.52,101.69 185.52,101.28 185.75,101.04 187.23,101.04 187.38,100.89 187.38,100.67 187.23,100.51 185.63,100.51 185.37,100.25 185.37,99.88 185.63,99.62 187.21,99.62 187.37,99.46 187.37,99.24 187.24,99.11 185.5,99.11 185.13,98.75 185.13,98.23 185.5,97.87 186.47,97.87 186.76,97.57 186.76,97.16 186.99,96.93 187.37,96.93 187.62,97.18 187.62,98.25 187.77,98.4 187.98,98.4 188.13,98.25 188.13,97.6 188.85,96.88 189.63,96.88 189.9,96.61 189.9,95.22 188.9,94.23 187.93,94.23 187.67,93.97 187.67,93.61 187.93,93.36 188.16,93.36 188.3,93.22 188.3,93.02 188.16,92.88 187.91,92.88 187.67,92.65 187.67,92.31 187.91,92.08 189.63,92.08 189.9,92.34 189.9,93.69 190.59,94.38 191.75,94.38 192.01,94.64 192.01,95 191.75,95.25 190.87,95.25 190.77,95.35 190.77,95.66 190.87,95.76 191.99,95.76 192.34,95.4 192.73,95.4 192.98,95.66 192.98,96.83 193.11,96.95 193.38,96.95 193.5,96.83 193.5,94.73 193.77,94.47 194.21,94.47 194.47,94.73 194.47,101.7 195.1,102.34 195.1,105.26 196.1,106.26 197.77,106.26 199.02,107.51 199.8,107.51 200.34,108.05 200.67,108.05 200.92,107.8 200.92,107.43 201.07,107.28 201.19,107.28 201.28,107.37 U2000.AN12
PEG_TXP1: length 68.8
  IN3 w0.089: v1(186.72,106.61) 186.72,106.42 186.82,106.31 187.69,106.31 188.06,105.95 188.06,104.84 190.62,102.28 190.62,99.67 192.2,98.1 196.57,98.1 196.82,97.85 196.82,97.5 196.57,97.25 193.21,97.25 193.07,97.11 193.07,96.91 193.21,96.78 196.09,96.78 196.34,96.53 196.34,96.17 196.09,95.93 194.88,95.93 194.72,95.77 194.72,95.28 195.11,94.9 195.59,94.9 195.89,95.19 196.15,95.46 196.75,95.46 196.95,95.25 196.95,94.26 197.09,94.12 198.33,94.12 198.49,94.28 198.49,94.48 198.38,94.59 197.77,94.59 197.42,94.94 197.42,95.25 197.62,95.46 198.41,95.46 198.55,95.59 198.55,95.79 198.41,95.93 197.77,95.93 197.52,96.17 197.52,96.53 197.77,96.78 198.41,96.78 198.55,96.91 198.55,97.11 198.41,97.25 197.58,97.25 197.33,97.5 197.33,97.85 197.58,98.1 198.41,98.1 198.55,98.23 198.55,98.43 198.41,98.57 197.75,98.57 197.5,98.82 197.5,99.17 197.75,99.42 198.41,99.42 198.55,99.56 198.55,99.75 198.41,99.89 198.15,99.89 197.9,100.14 197.9,100.49 198.15,100.74 198.41,100.74 198.55,100.88 198.55,101.07 198.41,101.21 197.72,101.21 197.47,101.46 197.47,101.81 197.72,102.06 198.41,102.06 198.55,102.2 198.55,103.96 199.15,104.56 199.15,104.75 199.02,104.89 198.48,104.89 198.23,105.14 198.23,105.49 198.48,105.74 199.16,105.74 199.3,105.88 199.3,106.07 199.16,106.21 198.72,106.21 198.47,106.46 198.47,106.81 198.72,107.06 199.91,107.06 200.25,106.72 200.25,106.09 200.36,105.97 200.56,105.97 200.84,106.25 200.84,107.4 200.7,107.53 198.79,107.53 198.55,107.77 198.55,108.09 v1(198.3,108.34)
  BOTTOM w0.095: C9006.1 185.85,106.5 186.09,106.26 186.59,106.26 186.72,106.39 v1(186.72,106.61) ; U2000.AN14 200.89,108.91 199.2,108.91 199.06,108.77 198.73,108.77 v1(198.3,108.34)
PEG_TXP2: length 69.1
  BOTTOM w0.095: C9008.1 184.62,107.16 188.84,107.16 188.97,107.03 188.97,106.76 188.84,106.63 188.17,106.63 187.84,106.3 187.84,105.65 188.03,105.46 188.03,102.5 188.29,102.24 188.75,102.24 188.89,102.09 188.89,101.88 188.75,101.73 188.22,101.73 187.96,101.48 187.96,101.12 188.22,100.87 188.73,100.87 188.89,100.71 188.89,100.06 188.73,99.9 188.23,99.9 187.98,99.65 187.98,99.29 188.23,99.04 188.58,99.04 188.74,98.88 188.74,97.91 189.09,97.56 189.49,97.56 189.76,97.83 189.76,101.89 189.91,102.04 190.12,102.04 190.27,101.89 190.27,97.1 191,96.37 192.11,96.37 192.37,96.63 192.37,96.97 192.11,97.23 191.38,97.23 191.23,97.39 191.23,97.61 191.38,97.77 192.38,97.77 192.59,97.56 193.6,97.56 193.86,97.83 193.86,98.37 193.6,98.63 191.29,98.63 191.14,98.78 191.14,98.99 191.29,99.14 193.61,99.14 193.86,99.39 193.86,99.75 193.61,100 191.28,100 191.13,100.15 191.13,100.36 191.28,100.51 193.6,100.51 193.86,100.77 193.86,101.11 193.6,101.37 191.31,101.37 191.16,101.52 191.16,101.73 191.31,101.88 193.79,101.88 194.49,102.59 194.49,105.79 194.65,105.95 194.93,105.95 195.86,106.87 197.52,106.87 197.78,107.13 197.78,107.55 197.57,107.76 197.28,107.76 197.12,107.92 197.12,108.88 197.53,109.29 199.94,109.29 200.2,109.55 200.33,109.55 200.48,109.4 U2000.AP14
PEG_TXP3: length 67.9
  IN3 w0.089: v1(198.38,109.99) 198.46,109.99 198.72,109.73 198.72,109.63 198.96,109.39 199.28,109.39 199.42,109.26 199.42,109.06 199.28,108.92 197.27,108.92 197.01,108.66 197.01,107.53 197.26,107.28 197.73,107.28 197.89,107.13 197.89,106.77 197.75,106.63 196.43,106.63 196.18,106.38 196.18,106.03 196.43,105.78 197.51,105.78 197.64,105.64 197.64,105.45 197.51,105.31 195.94,105.31 195.69,105.06 195.69,104.71 195.94,104.46 197.36,104.46 197.5,104.32 197.5,104.13 197.36,103.99 195.8,103.99 195.55,103.74 195.55,103.39 195.8,103.14 197.83,103.14 197.97,103 197.97,102.81 197.83,102.67 195.41,102.67 195.1,102.37 195.1,101.51 194.97,101.37 192,101.37 191.74,101.11 191.74,100.74 192,100.47 194.97,100.47 195.1,100.33 195.1,100.14 194.97,100 192.89,100 192.63,99.74 192.63,99.41 192.89,99.15 196.11,99.15 196.37,99.41 196.37,101.67 196.52,101.82 196.73,101.82 196.88,101.67 196.88,98.83 196.73,98.68 192.65,98.68 191.21,100.13 191.21,102.52 188.64,105.09 188.64,106.27 188.31,106.6 188.31,107.99 187.94,108.36 186.89,108.36 186.72,108.52 v1(186.72,108.64)
  BOTTOM w0.095: v1(186.72,108.64) 186.72,108.52 186.56,108.36 185.99,108.36 185.85,108.5 C9010.1 ; v1(198.38,109.99) 198.66,110.28 198.66,110.49 199.01,110.84 200.69,110.84 201.03,110.5 201.53,110.5 201.66,110.37 201.66,110.23 201.53,110.1 U2000.AN15
PEG_TXP4: length 68.9
  BOTTOM w0.095: C9012.1 184.33,109.18 184.45,109.3 184.88,109.3 184.99,109.19 187.7,109.19 187.97,109.45 187.97,110.06 188.12,110.21 188.33,110.21 188.49,110.06 188.49,109.45 188.75,109.19 190.28,109.19 190.43,109.04 190.43,108.82 190.28,108.66 187.95,108.66 187.69,108.41 187.69,108.05 187.95,107.8 190.28,107.8 190.43,107.65 190.43,107.44 190.28,107.29 189.83,107.29 189.58,107.04 189.58,106.68 189.83,106.43 190.31,106.43 190.46,106.28 190.46,106.07 190.31,105.92 188.89,105.92 188.64,105.67 188.64,105.31 188.89,105.06 190.28,105.06 190.43,104.91 190.43,104.7 190.28,104.55 188.95,104.55 188.69,104.28 188.69,103.09 188.95,102.83 189.47,102.83 189.73,103.09 189.73,103.53 189.89,103.68 190.11,103.68 190.27,103.53 190.27,102.91 190.52,102.66 190.88,102.66 191.13,102.91 191.13,103.96 191.28,104.11 191.49,104.11 191.64,103.96 191.64,102.74 191.89,102.49 193.54,102.49 193.88,102.84 193.88,103.09 193.62,103.35 192.65,103.35 192.5,103.5 192.5,103.71 192.65,103.86 193.63,103.86 193.88,104.12 193.88,104.47 193.63,104.73 192.42,104.73 192.28,104.87 192.28,105.09 192.42,105.23 193.63,105.23 193.88,105.49 193.88,105.85 193.63,106.1 192.38,106.1 192.23,106.25 192.23,106.46 192.38,106.61 194.66,106.61 194.91,106.86 194.91,107.22 194.66,107.47 192.4,107.47 192.25,107.62 192.25,107.83 192.4,107.98 194.88,107.98 195.14,108.24 195.14,109.44 195.29,109.58 195.5,109.58 195.65,109.44 195.65,107.73 195.9,107.48 196.26,107.48 196.51,107.73 196.51,109.62 196.67,109.78 197.05,109.78 197.32,110.04 197.32,110.41 197.05,110.67 196.64,110.67 196.49,110.82 196.49,111.04 196.64,111.2 200.87,111.2 201.05,111.38 201.57,111.38 201.68,111.49 201.68,111.69 201.57,111.8 U2000.AN17
PEG_TXP5: length 68.7
  IN3 w0.089: v1(186.72,110.68) 187.01,110.39 190.34,110.39 190.6,110.14 190.6,109.78 190.34,109.53 188.13,109.53 187.99,109.39 187.99,109.19 188.13,109.06 190.35,109.06 190.6,108.81 190.6,108.46 190.35,108.21 189.03,108.21 188.89,108.07 188.89,107.87 189.03,107.74 190.45,107.74 190.7,107.49 190.7,107.13 190.45,106.89 189.3,106.89 189.16,106.75 189.16,106.55 189.3,106.42 190.47,106.42 190.72,106.17 190.72,105.81 190.47,105.56 189.46,105.56 189.32,105.43 189.32,105.23 189.46,105.09 190.3,105.09 190.53,104.87 190.53,104.25 191.79,102.99 191.79,102.11 191.94,101.96 194.38,101.96 194.52,102.1 194.52,102.29 194.38,102.43 192.57,102.43 192.32,102.68 192.32,103.03 192.57,103.28 194.77,103.28 194.92,103.43 194.92,103.6 194.77,103.75 192.2,103.75 191.95,104 191.95,104.35 192.2,104.6 194.97,104.6 195.1,104.74 195.1,104.93 194.97,105.07 192.33,105.07 192.08,105.32 192.08,105.67 192.33,105.92 195.42,105.92 195.56,106.06 195.56,106.62 196.42,107.48 196.42,108.9 197.04,109.52 197.04,110.49 197.24,110.68 199.28,110.68 199.42,110.82 199.42,111.01 199.28,111.15 197.21,111.15 196.95,111.42 196.95,112.31 198.07,113.44 199.46,113.44 199.73,113.17 199.73,112.76 199.46,112.5 198.93,112.5 198.78,112.35 198.78,112.1 v1(198.99,111.89)
  BOTTOM w0.095: U2000.AP17 200.48,111.98 200.05,112.41 198.88,112.41 198.72,112.25 198.72,111.99 198.83,111.89 v1(198.99,111.89) ; C9014.1 186.14,110.4 186.44,110.4 v1(186.72,110.68)
PEG_TXP6: length 69.1
  BOTTOM w0.095: C9016.1 184.33,111.27 184.39,111.33 184.94,111.33 185.05,111.22 187.7,111.22 187.97,111.49 187.97,112.41 188.13,112.57 190.28,112.57 190.43,112.43 190.43,112.22 190.28,112.07 188.73,112.07 188.47,111.81 188.47,111.46 188.73,111.2 190.13,111.2 190.29,111.04 190.29,110.85 190.14,110.7 189.36,110.7 189.1,110.43 189.1,110.07 189.36,109.81 190.47,109.81 191.13,110.47 191.81,110.47 192.11,110.17 192.11,108.85 192.37,108.59 192.72,108.59 192.98,108.85 192.98,110.06 193.13,110.21 193.34,110.21 193.49,110.06 193.49,108.84 193.74,108.59 194.1,108.59 194.35,108.84 194.35,110.03 194.51,110.19 195.59,110.19 195.88,110.48 195.88,110.81 195.61,111.08 192.43,111.08 192.28,111.22 192.28,111.44 192.43,111.58 195.51,111.58 195.76,111.84 195.76,112.2 195.51,112.45 192.03,112.45 191.89,112.6 191.89,112.81 192.03,112.96 195.63,112.96 195.88,113.21 195.88,113.57 195.63,113.82 192.45,113.82 192.3,113.97 192.3,114.18 192.45,114.33 195.52,114.33 195.76,114.57 195.76,114.95 195.52,115.19 193.04,115.19 192.89,115.34 192.89,115.55 193.04,115.7 196.03,115.7 196.27,115.45 196.27,114.13 196.39,114.02 196.39,112.17 196.64,111.91 197,111.91 197.25,112.17 197.25,112.94 197.41,113.1 200.74,113.1 200.92,112.92 200.92,112.44 200.97,112.38 201.23,112.38 201.28,112.44 U2000.AN18
PEG_TXP7: length 68.6
  IN3 w0.089: v1(197.87,113.93) 198.01,113.93 198.14,114.06 198.14,114.31 198,114.45 196.83,114.45 196.55,114.17 196.55,109.59 196.03,109.07 196.03,107.86 195.8,107.63 193.06,107.63 192.92,107.5 192.92,107.3 193.06,107.16 194.92,107.16 195.16,106.92 195.16,106.56 194.92,106.31 192.33,106.31 192.06,106.58 192.06,108.22 192.33,108.49 195.04,108.49 195.18,108.62 195.18,108.82 195.04,108.96 192.33,108.96 192.08,109.2 192.08,109.56 192.33,109.81 195.46,109.81 195.6,109.94 195.6,110.14 195.46,110.28 192.2,110.28 191.95,110.53 191.95,110.88 192.2,111.13 195.47,111.13 195.61,111.26 195.61,111.46 195.47,111.6 192.45,111.6 192.21,111.85 192.21,112.2 192.45,112.45 193.44,112.45 193.58,112.59 193.58,112.78 193.44,112.92 191.95,112.92 191.74,112.71 190.82,112.71 189.96,113.57 188.14,113.57 187.99,113.41 187.99,113.17 188.14,113.02 189.71,113.02 189.96,112.77 189.96,112.42 189.71,112.17 188.9,112.17 188.75,112.03 188.75,111.83 188.9,111.69 190.32,111.69 190.57,111.44 190.57,111.08 190.32,110.83 188.36,110.83 187.87,111.33 187.87,111.96 187.6,112.23 186.81,112.23 186.72,112.14 v1(186.72,111.95)
  BOTTOM w0.095: v1(197.87,113.93) 198.09,114.14 198.09,114.34 198.33,114.58 199.35,114.58 200,113.93 200.79,113.93 200.89,114.03 200.89,114.36 200.99,114.45 201.13,114.45 U2000.AN20 ; v1(186.72,111.95) 186.72,112.15 186.6,112.28 186,112.28 185.85,112.12 C9018.1
PEG_TXP8: length 69.3
  BOTTOM w0.095: C9020.1 184.62,113.25 190.38,113.25 190.63,113.51 190.63,113.86 190.38,114.12 188,114.12 187.85,114.27 187.85,114.48 188,114.63 188.36,114.63 188.58,114.84 188.58,116.54 188.72,116.68 188.93,116.68 189.07,116.54 189.07,114.83 189.27,114.63 189.73,114.63 189.94,114.83 189.94,116.57 190.08,116.71 190.28,116.71 190.42,116.57 190.42,115.16 190.68,114.89 192.02,114.89 192.28,115.16 192.28,117.05 192.89,117.66 192.89,118.55 193.5,119.16 193.5,121.51 193.8,121.81 193.8,124.4 193.96,124.56 195.1,124.56 195.24,124.42 195.24,124.2 195.1,124.06 194.56,124.06 194.31,123.8 194.31,123.44 194.56,123.19 195.32,123.19 195.47,123.04 195.47,122.83 195.32,122.68 194.56,122.68 194.31,122.43 194.31,122.07 194.56,121.82 195.31,121.82 195.47,121.66 195.47,121.47 195.31,121.31 194.23,121.31 194.02,121.11 194.02,120.63 194.2,120.45 195.79,120.45 195.94,120.3 195.94,120.09 195.79,119.94 194.28,119.94 194.02,119.69 194.02,119.33 194.28,119.08 195.84,119.08 195.94,118.98 195.94,118.67 195.84,118.57 193.65,118.57 193.4,118.32 193.4,117.93 193.63,117.71 196.37,117.71 196.51,117.56 196.51,117.35 196.37,117.2 193.14,117.2 192.88,116.94 192.88,116.57 193.14,116.31 196.47,116.31 196.88,115.9 196.88,114.62 197.11,114.39 197.5,114.39 198.11,115.01 199.51,115.01 199.9,114.62 200.16,114.62 U2000.AP20
PEG_TXP9: length 69.1
  IN3 w0.089: v1(186.72,114.74) 186.72,114.66 186.93,114.45 190.01,114.45 190.05,114.5 190.13,114.57 190.13,114.8 189.98,114.94 187.93,114.94 187.67,115.19 187.67,115.55 187.93,115.8 190.35,115.8 190.89,115.26 191.82,115.26 192.25,114.83 192.25,113.83 192.39,113.69 193.44,113.69 193.58,113.83 193.58,114.02 193.44,114.16 193,114.16 192.75,114.41 192.75,114.76 193,115.01 193.44,115.01 193.58,115.15 193.58,115.35 193.44,115.48 192.37,115.48 192.12,115.73 192.12,116.08 192.37,116.33 193.7,116.33 193.83,116.47 193.83,116.67 193.7,116.8 192.91,116.8 192.65,117.07 192.65,118.79 193.17,119.31 193.66,119.31 193.8,119.45 193.8,119.94 194.36,120.51 196.49,120.51 196.74,120.26 196.74,119.9 196.49,119.65 194.82,119.65 194.68,119.52 194.68,119.32 194.82,119.18 196.51,119.18 196.76,118.94 196.76,118.58 196.51,118.33 193.64,118.33 193.5,118.2 193.5,117.78 193.63,117.65 194.26,117.65 194.47,117.86 196.51,117.86 196.76,117.61 196.76,117.26 196.51,117.01 194.86,117.01 194.72,116.88 194.72,116.68 194.86,116.54 196.57,116.54 196.86,116.26 196.86,115.92 196.63,115.69 194.64,115.69 194.35,115.4 194.35,112.52 194.51,112.37 195.62,112.37 195.78,112.52 195.78,112.69 195.62,112.84 195.16,112.84 194.91,113.09 194.91,113.44 195.16,113.69 195.62,113.69 195.78,113.84 195.78,114.01 195.62,114.16 195.05,114.16 194.79,114.43 194.79,114.96 195.05,115.22 198.22,115.22 198.28,115.28 198.28,115.53 v1(198.13,115.68)
  BOTTOM w0.095: v1(186.72,114.74) 186.44,114.46 186.13,114.46 C9022.1 ; U2000.AN21 201.58,115.1 201.71,115.23 201.71,115.42 201.58,115.55 200.81,115.55 200.69,115.67 200.29,115.67 199.65,116.31 198.75,116.31 v1(198.13,115.68)
PEG_TXP10: length 68.7
  BOTTOM w0.095: C9024.1 184.33,115.21 184.68,115.57 184.9,115.57 185.18,115.29 187.7,115.29 187.97,115.55 187.97,116.79 188.58,117.4 188.58,118.52 188.75,118.69 190.37,118.69 190.52,118.54 190.52,118.33 190.37,118.18 189.34,118.18 189.08,117.93 189.08,117.57 189.34,117.32 190.53,117.32 190.66,117.18 191.55,117.18 192.28,117.92 192.28,118.8 192.89,119.41 192.89,121.76 193.19,122.06 193.19,127.28 193.34,127.43 193.58,127.43 193.7,127.3 193.7,125.43 193.95,125.17 194.31,125.17 194.56,125.43 194.56,128.08 194.84,128.35 194.84,129.12 195.5,129.78 195.5,130.87 195.6,130.96 195.88,130.96 195.98,130.87 195.98,129.88 196.22,129.64 197.03,129.64 197.14,129.54 197.14,129.23 197.03,129.13 195.55,129.13 195.29,128.87 195.29,128.49 195.51,128.27 197.25,128.27 197.39,128.13 197.39,127.98 197.15,127.74 195.25,127.74 195.04,127.53 195.04,127.05 195.23,126.86 196.93,126.86 197.08,126.71 197.08,126.5 196.93,126.35 195.28,126.35 195.04,126.11 195.04,125.7 195.26,125.49 196.93,125.49 197.08,125.34 197.08,125.13 196.93,124.98 196.08,124.98 195.85,124.75 195.85,123.52 196.08,123.3 196.08,121.02 196.77,120.33 196.77,120.08 196.55,119.87 196.55,118.42 197.12,117.85 197.12,117.31 197.39,117.04 197.39,116.37 197.62,116.14 198,116.14 198.42,116.57 199.8,116.57 200.12,116.25 200.48,116.25 200.57,116.17 200.57,115.99 200.67,115.89 200.82,115.89 200.92,115.99 200.92,116.44 201.05,116.57 201.05,116.71 201.13,116.8 U2000.AN23
PEG_TXP11: length 68.8
  IN3 w0.089: v1(186.72,116.77) 187.01,116.49 189.94,116.49 190.8,117.34 191.82,117.34 192.06,117.59 192.06,119.03 194.12,121.09 196.9,121.09 197.35,120.64 197.35,119.01 197.5,118.86 198.09,118.86 198.34,118.61 198.34,118.26 198.09,118.01 197.5,118.01 197.35,117.86 197.35,117.36 198.34,116.36 199.87,116.36 200.31,115.91 200.31,115.23 200.05,114.96 199.31,114.96 199.17,114.82 199.17,114.63 199.31,114.49 200.05,114.49 200.31,114.23 200.31,108.46 200.46,108.31 201.49,108.31 201.64,108.46 201.64,108.63 201.49,108.78 201.06,108.78 200.81,109.03 200.81,109.38 201.06,109.63 202.71,109.63 202.85,109.77 202.85,109.96 202.71,110.1 201.06,110.1 200.81,110.35 200.81,110.7 201.06,110.95 202.56,110.95 202.7,111.09 202.7,111.28 202.56,111.42 201.06,111.42 200.81,111.67 200.81,112.02 201.06,112.27 201.7,112.27 201.84,112.41 201.84,112.6 201.7,112.74 201.06,112.74 200.81,112.99 200.81,113.34 201.06,113.59 201.7,113.59 201.84,113.73 201.84,113.92 201.7,114.06 201.06,114.06 200.81,114.31 200.81,114.66 201.06,114.91 202.46,114.91 202.6,115.05 202.6,115.24 202.46,115.38 201.22,115.38 200.95,115.65 200.95,116.86 201.21,117.12 202.46,117.12 202.6,117.26 202.6,117.86 202.13,118.33 201.92,118.33 201.77,118.18 201.77,117.86 201.51,117.59 201.1,117.59 200.83,117.86 200.83,118.57 200.69,118.71 200.5,118.71 200.36,118.57 200.36,117.13 200.1,116.87 198.85,116.87 198.61,117.11 198.61,117.44 198.45,117.6 v1(198.37,117.6)
  BOTTOM w0.095: U2000.AP23 200.28,117 199.1,117 198.5,117.6 v1(198.37,117.6) ; C9026.1 186.13,116.49 186.44,116.49 v1(186.72,116.77)
PEG_TXP12: length 69.6
  BOTTOM w0.095: U2000.AN24 201.28,117.45 201.2,117.37 200.99,117.37 200.91,117.45 200.91,117.93 200.8,118.04 197.83,118.04 197.16,118.7 197.16,119.64 197.46,119.94 198.46,119.94 198.61,120.09 198.61,120.3 198.46,120.45 197.54,120.45 196.69,121.3 196.69,123.55 196.46,123.78 196.46,124.14 196.68,124.36 197.57,124.36 197.69,124.48 197.69,127.44 198.62,128.37 198.62,130.07 198.46,130.23 196.84,130.23 196.59,130.48 196.59,130.84 196.84,131.09 198.47,131.09 198.62,131.24 198.62,131.45 198.47,131.6 197,131.6 196.74,131.85 196.74,132.21 197,132.46 197.84,132.46 197.99,132.61 197.99,132.82 197.84,132.97 196.39,132.97 196.23,132.81 196.23,131.83 195.98,131.57 195.62,131.57 195.37,131.83 195.37,132.8 195.22,132.95 195.01,132.95 194.89,132.82 194.89,130.03 194.23,129.37 194.23,128.65 193.63,128.04 192.9,128.04 192.64,127.79 191.65,127.79 191.51,127.65 191.51,127.28 191.66,127.13 192.32,127.13 192.58,126.87 192.58,126.53 192.32,126.27 191.21,126.27 191.06,126.12 191.06,125.91 191.21,125.76 192.3,125.76 192.58,125.48 192.58,122.31 192.12,121.85 192.12,121.56 192.28,121.39 192.28,119.69 191.92,119.33 190.69,119.33 190.46,119.57 190.46,121.23 190.31,121.38 190.1,121.38 189.95,121.23 189.95,119.51 189.73,119.3 189.3,119.3 189.08,119.52 189.08,120.17 188.94,120.32 188.72,120.32 188.58,120.17 188.58,119.38 187.97,118.77 187.97,117.65 187.63,117.32 184.87,117.32 184.75,117.43 184.4,117.43 184.33,117.36 C9028.1
PEG_TXP13: length 68.8
  IN3 w0.089: v1(199.04,119.31) 198.97,119.31 198.6,119.69 198.6,120.15 198.71,120.27 199.36,120.27 199.61,120.52 199.61,120.87 199.36,121.12 197.69,121.12 196.81,122.01 196.81,126.71 196.54,126.98 195.54,126.98 195.29,126.73 195.29,126.37 195.54,126.13 195.73,126.13 195.87,125.99 195.87,125.79 195.73,125.66 192.11,125.66 191.87,125.41 191.87,125.05 192.11,124.8 195.73,124.8 195.87,124.67 195.87,124.47 195.73,124.34 192.05,124.34 191.8,124.09 191.8,123.73 192.05,123.48 195.73,123.48 195.87,123.35 195.87,123.15 195.73,123.01 192.05,123.01 191.8,122.77 191.8,122.41 192.05,122.16 195.71,122.16 195.87,122.01 195.87,121.81 195.73,121.67 192.37,121.67 192.12,121.42 192.12,121.06 192.37,120.8 192.62,120.8 192.69,120.73 192.69,120.49 191.7,119.5 190.75,119.5 190.52,119.74 187.92,119.74 187.67,119.49 187.67,119.14 187.92,118.89 190.06,118.89 190.21,118.73 190.21,117.58 189.7,117.07 188,117.07 187.87,117.21 187.87,117.4 188,117.54 189.45,117.54 189.71,117.79 189.71,118.15 189.45,118.4 187.88,118.4 187.77,118.52 186.85,118.52 186.72,118.65 v1(186.72,118.8)
  BOTTOM w0.095: U2000.AN26 201.28,119.14 201.18,119.05 200.77,119.05 200.54,118.82 198.94,118.82 198.81,118.95 198.81,119.22 198.91,119.31 v1(199.04,119.31) ; v1(186.72,118.8) 186.72,118.6 186.55,118.43 185.98,118.43 185.85,118.56 C9030.1
PEG_TXP14: length 69.2
  BOTTOM w0.095: C9032.1 184.62,119.35 187.6,119.35 187.97,119.72 187.97,120.79 188.13,120.95 189.07,120.95 189.34,121.22 189.34,121.98 189.59,122.23 190.33,122.23 190.78,121.77 191.18,121.77 191.42,122.02 191.42,122.39 191.3,122.51 191.3,122.76 191.45,122.91 191.73,122.91 191.97,123.15 191.97,123.55 191.75,123.78 191.58,123.78 191.44,123.92 191.44,124.14 191.58,124.28 191.72,124.28 191.97,124.54 191.97,124.9 191.72,125.15 190.93,125.15 190.59,125.49 189.73,125.49 189.58,125.64 189.58,125.85 189.73,126.01 190.09,126.01 190.9,126.82 190.9,128.21 191.12,128.42 192.42,128.42 192.64,128.65 193.34,128.65 193.62,128.93 193.62,129.63 193.82,129.83 193.82,132.67 193.12,133.38 192.13,133.38 191.92,133.6 191.92,135.08 192.06,135.23 192.28,135.23 192.42,135.08 192.42,134.14 192.68,133.89 193.04,133.89 193.29,134.14 193.29,135.34 193.44,135.49 193.65,135.49 193.8,135.34 193.8,133.46 194.05,133.2 194.41,133.2 194.66,133.46 194.66,135.21 194.81,135.36 195.02,135.36 195.17,135.21 195.17,133.79 195.42,133.54 195.78,133.54 196.03,133.79 196.03,134.69 196.19,134.85 196.41,134.85 196.56,134.69 196.56,133.83 196.82,133.58 197.18,133.58 197.43,133.83 197.43,134.82 197.58,134.98 197.81,134.98 197.96,134.82 197.96,133.9 198.6,133.27 198.6,132.38 199.23,131.74 199.23,130.85 199.5,130.58 200.4,130.58 200.55,130.43 200.55,130.22 200.4,130.08 199.5,130.08 199.23,129.81 199.23,128.12 198.3,127.19 198.3,123.79 198.16,123.65 197.57,123.65 197.33,123.4 197.33,121.55 197.82,121.06 198.73,121.06 199.43,120.36 199.43,120.17 199.96,119.64 200.1,119.64 200.44,119.3 U2000.AP26
PEG_TXP15: length 68.2
  IN3 w0.089: v1(198.02,122.39) 197.74,122.1 197.54,122.1 197.39,122.25 197.39,123.92 197.54,124.07 197.97,124.07 198.22,124.32 198.22,124.67 197.97,124.92 197.53,124.92 197.39,125.06 197.39,125.25 197.53,125.39 197.97,125.39 198.22,125.64 198.22,125.99 197.97,126.24 197.53,126.24 197.39,126.38 197.39,126.57 197.53,126.71 197.97,126.71 198.22,126.96 198.22,127.31 197.97,127.56 195.24,127.56 195.1,127.7 195.1,127.89 195.24,128.03 197.95,128.03 198.22,128.29 198.22,128.67 197.95,128.93 197.35,128.93 197.2,129.08 197.2,129.94 196.94,130.2 193.51,130.2 193.26,129.95 193.26,129.6 193.51,129.35 196.11,129.35 196.25,129.21 196.25,129.02 196.11,128.88 190.97,128.88 190.72,128.63 190.72,128.28 190.97,128.03 194.08,128.03 194.22,127.89 194.22,127.7 194.08,127.56 190.46,127.56 190.21,127.31 190.21,126.96 190.46,126.71 194.57,126.71 194.71,126.57 194.71,126.38 194.57,126.24 191.19,126.24 190.85,125.9 190.85,125.34 191.21,124.97 191.21,122.2 190.96,121.95 189.21,121.95 188.94,121.68 188.94,121.28 189.21,121.02 190.39,121.02 190.53,120.88 190.53,120.69 190.39,120.55 186.85,120.55 186.72,120.68 v1(186.72,120.84)
  BOTTOM w0.095: v1(198.02,122.39) 198.31,122.1 198.85,122.1 200.16,120.79 200.71,120.79 201.01,120.49 201.54,120.49 201.65,120.38 201.65,120.22 201.53,120.1 U2000.AN27 ; C9034.1 186.15,120.51 186.6,120.51 186.72,120.63 v1(186.72,120.84)
PEGX_RST#: length 57.3
  TOP w0.114: R2147.1 220.64,83.2 v1(220.25,83.59) 220.12,83.72 R2038.1 ; v1(197.14,96.26) 197.14,97.6 198.11,98.57 198.11,100.57 198.51,100.97 199.09,100.97 200.43,102.31 200.43,106.03 201.14,106.74 202.85,106.74 203.72,107.61 204.54,107.61 v1(204.96,107.2)
  IN4 w0.076: v1(220.25,83.59) 219.55,84.29 209.61,84.29 208.95,84.95 206.75,84.95 204.36,87.34 203.63,87.34 200.29,90.68 200.29,91.06 198.15,93.19 198.15,95.26 197.14,96.28 v1(197.14,96.26)
  BOTTOM w0.114: Q2015.2 218.98,89.74 218.98,88.89 219.36,88.51 219.36,86.97 220.09,86.24 220.09,83.82 220.25,83.65 v1(220.25,83.59)
  BOTTOM w0.127: U2000.AJ12 204.93,107.2 v1(204.96,107.2)
PEX_PLL_HVDD: length 0.6
  BOTTOM w0.381: U2000.AH12 v1(205.78,107.2)
PEX_TERMP: length 9
  BOTTOM w0.102: U2000.AP29 200.44,121.76 199.8,121.76 198.99,122.57 198.99,126.93 200.05,127.98
  BOTTOM w0.114: R2065.2 200.05,127.98
PEX_VDD: length 4.8
  BOTTOM w0.305: U2000.AF6 207.08,102.63 v1(206.71,103) 206.28,102.58 U2000.AG6 ; U2000.AC8 209.63,104.2 v1(210.02,103.8) 210.01,103.8 209.61,103.4 U2000.AC7 ; U2000.AG9 206.18,105.05 v1(205.8,104.67) 206.18,104.29 U2000.AG8
  BOTTOM w0.356: U2000.AH25 205.38,118.62 v3(205.12,118.87)
  BOTTOM w0.381: U2000.AG9 206.18,105.13 v1(205.78,105.53)
  vias: v1(204.76,91.02) v1(205.77,116.39) v1(205.77,115.51) v1(205.77,113.85) v1(206.66,116.39) v1(206.66,115.5) v1(206.66,114.74) v1(206.66,113.85) v4(204.58,93.64) v4(204.58,92.88) v4(204.58,92.12) v4(205.21,93.26) v4(205.21,92.5)
PEX_VDD_S:
  vias: v1(200.18,92.29)
PEXVDD_PWREN: length 5.2
  TOP w0.114: v1(190.53,71.46) 190.15,71.85 PQ9502.3 188.63,72.18 PR9521.2 PR9520.1 187.61,71.85 188.37,71.08 PQ9501.2
PEXVDD_PWREN_MOS: length 27.1
  TOP w0.381: v1(191.29,71.85) 191.29,71.21 190.41,70.32 PQ9501.3 ; v1(198.66,86.93) 199,86.93 199.51,87.43 PR9519.2
  IN2 w0.381: v1(191.29,71.85) 189.77,73.37 189.77,76.04 191.78,78.04 195.76,78.04 200.33,82.61 200.33,85.67 199.07,86.93 v1(198.66,86.93)
PGDMON: length 3.2
  TOP w0.114: R9266.2 244.82,70.55 244.75,70.48 244.75,69.7 v1(245.02,69.43) 245.29,69.43 v1(245.8,69.95)
  BOTTOM w0.114: v1(245.8,69.95) 245.8,70.03 U9002.Y14
PLAY_MUTE_LED: length 8.7
  TOP w0.114: Q6805.3 241.97,46.57 241.84,46.7 241.08,46.7 240.19,47.59 v1(240.19,48.35) 240.19,48.99 239.78,49.39 239.43,49.39 239.3,49.52 238.49,49.52 238.15,49.18 R6806.2 237.85,49.04 237.65,49.24 237.65,49.62 237.01,50.26 R6818.1
PLAY_MUTE_LED_CNTR: length 132.3
  TOP w0.114: v1(243.75,43.17) 243.51,43.41 241.96,43.41 241.7,43.66 R6826.1 241.7,44.3 241.47,44.53 Q6805.2 ; v1(339.48,30.78) 338.77,30.78 337.07,29.08 337.07,27.77 336.4,27.11 336.4,26.1 335.87,25.57 335.87,23.43 338.25,21.05 338.58,21.05 339.03,20.61 339.03,19.99 338.99,19.95 338.99,19.3 338.63,18.94 338.63,17.99 339.03,17.59 339.03,15.7 338.53,15.2 338.53,14.66 338.83,14.36 U3600.10
  IN3 w0.089: v1(243.75,43.17) 244.28,42.64 244.28,41.77 244.51,41.55 244.51,41.54 247.68,38.37 247.68,38.37 256.37,38.37 256.73,38.01 258.04,38.01 260.28,40.25 261.89,40.25 262.24,39.89 268.36,39.89 270.44,37.81 276.14,37.81 277.34,36.62 283.22,36.62 283.63,36.2 286.38,36.2 286.93,35.65 295.31,35.65 295.74,36.08 296.63,36.08 298.59,34.13 300.49,34.13 302.83,31.79 304.53,31.79 305.36,30.96 307.76,30.96 310.11,28.62 321.27,28.62 322.08,27.8 328.35,27.8 328.89,28.34 330.02,28.34 332.01,30.33 332.01,31.08 333.25,32.32 335.26,32.32 336.04,31.54 336.56,31.54 337.31,30.78 v1(339.48,30.78)
PLT_ID0: length 8.2
  BOTTOM w0.114: U9002.AU46 263.21,64.61 263.81,64.01 263.81,63.54 265.36,61.99 265.36,60.27 R9150.1 266.04,60.18 266.96,59.26 R9149.2
PLT_ID1: length 7.9
  BOTTOM w0.114: U9002.AU47 264.05,64.68 264.69,64.04 264.69,63.6 265.71,62.59 265.84,62.59 266.44,61.99 266.44,61.18 R9152.1 266.8,60.95 267.33,60.42 267.36,60.42 267.73,60.05 R9151.2
PLT_ID2: length 8.4
  TOP w0.114: R9153.2 259.7,80.26 259.7,79.47 259.43,79.2 259.28,79.2 259.02,78.95 259.02,78.56 258.63,78.17 R9154.1 258.16,77.46 256.66,75.96 256.66,75.24 256.36,74.94 v1(256.36,74.28)
  BOTTOM w0.114: v1(256.36,74.28) 256.62,74.02 U9002.BA24
PLT_RST#: length 9.1
  TOP w0.127: U9003.1 265.16,79 265.16,79.14 264.85,79.44 264.67,79.44 U9003.2 v1(262.41,77.18) 261.5,76.27 R9215.1 259.73,76.27 R9336.2 R9547.2
PLT_SYSRST_CPU: length 5.4
  TOP w0.114: R9547.1 260.36,74.11 R9602.1 v1(259.73,73.1) 259.37,72.73 259.37,72.42 258.66,71.72 v1(257.84,71.72)
  BOTTOM w0.102: v1(257.84,71.72) 257.67,71.55 U9002.AV29
PLTRST#_EC: length 72.3
  TOP w0.114: R9336.1 258.96,74.92 259.78,74.11 259.78,73.73 259.01,72.96 259.01,72.94 258.91,72.84 v1(258.91,72.57)
  IN1 w0.076: v1(258.91,72.57) 258.91,73.21 258.5,73.62 257.97,73.62 256.7,72.35 256.7,71.24 257.89,70.04 257.89,69.42 260.66,66.65 260.66,66.27 261.02,65.91 261.38,65.91 262.15,65.14 262.73,65.14 263.15,64.72 263.15,63.67 264.86,61.96 264.86,58.49 265.88,57.47 267.43,57.47 268.36,56.54 268.36,55.65 270.07,53.94 270.92,53.94 274.03,50.83 274.03,50.18 274.31,49.9 276.41,49.9 277.91,48.4 v1(278.17,48.4)
  IN2 w0.076: v3(267.59,29.22) 267.26,29.55 267.26,30.21 267.49,30.44
  IN2 w0.089: 267.49,30.44 270.43,33.38 270.43,36.39 273.01,38.97 273.01,43.37 v1(271.74,44.64) 271.74,44.85 274.22,47.33 277.09,47.33 v1(278.17,48.4)
  BOTTOM w0.114: LED9003.1 271.49,44.4 v1(271.74,44.64) ; U6001.J5 v3(267.59,29.22)
PM_PWROK: length 118.6
  TOP w0.127: v1(243.85,83.89) 243.75,83.99 241.31,83.99 240.89,84.41 233.36,84.41 230.36,81.4 230.36,73.83 230.03,73.5 229.31,73.5 228.87,73.06 228.87,71.99 228.66,71.78 228.66,63.13 228.12,62.59 228.12,59.43 229.5,58.05 229.5,53.56 228.71,52.77 228.71,32.55 228.79,32.47 v1(228.79,32.45) ; v3(266.94,29.87) 266.94,30.11 266.33,30.72 266.33,31.18 265.66,31.84 265.66,32.4 265.01,33.05 v1(265.01,33.22) 265.02,33.23 R6071.2
  IN4 w0.127: v1(228.79,32.45) 228.79,32.47 228.86,32.4 229.69,32.4 232.15,29.94 255.54,29.94 258.83,33.22 v1(265.01,33.22)
  BOTTOM w0.102: 246.74,80.93 246.74,80.92 247.43,80.23 247.68,80.23 247.94,79.97 U9002.AU3
  BOTTOM w0.114: U6001.K4 v3(266.94,29.87)
  BOTTOM w0.127: 246.74,80.93 246.69,80.99 246.52,81.15 246.52,81.54 245.94,82.12 245.94,83.63 245.66,83.91 245.66,84.47 245.38,84.75 244.33,84.75 244.14,84.56 244.14,84.18 v1(243.85,83.89)
PM_SYNC: length 330
  IN1 w0.076: v1(83.55,58.26) 83.52,58.26 84.23,58.97 84.23,60.09 83.52,60.8 83.52,62.62 84.84,63.94 84.84,67.23 87.46,69.85 87.46,70.54 91.31,74.39 92.05,74.39 93.78,76.12 94.36,76.12 96.28,78.04 99.72,78.04 102.52,80.84 102.52,82.34 105.21,85.03 105.21,89.14 106.46,90.38 106.46,90.86 107.96,92.36 107.96,93.65 109.3,94.99 109.3,97.28 118.25,106.23 118.25,110.25 123.13,115.14 123.91,115.14 124.12,115.36 124.12,116.16 125.19,117.22 129.13,117.22 129.91,118 133.05,118 136.44,121.39 136.44,121.87 136.93,122.36 140.59,122.36 141.51,123.28 141.51,124.09 v1(141.04,124.55)
  IN2 w0.089: v1(83.55,58.26) 84.33,57.47 86.37,57.47 86.87,56.97 86.87,55.57 87.51,54.92 88.95,54.92 91.23,52.64 94.54,52.64 97.13,50.05 97.13,48.74 103.55,42.32 103.55,31.44 105.48,29.51 105.48,28.84 106.19,28.13 106.86,28.13 108.32,26.68 168.73,26.68 169.48,27.42 182.41,27.42 182.66,27.17 204.89,27.17 206.2,28.49 217.78,28.49 220.83,31.54 222.15,31.54 222.84,32.23 227.63,32.23 229.03,33.63 229.38,33.63 229.73,33.27 230.91,33.27 231.68,34.04 231.68,35.76 233.69,37.77 233.69,58.72 232.95,59.45 232.95,60.03 233.75,60.83 233.75,62.92 233.04,63.63 233.04,67.32 230.16,70.2 230.16,73.77 v1(229.92,74)
  BOTTOM w0.114: U9001.BM34 141.04,124.48 v1(141.04,124.55) ; R9164.1 236.69,82.28 235.2,82.28 232.41,79.49 231.81,79.49 230.82,78.5 230.82,75.94 230.46,75.58 230.46,74.54 v1(229.92,74)
PM_SYNC_R: length 10
  BOTTOM w0.102: 242.73,77.56 243.9,76.39 244.21,76.39 244.33,76.28 244.81,76.28
  BOTTOM w0.114: 242.73,77.56 242.29,78.01 240.94,78.01 237.98,80.97 237.98,81.3 ; 237.98,81.3 v1(237.98,81.32) ; 237.98,81.3 237.98,81.29 237.98,81.5 R9164.2
PM_THRMTRIP#: length 262.2
  TOP w0.102: v1(145.57,43.65) 144.96,44.27 R1001.1 ; R1044.1 149.13,44.41 v1(150.02,43.52)
  TOP w0.127: v1(225.63,78.09) 225.63,78.65 226.09,79.11 R2137.2 ; v1(172.63,131.54) 172.5,131.54 171.94,132.09 171.94,136.67 171.74,136.87 Q9000.3
  IN1 w0.127: v1(172.63,131.54) 173.51,131.54 175.13,133.15 176.72,133.15 177.3,132.58 179.54,132.58 180.15,133.19 181.34,133.19 181.78,132.76 184.56,132.76 184.87,133.06 188.18,133.06 191.56,129.68 191.56,129.11 191.76,128.91 192.44,128.91 v1(192.81,129.27)
  IN2 w0.127: v1(192.81,129.27) 193.22,128.85 193.22,120.41 192.12,119.31 192.12,104.45 190.89,103.21 v1(190.89,98.13) 188.41,98.13 187.1,96.83 187.1,91.28 184.82,88.99 183.98,88.99 182.37,87.38 182.37,70.96 185.83,67.5 185.83,45.86 185.44,45.47 185.44,32.46 184.28,31.31 182.68,31.31 182.15,31.84 145.08,31.84 144.05,30.81 v1(144.05,30.7)
  IN3 w0.127: v1(231.3,78.37) 228.93,78.37 228.24,79.06 227.9,79.06 227.48,78.64 225.94,78.64 225.63,78.33 v1(225.63,78.09) 225.13,78.09 224.22,79.01 220.18,79.01 219.44,79.76 211.97,79.76 208.96,82.77 205.15,82.77 202.6,85.32 202.6,85.82 196.76,91.66 196.76,92.28 193.1,95.94 192.97,95.94 190.89,98.02 v1(190.89,98.13) ; v1(144.05,30.7) 143.92,30.82 143.92,42 v1(145.57,43.65)
  BOTTOM w0.102: 144.08,30.41 144.05,30.44 v1(144.05,30.7) ; v1(145.57,43.65) 145.75,43.47 147.82,43.47 148.57,44.22 R1044.1 148.59,44.39 149.16,44.39 v1(150.02,43.52)
  BOTTOM w0.127: 144.08,30.41 145.07,29.43 R1026.1 ; v1(231.3,78.37) 231.75,78.37 235.33,81.96 236,81.96 R9161.2
PM_THRMTRIP#_L: length 11.3
  BOTTOM w0.114: U9002.AD3 243.82,75.58 243.48,75.58 243.05,76.01 242.54,76.01 241.1,77.45
  BOTTOM w0.127: 241.1,77.45 240.86,77.69 240.44,77.69 C9195.1 239.85,77.56 v1(239.3,77.56) 238.88,77.98 238.88,78.11 238.41,78.58 238.41,79.17 R9141.1 237.9,79.44 237.55,79.8 237.22,79.8 236.89,80.13 236.89,81.07 R9161.1
PORTD_A: length 2.4
  TOP w0.203: U3600.42 341.23,6.04 341.51,5.76
  TOP w0.254: 341.51,5.76 341.65,5.62 341.7,5.62 v1(341.94,5.37) 341.97,5.35 R3611.2
PORTD_A_R: length 2
  TOP w0.203: R3611.1 342.42,3.92 v1(342.11,3.61) 341.92,3.43 C3611.2
PORTD_B: length 4.2
  TOP w0.203: C3612.2 342.96,4.31 v1(343.19,4.54) 343.19,5.45 342.68,5.96 341.8,5.96 341.63,6.12 U3600.43
PP_DETECT#: length 297.2
  TOP w0.114: v3(271.49,27.92) 271.94,27.92 272.25,28.23 273.17,28.23 274.42,29.48 277.76,29.48 278.57,30.29 278.57,30.67 278.89,30.99 v1(279.23,30.99) 279.41,30.99 279.97,30.44 R6237.2
  IN4 w0.076: v1(52.74,44.67) 53.37,44.03 57.18,44.03 58.2,45.05 68.89,45.05 70.82,43.12 71.42,43.12 73.31,45.01 73.31,45.82 76.38,48.9 88.98,48.9 91.17,46.71 91.17,44.41 97.52,38.06 97.52,20.02 108.84,8.69 111.91,8.69 114.62,5.98 176.31,5.98 187.36,17.03 202.42,17.03 204.76,14.7 204.76,10.89 205.52,10.12 209.05,10.12 209.25,10.33 210.56,10.33 212.24,8.65 215.91,8.65 217.85,6.71 234.41,6.71 235.49,5.63 237.09,5.63 238.41,6.95 239.17,6.95 239.66,7.43 250.95,7.43 251.5,7.99 251.5,8.3 251.09,8.71 251.09,14.03 251.54,14.49 251.54,19.1 250.79,19.85 250.79,21.91 252.56,23.69 254.77,23.69 256.14,25.06 257.41,25.06 257.64,25.29 258.26,25.29 258.99,26.02 261.63,26.02 262.67,27.06 263.71,27.06 264.09,26.68 265.39,26.68 265.94,27.24 265.94,28.77 266.07,28.89 268.66,28.89 269.32,28.24 271.17,28.24 v3(271.49,27.92)
  BOTTOM w0.114: R3079.2 v1(52.74,44.67) ; U6001.G10 v3(271.49,27.92)
PP_DETECT#_EDP: length 4.9
  BOTTOM w0.114: Q3006.2 51.6,49.94 v1(51.42,50.13) 51.42,50.74 51.7,51.02 51.7,51.23 R3080.2 52.18,51.71 52.18,52.57 52.43,52.82 CON3000.27

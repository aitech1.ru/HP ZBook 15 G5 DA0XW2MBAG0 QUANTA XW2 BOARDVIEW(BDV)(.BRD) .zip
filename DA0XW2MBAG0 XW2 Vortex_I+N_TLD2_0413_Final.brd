# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPP_G1: length 138.1
  TOP w0.114: v1(332.06,57.11) 328.23,53.28 328.23,53.25 328.02,53.05 328.02,45.99 328.68,45.33 331.5,45.33 332.21,44.62 332.21,37.12 330.23,35.14 v1(330.23,32.6)
  IN1 w0.076: v1(251.24,87.34) 251.31,87.42 255.78,87.42 258.3,84.9 259.13,84.9 261.33,82.7 261.33,82.38 269.32,74.39 269.32,74.16 271.38,72.1 272.5,72.1 274.09,70.51 274.62,70.51 274.87,70.26 275.51,70.26 276.49,69.28 277.15,69.28 279.83,66.6 280.46,66.6 283.27,63.79 285.42,63.79 289.31,59.9 289.88,59.33 289.88,59.06 290.6,58.35 294.15,58.35 295.19,57.3 297.1,57.3 297.86,56.54 299.55,56.54 300.11,57.1 300.88,57.1 301.44,56.54 304.01,56.54 304.65,57.19 307.12,57.19 307.47,57.55 314.05,57.55 314.43,57.16 316.57,57.16 316.77,57.37 320.96,57.37 321.09,57.24 327.69,57.24 327.87,57.06 332.01,57.06 v1(332.06,57.11)
  BOTTOM w0.089: 253.27,80.99 253.52,81.24 253.57,81.24
  BOTTOM w0.102: 253.27,80.99 253.22,80.94 U9002.BE9 ; 252.13,86.45 252.89,85.69 253.15,85.69 254.45,84.39 254.45,82.12 253.57,81.24
  BOTTOM w0.114: v1(330.23,32.6) 330.08,32.45 v1(330.08,31.56) 330.08,31 331.02,30.06 R9618.2 ; 252.13,86.45 v1(251.24,87.34)
GPP_G2: length 74
  IN1 w0.076: v1(250.4,87.47) 250.86,87.92 250.86,88.23 251.03,88.41 251.82,88.41 252.25,87.97 255.84,87.97 258.53,85.28 259.18,85.28 261.63,82.83 261.63,82.51 269.67,74.47 269.67,74.3 270.75,73.22 272.71,73.22 274.53,71.4 275.51,71.4 280,66.92 280.65,66.92 283.42,64.15 285.5,64.15 290.89,58.76 291.32,58.76 291.7,59.14 v1(291.7,59.27)
  BOTTOM w0.102: 250.81,86.45 250.94,86.32 251.35,86.32 252.86,84.82 253.44,84.82 254.03,84.23 254.03,82.31 253.8,82.08 253.47,82.08 253.19,81.79 U9002.BF8
  BOTTOM w0.114: v1(250.4,87.47) 250.58,87.28 250.58,86.68 250.81,86.45 ; v1(291.7,59.27) 291.7,59.19 291.47,58.96 291.47,57.27 291.12,56.92 291.12,56.91 290.48,56.28 290.48,55.72 288.73,53.96 v1(288.73,53.74) 288.45,53.46 288.45,51.48 288.09,51.12 288.09,50.87 R9619.2
GPP_G3: length 117.4
  IN1 w0.076: v1(314.38,57.85) 314.37,57.83 307.55,57.83 307.05,57.34 304.59,57.34 303.94,56.69 301.5,56.69 300.95,57.25 300.04,57.25 299.49,56.69 297.92,56.69 297.16,57.46 295.25,57.46 294.21,58.5 290.67,58.5 290.08,59.09 290.08,59.35 285.44,64 283.29,64 280.52,66.77 279.93,66.77 276.73,69.97 276.15,69.97 275.67,70.44 274.94,70.44 274.72,70.66 274.16,70.66 272.57,72.25 271.46,72.25 269.51,74.2 269.51,74.42 261.48,82.44 261.48,82.76 259.19,85.05 258.45,85.05 255.84,87.67 251.53,87.67 v1(251.23,87.97)
  BOTTOM w0.114: R9145.1 251.23,88.59 v1(251.23,87.97) 253.18,86.02 253.18,85.95 254.21,84.93 254.22,84.93 254.66,84.48 254.66,82.02 U9002.BF9 ; R9344.1 308.88,37.77 309.61,38.5 309.61,39.69 309.07,40.22 v1(309.07,41.14) 308.82,41.39 308.82,42.64 309.4,43.22 309.4,44.81 310.83,46.24 311.03,46.24 312.04,47.25 313.15,47.25 313.49,46.9 315.82,46.9 317.36,48.45 317.36,50.1 317.69,50.43 317.7,50.43 318.37,51.09 318.37,52.34 318.01,52.69 316.01,52.69 315.5,53.2 315.5,55.79 314.38,56.9 v1(314.38,57.85)
GPP_G4: length 64.6
  IN1 w0.076: v1(250.48,88.1) 251.03,88.66 252.13,88.66 252.64,88.15 255.91,88.15 258.62,85.44 259.23,85.44 261.79,82.89 261.79,82.57 263.39,80.97 264.11,80.97 264.3,80.78 264.3,80.07 269.87,74.5 269.87,74.37 270.85,73.4 272.8,73.4 274.64,71.55 275.58,71.55 280.05,67.08 280.72,67.08 283.47,64.33 285.55,64.33 288.31,61.57 288.31,61.56 288.52,61.34 288.53,61.34 290.68,59.19 290.96,59.19 v1(291.04,59.27)
  BOTTOM w0.102: U9002.BG8 253.77,81.74 254.24,82.21 254.24,84.32 253.14,85.41 252.79,85.41 251.75,86.45
  BOTTOM w0.114: v1(291.04,59.27) 291.02,59.29 R9620.2 ; v1(250.48,88.1) 250.83,87.75 250.83,86.98 251.1,86.7 251.49,86.7 251.75,86.45
GPP_H15: length 14.7
  BOTTOM w0.102: U9002.AC47 258.5,59.55 259.39,58.67 259.39,57.41 258.45,56.48 258.45,55.18
  BOTTOM w0.114: 258.45,55.18 258.45,54.24 260.54,52.16 260.67,52.16 261.53,51.29 R9369.2 262.77,51.29 263.43,50.64 v1(263.43,50.26) 263.07,49.9 R9368.1
GPP_J4: length 2.9
  TOP w0.114: R9377.2 249.23,80.96 249.23,80.23 249.43,80.02 v1(249.43,79.89) 249.43,79.85 249.33,79.75 v1(249.33,79.21)
  BOTTOM w0.102: U9002.AV4 249.1,79.45 v1(249.33,79.21)
GPP_J6: length 11.5
  TOP w0.114: v1(245.29,85.84) 245.42,85.84 246.07,86.49 R9378.2 R9546.2 247.79,85.61 248.45,85.61 248.63,85.42 248.63,85.12 249.01,84.74 249.01,84.23 249.69,83.55 249.69,83.31 250.24,82.77 250.24,81.39 249.71,80.86 v1(249.71,80.51) 249.79,80.43 R9373.2
  BOTTOM w0.102: v1(249.71,80.51) 249.71,80.64 U9002.BA4
GPP_J9: length 7
  TOP w0.114: R9371.1 246.67,81.62 v1(246.67,80.69) 247.15,80.2 R9544.2 247.75,79.87 248.57,79.05 248.57,79.05 248.95,78.67 248.95,78.1 v1(248.79,77.94)
  BOTTOM w0.102: U9002.AU9 249.9,78.01 249.79,78.12 248.98,78.12 v1(248.79,77.94)
GPP_K21: length 9.3
  BOTTOM w0.102: 257.59,56.73 257.14,57.18 256.95,57.18 255.91,58.22 U9002.T45
  BOTTOM w0.114: R9255.1 259.17,51.12 258.52,51.12 257.82,51.82 R9256.2 257.82,53.1 257.46,53.46 257.46,55.97 257.69,56.2 257.69,56.63 257.59,56.73
GPS_XMIT_OFF#: length 132.3
  IN2 w0.089: v3(270.39,77.96) 270.39,77.71 271.46,76.65 271.68,76.65 272.93,75.4 274.01,75.4 275.71,73.71 276.07,73.71 277.27,72.51 278.42,72.51 282.56,68.37 282.56,67.55 283.58,66.52 285.98,66.52 291.17,61.33 292.49,61.33 293.54,60.28 296.46,60.28 297.93,58.81 302.42,58.81 302.59,58.64 306.4,58.64 307.29,59.53 313.85,59.53 315.36,58.02 317.82,58.02 321.72,54.12 322.53,54.12 322.83,53.82 323.51,53.82 323.91,53.42 323.91,51.67 323.68,51.44 323.68,49.77 322.35,48.44 322.35,31.85 325.49,28.7 326.92,28.7 327.28,28.34 329.73,28.34 330.41,29.02 334.27,29.02 336.15,27.14 338.54,27.14 338.9,27.5 v1(338.9,27.73)
  BOTTOM w0.102: U9002.BC33 260.87,71.81 261.03,71.96 261.03,72.06 261.21,72.25 261.32,72.25 262,72.93 262,73.27 262.52,73.79 262.92,73.79 263.72,74.6 264.7,74.6 264.79,74.68
  BOTTOM w0.114: v3(270.39,77.96) 269.77,77.96 269.35,77.54 R9204.1 269.24,76.82 268.74,76.82 268.65,76.74 268.65,76.74 267.06,75.15 266.49,75.15 266.13,75.5 265.61,75.5 264.79,74.68 ; v1(338.9,27.73) 339,27.63 v1(339,25.74) 339,24.73 338.36,24.09 338.36,23.64 337.76,23.04 337.76,22.07 337.37,21.68 337.37,20.77 337.06,20.46 337.06,19.42 337.14,19.34 337.14,17.92 336.91,17.69 336.91,17.23 337,17.14 CON4201.26
GPU_CLK_REQ1#: length 112.4
  IN1 w0.076: v1(251.8,93.82) 251.28,93.3 251.28,92.48 250.96,92.17 249.86,92.17 249.73,92.29 249.21,92.29 248.8,91.89 248.8,90.18 247.61,88.99 242.03,88.99 237.07,93.94 234.09,93.94 232.6,95.44 222.95,95.44 219.11,99.28 217.33,99.28 216.9,99.71 215.75,99.71 215.25,100.22 214.76,100.22 213.82,99.28 212.63,99.28 211.87,100.04 211.87,101.18 210.98,102.07 209.58,102.07 208.26,103.39 205.59,103.39 205.39,103.6 203.19,103.6 200.82,101.23 v1(200.82,100.55)
  IN3 w0.089: v3(269.52,78.83) 269.52,79.32 266.58,82.26 266.58,83.1 264.14,85.54 264.14,86.08 261.99,88.23 261.99,89.22 259.25,91.96 256.8,91.96 254.69,94.07 252.05,94.07 v1(251.8,93.82)
  BOTTOM w0.102: 263.33,75.5 262.69,75.5 262.31,75.12 262.31,74.44 261.46,73.59 261.42,73.59 260.77,72.95 U9002.BE31
  BOTTOM w0.114: Q2012.3 196.34,92.52 v1(198.41,94.58) 198.79,94.96 198.79,98.26 200.06,99.53 200.06,100.29 200.31,100.55 v1(200.82,100.55) ; 263.33,75.5 263.6,75.24 263.93,75.24 265.51,76.82 265.68,76.82 267.23,78.38 R9178.1 268.53,78.38 268.89,78.74 269.41,78.74 269.49,78.83 v3(269.52,78.83)
GPU_PEX_RST_HOLD#: length 13.6
  TOP w0.114: R2042.2 217.72,93.03 217.72,95.62 217.61,95.73 217.61,97.6 216.63,98.58 216.63,100.76 216.26,101.14 216.26,101.7 216.21,101.74 216.21,102.47 216.01,102.67 216.01,103.2 216.34,103.53 216.34,104.08 215.83,104.58 v1(215.83,104.6)
  BOTTOM w0.114: U2000.T8 v1(215.83,104.6)
GPUEVENT#: length 13.7
  TOP w0.114: v1(220.01,102.12) 219.62,101.72 219.62,99.91 220,99.53 220,97.07 220.63,96.43 220.63,95.65 R2044.2 220.76,94.51 220.76,94.07 220.55,93.87 220.55,93.33 220.62,93.27 220.62,92.58 220.58,92.54 v1(220.58,92.09) 220.9,91.77 220.9,90.92 D2003.2
  BOTTOM w0.114: v1(220.01,102.12) U2000.L6
GPUMON_ALERT_EC: length 2.3
  TOP w0.203: v1(201.33,53.05) PR9824.2 PR9811.2
  BOTTOM w0.203: PR9824.2 v1(201.33,53.05)
H_CPU_SVIDALRT#: length 15.3
  TOP w0.114: R9030.1 133.31,118.5 v1(133.31,119.9) 133.31,120.22 135.94,122.86 141.21,122.86 141.78,123.44 142.97,123.44 143.63,122.78 v1(144.11,122.78)
  BOTTOM w0.114: v1(144.11,122.78) 143.79,122.46 U9001.BH31
H_CPU_SVIDDAT: length 20.6
  TOP w0.114: v3(143.39,121.36) 143.39,122.64 142.82,123.21 141.88,123.21 141.3,122.63 136.04,122.63 133.74,120.33 133.74,117.91 R9034.2 132.37,117.57 131.73,117.57 131.48,117.31 131.48,116.52 v1(131.17,116.22) 130.87,115.91 R9036.1
  BOTTOM w0.114: U9001.BH29 143.64,121.11 v3(143.39,121.36)
H_PECI: length 3.8
  BOTTOM w0.114: U6001.M7 269.22,32.28 v1(269.02,32.48) 268.71,32.48 268,33.19 268,33.61 R6026.1
H_PM_DOWN: length 355.4
  TOP w0.114: v1(241.84,77.47) 238.19,81.12 234.95,81.12 233.01,79.18 233.01,74.09 232.41,73.49 232.41,73.17 231.42,72.18 231.42,71.12 230.43,70.13 230.43,62.41 229.88,61.86 229.88,60.15 231.26,58.78 231.26,37.85 232.36,36.75 232.36,32.35 226.75,26.74 221.15,26.74 220.77,26.74 212.24,18.2 206.25,18.2 203.71,15.65 203.71,14.64 203.44,14.37 203.44,13 v1(203.23,12.79)
  IN1 w0.076: v1(203.23,12.79) 202.98,13.04 202.98,15.54 200.41,18.11 182.34,18.11 178.28,14.05 112.02,14.05 104.64,21.43 102.79,21.43 v1(102.13,20.76) ; v1(134.69,122.21) 131.75,119.27 123.76,119.27 121.39,116.91 121.04,116.91 120.61,116.47 120.61,114.41 116.98,110.78 116.98,106.82 109.43,99.28 108.74,99.28 107.73,98.26 107.73,97.04 107.24,96.55 107.24,95.96 106.97,95.69 106.97,95.21 106.69,94.93 106.69,92.89 105.19,91.39 105.19,90.91 103.41,89.13 103.41,88.36 102.39,87.34 102.39,86.45 101.25,85.31 101.25,81.42 99.3,79.47 95.9,79.47 93.83,77.39 93.26,77.39 91.52,75.66 90.78,75.66 85.68,70.56 85.68,70.04 83.42,67.78 83.42,67.02 81.31,64.91 81.31,60.29 82.46,59.15 v1(82.46,58.89)
  BOTTOM w0.102: U9002.AE2 243.91,76.1 242.83,77.18 242.64,77.18 242.49,77.32
  BOTTOM w0.114: v1(82.46,58.89) 82.84,58.89 83.01,58.71 83.01,58.08 84.36,56.73 86.35,56.73 90.74,52.35 93.47,52.35 95.97,49.84 95.97,42.64 100.88,37.74 100.88,32.79 101.65,32.01 101.65,21.58 102.13,21.11 v1(102.13,20.76) ; 242.49,77.32 242.34,77.47 v1(241.84,77.47) ; R9012.1 v1(134.69,122.21)
H_PM_DOWN_R: length 4.8
  BOTTOM w0.114: R9012.2 138.44,122.87 138.51,122.94 139.71,122.94 U9001.BP31
H_PRDY#: length 366.3
  TOP w0.114: R9268.1 245.95,79.16 245.95,79.9 245.47,80.38 244.61,80.38 242.43,82.56 234.36,82.56 230.79,78.99 230.79,73.75 230.21,73.17 229.44,73.17 229.2,72.93 229.2,71.85 228.99,71.64 228.99,63 228.45,62.46 228.45,59.56 229.82,58.18 229.82,51.96 229.08,51.21 229.08,34.49 229.71,33.87 229.71,32.08 225.88,28.25 220.21,28.25 211.6,19.64 205.38,19.64 201.38,15.64 v1(201.38,13.88)
  IN1 w0.076: v1(87.92,64.48) 88.14,64.71 88.14,68 89.83,69.69 89.83,71.4 91.75,73.32 92.49,73.32 93.97,74.8 95.94,74.8 97.01,75.87 99.77,75.87 104.59,80.68 104.59,82.44 107.34,85.2 107.34,88.65 108.78,90.1 108.78,91.25 110.1,92.57 110.1,93.85 111.98,95.73 111.98,96.3 115.72,100.04 115.72,100.15 115.14,100.74 115.14,100.84 115.35,101.06 115.46,101.06 116.05,100.47 116.15,100.47 116.37,100.69 116.37,100.8 115.78,101.38 115.78,101.49 116,101.71 116.11,101.71 116.69,101.12 116.8,101.12 117.02,101.34 117.02,101.44 116.43,102.03 116.43,102.14 116.65,102.35 116.75,102.35 117.34,101.77 117.45,101.77 117.66,101.98 117.66,102.09 117.08,102.68 117.08,102.78 117.29,103 117.4,103 117.99,102.41 118.09,102.41 118.31,102.63 118.31,102.74 117.72,103.32 117.72,103.43 117.94,103.65 118.05,103.65 118.63,103.06 118.74,103.06 120.32,104.64 120.32,104.75 119.8,105.27 119.8,105.38 120.01,105.59 120.12,105.59 120.64,105.07 120.75,105.07 122.78,107.1 125,107.1 125.89,107.99 125.89,112.49 127.59,114.19 128.48,114.19 130.9,116.61 133.72,116.61 134.14,117.03 134.97,117.03 136.18,118.24 136.18,118.52 136.49,118.84 140.19,118.84 v1(140.39,119.04) ; v1(102.97,18.66) 103.07,18.76 104.93,18.76 112.68,11.01 177,11.01 182.8,16.82 197.68,16.82 198.66,15.84 200.43,15.84 201.17,15.1 201.17,14.09 v1(201.38,13.88)
  BOTTOM w0.114: v1(102.97,18.66) 103.71,19.41 103.71,20.74 102.3,22.16 102.3,37.55 101.98,37.87 101.98,39.42 99.77,41.64 97.9,41.64 96.62,42.91 96.62,54.38 97.19,54.95 97.19,59.6 95.02,61.78 92.91,61.78 92.36,62.32 92.36,63.46 91.62,64.2 90.2,64.2 ; 90.2,64.2 90.23,64.17 CON400.5 ; 90.2,64.2 88.2,64.2 v1(87.92,64.48) ; U9001.BP27 140.07,119.37 v1(140.39,119.04)
H_PRDY#_L: length 2.6
  TOP w0.114: R9268.2 R9271.2 246.07,77.52 v1(246.76,77.52)
  BOTTOM w0.102: U9002.AM5 246.77,77.53 v1(246.76,77.52)
H_PREQ#: length 342.4
  TOP w0.114: v1(141.71,121.42) 141.71,121.44 141.33,121.83 138.79,121.83 138.54,121.58 138.54,121.22 137.05,119.74 135.99,119.74 135.41,119.17 R9305.2
  IN1 w0.076: v1(141.71,121.42) 141.36,121.77 138.84,121.77 137.18,120.11 136.02,120.11 133.29,117.38 130.59,117.38 128.16,114.95 125.37,114.95 124.95,114.53 123.39,114.53 118.86,110 118.86,105.97 109.91,97.03 109.91,94.74 108.57,93.39 108.57,92.11 107.07,90.61 107.07,90.13 106.58,89.64 106.58,85.53 103.13,82.08 103.13,80.59 99.21,76.67 95.73,76.67 94.87,75.82 93.91,75.82 92.17,74.08 91.43,74.08 87.79,70.43 87.79,69.69 85.15,67.05 85.15,63.57 84.54,62.96 84.54,60.03 84.97,59.6 v1(85.76,59.6)
  IN2 w0.089: v1(228.02,74.72) 228.76,73.98 228.76,71.1 232.68,67.17 232.68,63.49 233.4,62.77 233.4,60.98 231.53,59.11 231.53,36.63 227.48,32.58 222.7,32.58 222,31.89 220.68,31.89 217.63,28.84 206.06,28.84 204.79,27.58 182.75,27.58 182.56,27.78 169.33,27.78 168.59,27.03 109.48,27.03 106.76,29.75 105.73,29.75 103.91,31.58 103.91,42.47 97.49,48.89 97.49,50.25 94.71,53.02 91.36,53.02 89.1,55.28 87.66,55.28 87.22,55.71 87.22,57.36 86.94,57.64 86.94,58.42 v1(85.76,59.6)
  IN3 w0.089: v1(90.2,61.3) 89.03,60.14 86.49,60.14 85.96,59.6 v1(85.76,59.6)
  BOTTOM w0.114: v1(90.2,61.3) 90.33,61.3 90.73,61.7 CON400.3 ; 239,84.52 238.28,84.52 238.06,84.29 236.21,84.29 235.35,83.43 234.73,83.43 231.93,80.63 231.33,80.63 228.98,78.28 228.98,75.96 228.02,75 v1(228.02,74.72) ; v1(141.71,121.42) 141.75,121.42 U9001.BL30
H_PREQ#_L: length 9.8
  BOTTOM w0.102: 244.87,79.33 244.87,79.73
  BOTTOM w0.114: U9002.AL2 246.01,78.19 245.84,78.36 244.87,79.33 ; R9267.2 239.78,83.73 239.78,83.4 240.14,83.05 v1(241.33,83.05) 241.69,82.69 241.69,81.96 243.03,80.61 244.21,80.61 244.87,79.95 244.87,79.73
H_TCK: length 332.9
  IN1 w0.076: v1(136.18,119.31) 135.99,119.31 133.59,116.92 130.78,116.92 128.35,114.49 125.62,114.49 125.13,114 125.13,110.03 125.58,109.58 125.58,108.12 124.89,107.42 120.95,107.42 113.43,99.9 113.43,98.18 111.68,96.43 111.68,95.86 109.02,93.2 109.02,91.92 108.48,91.37 108.48,90.22 107.03,88.78 107.03,85.33 104.27,82.57 104.27,80.8 99.67,76.2 96.9,76.2 95.81,75.1 93.84,75.1 92.36,73.62 91.62,73.62 89.53,71.53 89.53,69.81 87.51,67.79 v1(87.51,65.92)
  IN2 w0.089: v1(87.51,65.92) 87.51,63.11 88.93,61.69 88.93,56.5 91.62,53.81 95.03,53.81 98.2,50.64 98.2,49.29 104.62,42.87 104.62,31.88 106.03,30.47 107.07,30.47 109.19,28.34 141.71,28.34 142.02,28.03 168.05,28.03 168.51,28.49 182.85,28.49 182.97,28.37 204.58,28.37 205.76,29.55 217.34,29.55 220.39,32.6 221.71,32.6 222.4,33.3 227.19,33.3 230.8,36.9 230.8,59.39 232.69,61.27 232.69,62.48 231.97,63.19 231.97,66.88 227.41,71.44 227.41,72.2 v1(227.74,72.53)
  BOTTOM w0.114: v1(87.51,65.92) 81.17,65.92 80.63,65.37 77.88,65.37 77.23,64.71 CON400.57 ; v1(227.74,72.53) 228.56,72.53 229.49,73.47 229.49,74.96 230.59,76.06 230.59,78.6 231.71,79.72 232.31,79.72 235.11,82.52 235.82,82.52 236.58,83.28 237.4,83.28 238.61,82.06 238.61,81.29 R9111.2 ; R9306.2 136.14,119.34 v1(136.18,119.31) 137.11,119.31 138.38,120.58 139.06,120.58 U9001.BR28
H_TDI: length 365.6
  TOP w0.114: R9304.2 132.88,116.3 133.97,117.39 133.97,120.24 136.13,122.4 141.4,122.4 141.58,122.59 142.34,122.59 v1(142.54,122.78)
  IN1 w0.076: v1(96.32,77.2) 96.69,76.83 99.16,76.83 102.98,80.65 102.98,82.15 106.42,85.59 106.42,89.7 106.92,90.19 106.92,90.67 108.41,92.17 108.41,93.46 109.76,94.8 109.76,97.09 118.7,106.04 118.7,110.06 123.32,114.68 124.89,114.68 125.3,115.1 128.02,115.1 128.26,115.34 128.26,116.19 128.84,116.77 129.32,116.77 130.08,117.53 133.22,117.53 135.95,120.26 137.11,120.26 138.78,121.92 141.02,121.92 141.88,122.78 v1(142.54,122.78)
  IN2 w0.089: v1(227.72,73.19) 228.23,72.68 228.23,70.88 232.15,66.95 232.15,63.27 232.86,62.55 232.86,61.2 230.98,59.31 230.98,36.83 227.26,33.12 222.47,33.12 221.78,32.43 220.46,32.43 217.41,29.38 205.83,29.38 204.63,28.17 182.92,28.17 182.78,28.31 168.58,28.31 168.13,27.85 141.94,27.85 141.63,28.16 109.11,28.16 106.98,30.29 105.96,30.29 104.44,31.8 104.44,42.75 98.02,49.17 98.02,50.54 94.93,53.63 91.55,53.63 89.16,56.02 v1(87.97,56.02)
  IN4 w0.076: v1(87.97,56.02) 87.97,56.81 86.6,58.18 86.6,60.11 87.05,60.57 87.05,62.31 88.86,64.12 88.86,66.15 89.82,67.11 89.82,71.08 95.94,77.2 v1(96.32,77.2)
  BOTTOM w0.114: R9115.2 240.05,79.86 240.05,80.62 239.17,81.5 239.17,81.82 237.49,83.5 236.49,83.5 235.73,82.74 235.01,82.74 232.22,79.95 231.62,79.95 230.05,78.39 v1(230.05,77.99) 230.36,77.69 230.36,76.16 229.26,75.06 229.26,73.83 228.63,73.19 v1(227.72,73.19) ; v1(96.32,77.2) 96.55,76.97 96.55,75.98 95.11,74.54 89.58,74.54 87.45,72.4 83.67,72.4 83.09,71.82 81.21,71.82 80.69,71.31 79.12,71.31 77.73,69.91 CON400.56 ; v1(142.54,122.78) 142.47,122.78 U9001.BL32
H_TDO: length 341.5
  IN1 w0.076: v1(136.73,118.42) 136.58,118.42 135.03,116.88 134.2,116.88 133.78,116.46 130.97,116.46 128.54,114.04 127.65,114.04 126.04,112.42 126.04,107.93 125.06,106.95 122.84,106.95 112.13,96.24 112.13,95.67 110.25,93.79 110.25,92.5 108.93,91.18 108.93,90.03 107.49,88.59 107.49,85.13 104.76,82.4 104.76,80.64 99.8,75.68 97.34,75.68 v1(96.93,75.27)
  IN2 w0.089: v1(87.51,57.88) 87.58,57.81 87.58,55.86 87.81,55.63 89.3,55.63 91.53,53.41 94.91,53.41 97.84,50.47 97.84,49.1 104.26,42.68 104.26,31.73 105.88,30.11 106.91,30.11 109.03,27.99 141.56,27.99 141.87,27.68 168.2,27.68 168.66,28.13 182.7,28.13 182.88,27.95 204.66,27.95 205.91,29.2 217.49,29.2 220.53,32.25 221.86,32.25 222.55,32.94 227.34,32.94 231.15,36.76 231.15,59.24 233.04,61.13 233.04,62.63 232.33,63.34 232.33,67.03 228.4,70.95 228.4,73.45 v1(228.12,73.73)
  IN4 w0.076: v1(96.93,75.27) 94.27,75.27 89.97,70.98 89.97,67.05 89.01,66.08 89.01,64.05 87.28,62.32 87.28,60.42 86.75,59.88 86.75,58.64 v1(87.51,57.88)
  BOTTOM w0.114: v1(228.12,73.73) 228.53,73.73 229.03,74.23 229.03,75.15 229.44,75.56 229.44,78.09 231.52,80.18 232.12,80.18 234.92,82.97 235.58,82.97 236.4,83.8 237.63,83.8 R9114.2 ; v1(96.93,75.27) 95.74,74.08 89.77,74.08 87.64,71.95 83.86,71.95 83.28,71.36 81.4,71.36 80.88,70.85 79.4,70.85 78.73,70.18 CON400.52 ; U9001.BT28 138.53,120.22 v1(136.73,118.42) 136.51,118.2 R9302.1
H_TMS: length 354.3
  TOP w0.114: R9303.2 135.28,114.01 135.72,114.01 136.25,114.54 136.25,117.55 136.69,117.99 138.21,117.99 138.44,118.21 138.44,118.72 139.54,119.83 v1(139.74,119.83)
  IN1 w0.076: v1(87.05,64.55) 87.05,65.22 86.9,65.37 86.9,67.95 88.75,69.8 88.75,70.97 91.56,73.78 92.3,73.78 94.04,75.51 95.48,75.51 v1(95.61,75.65) 95.61,75.63 96.33,76.35 99.61,76.35 104.12,80.87 104.12,82.64 106.88,85.4 106.88,88.84 108.32,90.29 108.32,91.44 108.87,91.98 108.87,93.27 110.22,94.61 110.22,96.9 120.88,107.57 124.82,107.57 125.43,108.18 125.43,109.51 124.97,109.97 124.97,114.06 125.56,114.64 128.29,114.64 130.71,117.07 133.41,117.07 136.04,119.7 139.61,119.7 v1(139.74,119.83)
  IN2 w0.089: v1(227.67,74.18) 228.21,74.18 228.58,73.82 228.58,71.02 232.51,67.1 232.51,63.41 233.22,62.7 233.22,61.05 231.35,59.18 231.35,36.7 227.41,32.76 222.62,32.76 221.93,32.07 220.61,32.07 217.56,29.02 205.98,29.02 204.72,27.76 182.83,27.76 182.63,27.95 168.73,27.95 168.27,27.5 141.8,27.5 141.49,27.81 108.96,27.81 106.84,29.93 105.81,29.93 104.08,31.66 104.08,42.6 97.66,49.02 97.66,50.35 94.81,53.2 91.43,53.2 89.17,55.46 87.73,55.46 87.4,55.79 87.4,57.44 87.12,57.72 87.12,58.23 87.66,58.76 87.66,59.96 87.18,60.44 87.18,64.42 v1(87.05,64.55)
  BOTTOM w0.114: U9001.BP28 140.07,120.15 v1(139.74,119.83) ; R9112.2 238.01,84.06 236.3,84.06 235.45,83.2 234.82,83.2 232.03,80.41 231.43,80.41 229.21,78.19 229.21,75.65 228.81,75.25 228.81,74.64 228.35,74.18 v1(227.67,74.18) ; v1(95.61,75.65) 94.73,74.77 89.49,74.77 87.35,72.63 83.58,72.63 82.99,72.05 81.11,72.05 80.65,71.59 79.03,71.59 77.23,69.79 CON400.58
H_TRST#: length 350.7
  IN1 w0.076: v1(96.96,77.2) 97.5,77.74 99.85,77.74 102.83,80.72 102.83,82.21 105.52,84.9 105.52,89.01 106.76,90.26 106.76,90.74 108.26,92.24 108.26,93.52 109.61,94.87 109.61,97.16 118.55,106.1 118.55,110.13 123.26,114.84 124.82,114.84 125.06,115.08 125.06,116.33 125.65,116.92 129.25,116.92 130.03,117.7 133.18,117.7 136.57,121.09 v1(136.94,121.09)
  IN2 w0.089: v1(227.64,75.22) 228.06,75.22 228.94,74.35 228.94,71.17 232.86,67.25 232.86,63.56 233.57,62.85 233.57,60.91 231.78,59.11 231.78,55.56 232.59,54.75 232.98,54.75 233.33,54.4 233.33,38.7 233.08,38.44 232.06,38.44 231.8,38.18 231.8,36.65 227.56,32.41 222.77,32.41 222.08,31.71 220.75,31.71 217.71,28.67 206.13,28.67 204.82,27.36 182.73,27.36 182.48,27.6 169.4,27.6 168.66,26.86 109.41,26.86 106.69,29.58 105.66,29.58 103.73,31.51 103.73,42.4 97.31,48.82 97.31,50.17 94.66,52.82 91.31,52.82 89.03,55.1 87.59,55.1 87.05,55.64 87.05,57.13 86.3,57.88 v1(86.18,57.88)
  IN4 w0.076: v1(96.96,77.2) 96.57,77.59 95.99,77.59 89.67,71.26 89.67,67.17 88.71,66.21 88.71,64.18 86.18,61.65 v1(86.18,57.88)
  BOTTOM w0.114: v1(227.64,75.22) 227.92,75.22 228.75,76.06 228.75,78.38 231.24,80.86 231.84,80.86 234.92,83.94 235.54,83.94 236.55,84.95 R9269.1 ; CON400.54 78.23,70.02 79.29,71.08 80.79,71.08 81.3,71.59 83.18,71.59 83.77,72.18 87.54,72.18 89.68,74.31 95.21,74.31 96.93,76.04 96.93,77.18 v1(96.96,77.2) ; R9307.2 v1(136.94,121.09) 136.94,121.12 137.35,121.53 137.35,121.97 137.61,122.22 139.64,122.22 U9001.BP30
H_TRST#_L: length 14
  BOTTOM w0.114: U9002.AM4 246.66,78.01 246.15,78.51 245.99,78.51 245.11,79.4 245.11,80.02 244.03,81.1 R9272.2 243.39,81.86 241.61,83.64 241.21,83.64 240.95,83.38 240.44,83.38 240.21,83.61 240.21,84.32 239.5,85.03 238.89,85.03 v1(238.64,85.28) 238.49,85.28 238.16,84.95 R9269.2
H_VCCST_PWRGD: length 10.8
  TOP w0.114: Q9002.6 189.75,94.05 189.64,94.16 R9309.1 188.28,94.16 184.69,97.74 184.69,100.04 v1(184.36,100.37)
  BOTTOM w0.114: v1(184.36,100.37) 184.36,100.59 R9340.2
HD_SDIN0: length 3.9
  TOP w0.114: U3600.60 343.57,13.08 343.74,13.25 343.74,14.72 v1(344.28,15.25) 344.84,15.81 R3605.2
HDA_SPKR: length 145.3
  TOP w0.114: R9127.2 258.35,73.82 258.78,73.38 258.78,73.03 258.41,72.66 v1(258.41,72.14) ; v1(321.75,39.19) 322.92,38.02 322.92,25.11 v1(322.82,25.01) 322.82,24.42 323.12,24.12 323.12,21.05 323.78,20.39 v1(323.78,19.45) ; v1(349.28,10.54) 349.66,10.16 R17956.1 351.17,9.38 R3630.2
  IN1 w0.076: v1(321.75,39.19) 320.42,40.52 313.98,40.52 309.47,45.02 308.21,45.02 307.96,44.77 307.96,43.9 307.37,43.32 307.09,43.32 306.58,42.81 300.77,42.81 300.35,43.23 296.23,43.23 295.51,43.96 289.11,43.96 287.79,45.28 284.74,45.28 282.02,48 279.57,48 278.48,49.09 277.83,49.09 275.98,50.94 274.46,50.94 271,54.4 270.05,54.4 268.69,55.75 268.69,57.54 267.8,58.43 266.3,58.43 265.21,59.53 265.21,62.04 263.46,63.79 263.46,65.69 262.76,66.38 262.49,66.38 261.87,67.01 261.87,67.28 261.47,67.68 259.85,67.68 258.1,69.43 258.1,70.14 257.72,70.53 257.72,71.03 258.41,71.73 v1(258.41,72.14)
  IN3 w0.089: v1(349.28,10.54) 349.28,11.65 348.13,12.8 348.13,16.99 346.86,18.26 344.2,18.26 341.61,20.84 336,20.84 335.24,20.08 331.65,20.08 331.17,20.56 325.81,20.56 325.03,19.78 324.11,19.78 v1(323.78,19.45)
  BOTTOM w0.114: v1(258.41,72.14) 258.38,72.11 258.38,71.62 U9002.AW29
HDACCEL_CLK: length 110.3
  TOP w0.114: Q9032.6 192.63,19.81 192.34,19.51 v1(192.34,19.41) ; v3(267.59,26.62) 267.99,27.01 268.38,27.01 268.87,26.53 268.87,23.69 268.64,23.46 268.64,22.14 268.13,21.63 268.13,19.45 v1(269.32,18.26) 269.58,18 R6412.2
  IN2 w0.089: v1(269.32,18.26) 269.09,18.03 269.09,17.69 268.69,17.29 268.69,15.53 269.53,14.7 269.53,10.63 268,9.11 268,6.87 266.98,5.84 266.87,5.74 262.12,5.74 261.55,6.31 251.96,6.31 250.69,5.03 243.86,5.03 242.29,6.6 239.85,6.6 238.98,5.73 236.58,5.73 236.3,6.01 236.3,6.64 235.04,7.91 226.72,7.91 225.04,9.58 210.8,9.58 210.06,10.33 208.74,10.33 207.88,11.19 207.88,11.8 v1(207.59,12.09)
  BOTTOM w0.114: v1(207.59,12.09) 207.39,12.29 207.11,12.29 206.4,13 206.4,13.85 201.61,18.63 193.11,18.63 v1(192.34,19.41) ; U6001.F5 v3(267.59,26.62)
HDACCEL_DAT: length 108.3
  TOP w0.114: v1(195.1,19.7) 195.23,19.83 195.23,21.3 194.96,21.57 Q9032.3 ; R6413.2 269.7,17.24 v1(268.68,18.26) 268.68,18.56 267.89,19.36 267.89,21.72 268.41,22.24 268.41,23.55 268.64,23.78 268.64,26.41 268.42,26.62 v3(268.24,26.62)
  IN2 w0.089: v1(208.22,12.07) 208.06,11.9 208.06,11.26 208.81,10.5 210.13,10.5 210.87,9.76 225.12,9.76 226.79,8.09 235.59,8.09 237.76,5.91 238.91,5.91 239.78,6.78 242.36,6.78 243.93,5.21 250.61,5.21 251.89,6.49 261.62,6.49 262.2,5.91 266.8,5.91 267.82,6.94 267.82,9.18 269.35,10.71 269.35,14.62 268.51,15.46 268.51,17.36 268.92,17.77 268.92,18.02 v1(268.68,18.26)
  BOTTOM w0.114: U6001.F6 v3(268.24,26.62) ; v1(195.1,19.7) 195.86,18.95 201.62,18.95 206.63,13.94 206.63,13.1 206.88,12.85 206.89,12.85 207.22,12.52 207.77,12.52 v1(208.22,12.07)
HDD_HALTLED#: length 102.4
  TOP w0.114: v1(318.62,39.87) 318.34,40.16 R9627.1
  IN2 w0.089: v1(318.62,39.87) 319.34,40.59 319.34,48.51 321.49,50.66 321.49,50.94 322.26,51.7 322.26,53.02 321.95,53.33 321.42,53.33 320.91,52.82 318.85,52.82 317.96,53.71 317.33,53.71 317.14,53.53 316.61,53.53 316.51,53.63 315.63,53.63 315.49,53.77 310.25,53.77 309.93,53.45 301.48,53.45 300.48,54.46 298.05,56.89 292.06,56.89 290,58.95 290,59.15 286.28,62.87 281.96,62.87 280.78,64.05 280.78,64.95 280.09,65.64 280.09,67.19 277.13,70.15 274.9,70.15 274.48,70.58 273.84,70.58 271.63,72.79 271.13,72.79 267.09,76.82 266.56,76.82 263.2,80.19 263.2,80.66 260.87,82.99 260.87,83 260.85,83.02 v3(259.26,83.02)
  BOTTOM w0.102: U9002.BE20 257,76.89 257.37,77.26 257.37,77.44 258.3,78.38 258.3,80.34 258.65,80.68 259.19,80.68 v1(259.75,81.24) 259.75,81.73 259.26,82.21 v3(259.26,83.02) 259.26,83.28 259.57,83.58
HDMI_HPD: length 149.6
  TOP w0.114: v1(249.96,77.24) 250.27,76.93 250.27,76.67 ; v3(355,54.47) 355.53,53.94 358.15,53.94 R18099.2
  IN3 w0.089: v3(355,54.47) 354.64,54.11 354.64,46.46 353.7,45.53 348.04,45.53 v1(347.25,46.32)
  IN4 w0.076: v1(249.96,77.24) 251.75,75.45 251.75,74.13 252.25,73.62 252.25,73.12 252,72.86 252,71.08 251.6,70.68 251.6,69.16 257.56,63.2 257.87,63.2 258.92,62.15 258.92,61.44 259.68,60.68 260.39,60.68 260.76,60.31 260.76,59.53 261.58,58.71 262.21,58.71 265.08,55.84 265.72,55.84 266.17,55.39 271.29,55.39 272.3,54.37 276.32,54.37 277.67,53.02 278,53.02 278.19,52.83 279.71,52.83 280.07,52.47 280.33,52.47 287.51,52.47 288.3,51.68 290.61,51.68 291.65,50.64 292.77,50.64 292.89,50.51 293.53,50.51 295.09,52.07 299.08,52.07 299.45,51.7 301.73,51.7 302.32,51.12 305.72,51.12 306.95,49.89 308.07,49.89 308.21,50.03 317.25,50.03 317.66,49.62 320.45,49.62 322.03,48.05 322.03,47.69 320.81,46.47 319.92,46.47 319.21,45.76 319.21,45.24 319.63,44.82 322.61,44.82 324.34,46.55 324.34,48.6 324.57,48.83 326.93,48.83 327.63,48.14 328.75,48.14 330.14,46.74 333.92,46.74 334.57,46.09 337.38,46.09 337.87,46.59 338.86,46.59 339.5,45.94 346.87,45.94 v1(347.25,46.32)
  BOTTOM w0.114: 249.44,76.98 249.65,76.98 249.9,77.24 v1(249.96,77.24)
HDMI_HPD_R: length 2.4
  TOP w0.114: R18099.1 v3(359.32,54.95)
  BOTTOM w0.114: R18089.1 v3(359.32,54.95) 359.3,54.97 U12006.40
HDMI_SCL_R: length 144.4
  IN1 w0.076: v1(249.06,76.32) 249.17,76.32 251.11,74.39 252.13,74.39 254.16,72.35 255.18,72.35 255.81,71.72 255.81,71.08 255.56,70.83 255.56,69.55 256.65,68.46 256.81,68.46 257.74,67.53 257.98,67.53 259.51,66 260.14,66 260.92,65.22 261.02,65.22 261.25,64.99 261.25,64.2 262.27,63.17 262.27,61.57 262.87,60.97 262.87,59.39 263.68,58.58 263.68,56.44 264.28,55.84 265.67,55.84 272.93,48.58 275.79,48.58 278.56,45.81 279.95,45.81 281.45,44.3 283.69,44.3 284.11,43.88 287.16,43.88 288.61,42.43 294.74,42.43 295.53,41.65 298.1,41.65 298.57,41.18 306.46,41.18 306.85,40.78 310.5,40.78 312.91,38.37 319.82,38.37 320.3,37.89 330.41,37.89 332.24,36.06 v1(333.03,36.06) 333.51,36.54 333.84,36.54 334.5,37.19 334.5,37.6 335.6,38.7 336.2,38.7 336.46,38.95 336.46,44.93 339.88,48.35 340.61,48.35 342.21,49.96 342.21,50.53 v1(344.84,53.15)
  BOTTOM w0.114: v1(249.06,76.32) 248.78,76.32 U9002.AL9 ; v1(344.84,53.15) 344.84,55.22 343.81,56.25 343.81,58.51 346.66,61.35 348.09,61.35 348.52,61.78 348.52,62.96 348.65,63.08 R9242.1 349.16,62.07
HDMI_SCL_R_R: length 3
  BOTTOM w0.114: Q9047.6 349.16,60.54 349.26,60.65 351.19,60.65 R18101.2
HDMI_SDA_R: length 144.4
  IN1 w0.076: v1(346.74,59.65) 346.74,60.8 346.62,60.92 346.36,60.92 346.23,60.8 346.23,59.44 346.13,59.34 345.79,59.34 345.73,59.4 345.73,60.67 345.6,60.8 345.35,60.8 345.22,60.67 345.22,59.53 345.03,59.34 339.93,59.34 339.62,59.65 334.82,59.65 334.58,59.9 332.45,59.9 332.06,59.5 329.65,59.5 328.61,60.54 318.04,60.54 316.9,61.69 315.65,61.69 314.43,60.46 310.61,60.46 310.53,60.54 305.14,60.54 304.07,59.48 297.84,59.48 296.95,60.37 293.49,60.37 292.42,61.43 291.2,61.43 286.32,66.32 283.64,66.32 281.28,68.67 280.47,68.67 276.17,72.98 275.18,72.98 273.37,74.79 271.56,74.79 271.25,75.1 271.25,76.07 270.06,77.26 269.96,77.26 260.18,87.04 260.05,87.04 259.16,87.92 259.16,89.09 258.05,90.21 253.88,90.21 252.3,91.78 250.49,91.78 250.12,91.42 249.82,91.42 249.45,91.78 v1(249.33,91.78)
  BOTTOM w0.114: Q9047.4 350.45,59.3 350.2,59.04 347.35,59.04 v1(346.74,59.65) ; U9002.AR3 247.36,79.38 245.86,80.89 245.86,81.11 245.62,81.35 245.57,81.35 244.36,82.57 R9243.1 243.85,83.17 242.98,84.04 242.68,84.04 242.22,84.5 242.22,85.31 v1(242.35,85.43) 244.76,87.85 246.44,87.85 249.08,90.49 249.08,91.53 v1(249.33,91.78)
HDMI_SDA_R_R: length 3
  BOTTOM w0.114: 350.45,62.07 350.81,62.07 351.02,61.86 351.95,61.86 352.08,61.98 352.08,62.19 351.95,62.32 351.7,62.32 351.55,62.47 R18100.2
HDMI_UP_CLK: length 50.8
  TOP w0.114: v1(359.82,85.18) 359.32,85.69 358.43,85.69 R3200.2
  IN3 w0.089: CON3200.15 360.37,93.06 360.37,91.29 358.81,89.73 358.81,86.16 359.28,85.69 359.32,85.69 v1(359.82,85.18) 359.96,85.05 359.96,69.32 360.73,67.78 360.73,65.97 362.08,64.61 362.08,63.26 361,62.18 355.58,62.18 354.1,60.7 354.1,59.52 v1(354.48,59.14)
  BOTTOM w0.114: R18101.1 352.1,60.06 352.1,59.88 352.3,59.68 352.48,59.68 352.58,59.78 353.14,59.78 353.35,59.98 R18090.1 353.64,60.29 353.76,60.16 353.85,60.07 353.85,59.02 354,58.88 354.36,58.88 354.48,59 v1(354.48,59.14) 354.66,58.96 U12006.7
HDMI_UP_DATA: length 48.6
  TOP w0.114: R3203.2 358.68,86.83 v1(359.32,86.2)
  IN3 w0.089: CON3200.16 360.71,92.58 360.71,91.15 359.15,89.59 359.15,86.36 v1(359.32,86.2) 359.82,85.69 359.91,85.69 360.3,85.3 360.3,69.46 361.21,68.55 361.21,65.97 362.43,64.76 362.43,63.12 361.14,61.84 356.71,61.84 354.65,59.78 v1(354.49,59.78)
  BOTTOM w0.114: U12006.8 354.91,59.36 v1(354.49,59.78) 354.49,59.96 353.85,60.59 353.85,62.57 353.6,62.83 R18088.1 R18100.1
HOOK2: length 11.3
  IN2 w0.089: v1(87.15,59.1) 86.09,60.16 81.28,60.16 v1(80.27,61.18)
  BOTTOM w0.114: R400.2 87.75,59.1 v1(87.15,59.1) ; R407.2 80.5,60.55 80.27,60.78 v1(80.27,61.18) 80.23,61.22 CON400.45
HOOK3: length 263.9
  TOP w0.114: v1(268.69,38.75) 268.69,41.04 268.36,41.36 268.36,45.48 267.54,46.29 267.54,48.27 267.88,48.6 268.76,48.6 272.18,45.19 272.18,44.3 272.96,43.52 274.49,43.52 275.25,44.29 275.25,48.5 273.82,49.92 273.82,53.32 271.79,55.36 269.9,55.36 R409.1 269.09,55.17 268.67,55.58 R408.1
  IN3 w0.089: v1(100.21,27.89) 102.64,25.47 112.05,25.47 116.35,21.17 148.37,21.17 148.59,20.95 159.19,20.95 160.23,21.99 178.77,21.99 180.7,23.92 187.08,23.92 187.66,24.5 190.4,24.5 190.94,25.04 212.18,25.04 214.41,27.27 232.54,27.27 238.54,33.27 241.32,33.27 244.68,36.63 246.81,36.63 248.2,38.03 256.23,38.03 256.6,37.66 258.18,37.66 260.44,39.92 261.86,39.92 262.26,39.52 268.25,39.52 268.69,39.08 v1(268.69,38.75)
  BOTTOM w0.114: v1(100.21,27.89) 99.34,28.76 99.34,37.05 92.86,43.52 92.86,46.67 89.28,50.26 83.83,50.26 79.79,54.29 79.79,59.66 79.54,59.91 C400.2 79.54,60.7 79.84,60.99 79.84,61.55 79.73,61.66 CON400.47
HP_EAPD: length 35.8
  TOP w0.114: v1(335.19,20.69) 335.08,20.59 335.08,19.32 334.08,18.31 D3600.3 333.16,15.94 R3620.1 333.17,14.74 R3619.1 334.59,14.74 334.75,14.58 334.75,13.92 334.91,13.76 336.17,13.76 336.59,13.35 336.75,13.35 336.83,13.43 U3600.15 ; R3638.1 v1(352.97,28.92)
  IN1 w0.076: v1(352.97,28.92) 352.4,29.49 347.94,29.49 346.08,27.62 344.23,27.62 343.87,27.98 341.99,27.98 341.28,27.27 339.74,27.27 337.47,25 337.47,23.09 335.19,20.8 v1(335.19,20.69)
HPOUT_DET: length 33.8
  TOP w0.203: Q3603.2 356.81,15.88 354.55,13.62 354.55,10.16 354.7,10.01 354.7,8.73 354.78,8.65 354.78,8.25 354.44,7.91 R3683.1 353.81,7.83 354.79,6.85 354.79,6.13 VC3603.1 ; VC3603.1 355.24,4.91 354.9,4.56 351.21,4.56 350.36,3.71 Q3606.2 348.5,2.38 v1(348.32,2.38) 348.27,2.33 344.99,2.33 343.91,3.41 Q3600.2 343.91,4.03 343.99,4.11 R3603.1 ; VC3603.1 356.54,4.91 357.28,4.17 CON3601.6
HPOUT_L: length 41.2
  TOP w0.203: U3600.33 337.63,5.71 337.81,5.53
  TOP w0.254: C3634.2 v1(357.16,20.16) ; 337.81,5.53 337.81,4.38 v1(337.9,4.28)
  IN1 w0.254: v1(337.9,4.28) 337.9,3.34 339.02,2.22 341.47,2.22 342.89,3.65 344.23,3.65 345.08,2.79 354.34,2.79 356.5,4.95 356.5,6.81 357.16,7.47 357.16,12.82 358.02,13.68 358.02,19.29 v1(357.16,20.16)
HPOUT_L1: length 1.9
  TOP w0.254: R3641.1 L3605.1 355.07,10.43 v1(355.02,10.48)
HPOUT_R: length 42.3
  TOP w0.203: U3600.34 338.03,5.86 338.21,5.69
  TOP w0.254: v1(338.61,4.52) 338.21,4.92 338.21,5.69 ; v1(357.16,23.59) 356.66,23.59 C3638.2
  IN1 w0.254: v1(338.61,4.52) 339.12,4.52 340.75,2.88 341.23,2.88 342.63,4.28 344.53,4.28 345.39,3.43 354.07,3.43 355.55,4.9 355.55,6.76 356.5,7.7 356.5,13.05 357.38,13.94 357.38,18.91 356.5,19.8 356.5,22.93 v1(357.16,23.59)
HPOUT_R1: length 1.9
  TOP w0.114: R3642.1 v1(351.58,3)
  TOP w0.254: L3606.1 R3642.1
I2C_C1_CLK: length 304.6
  TOP w0.114: R6351.1 104.19,6.12 104.58,5.73 v1(104.65,5.73)
  IN3 w0.089: v1(283.6,23.99) 283.6,23.46 282.38,22.25 278.35,22.25 277.15,21.05 277.15,14.57 271.94,9.36 261.83,9.36 260.84,10.35 v1(259.75,10.35)
  IN4 w0.076: v1(104.65,5.73) 105.54,6.62 111.47,6.62 112.92,5.17 179.74,5.17 182.11,7.55 182.11,10.71 187.24,15.84 202.29,15.84 202.86,15.27 202.86,11.61 206.88,7.6 215.78,7.6 217.5,5.88 233.84,5.88 234.94,4.79 238.39,4.79 239.59,6 240.66,6 241.07,6.4 241.51,6.4 242.74,5.17 248.39,5.17 249.99,6.77 256.14,6.77 259.72,10.35 v1(259.75,10.35) ; v3(262.06,86.83) 262.06,85.72 266.05,81.74 266.05,80.92 271.19,75.78 272.02,75.78 272.6,75.2 273.18,75.2 275.46,72.92 276.17,72.92 276.42,72.67 278.3,72.67 280.33,70.64 v1(281.08,70.64)
  BOTTOM w0.089: 257.84,77.16 257.59,76.9 257.59,76.63 U9002.BE21
  BOTTOM w0.102: 259.46,80.23 259.36,80.13 259.19,80.13 258.79,79.73 258.79,78.29 257.84,77.34 257.84,77.16
  BOTTOM w0.114: v1(281.08,70.64) 281.46,70.27 281.46,67.96 284.15,65.26 285.73,65.26 289.1,61.89 289.1,59.6 289.1,59.6 289.1,58.74 289.1,58.74 289.1,58.18 288.95,58.03 288.95,57.37 288.43,56.86 288.43,56.59 286.67,54.83 286.29,54.83 284.46,53 284.46,51.06 284.76,50.76 284.76,44.42 285.13,44.05 285.13,42.55 284.72,42.13 284.72,40.01 284.97,39.75 284.97,38.2 287.22,35.95 287.22,34.56 287.95,33.83 287.95,30.58 287.56,30.19 287.56,28.48 286.41,27.34 286.41,26.4 284.01,23.99 v1(283.6,23.99) ; 259.46,80.23 260.26,81.02 260.26,81.65 260.64,82.03 260.64,83.23 261.43,84.02 261.43,84.51 261.32,84.62 261.32,86.1 v3(262.06,86.83) ; v1(259.75,10.35) 259.45,10.06 R9506.2
I2C_C1_DATA: length 305.7
  TOP w0.114: R6355.1 102.9,6.32 103.42,6.84 104.18,6.84 v1(104.65,6.36)
  IN3 w0.089: v1(285.66,25.02) 285.66,24.89 282.67,21.9 278.49,21.9 277.49,20.9 277.49,14.28 272.12,8.92 261.7,8.92 261.39,9.23 259.85,9.23 v1(258.4,10.68)
  IN4 w0.076: v3(262.45,86.45) 262.45,85.8 266.38,81.87 266.38,81.06 271.32,76.11 272.15,76.11 272.64,75.63 273.22,75.63 275.6,73.25 276.31,73.25 276.55,73 278.44,73 280.32,71.12 v1(280.63,71.12) ; v1(104.65,6.36) 105.24,6.95 111.75,6.95 113.1,5.6 179.56,5.6 181.68,7.72 181.68,10.89 187.06,16.27 202.64,16.27 204.43,14.49 204.43,10.66 207.06,8.03 215.82,8.03 217.64,6.21 233.98,6.21 235.07,5.12 238.25,5.12 239.46,6.33 240.52,6.33 240.93,6.73 241.65,6.73 242.78,5.6 246.46,5.6 247,6.14 248.85,6.14 249.82,7.1 255.45,7.1 258.4,10.05 v1(258.4,10.68)
  BOTTOM w0.102: 259.45,79.25 259.43,79.24 259.21,79.24 259.04,79.06 259.04,78.25 258.05,77.26 258.05,77.05 U9002.BF21
  BOTTOM w0.114: R9505.2 258.1,10.38 v1(258.4,10.68) ; v1(280.63,71.12) 281.31,71.12 281.83,70.61 281.83,68.11 284.31,65.63 285.88,65.63 289.47,62.04 289.47,59.64 289.47,59.63 289.47,58.71 289.47,58.7 289.47,58 289.32,57.85 289.32,57.22 288.8,56.7 288.8,56.34 287.7,55.24 286.9,54.43 286.9,54.12 286.9,53.79 285.83,52.72 285.63,52.72 284.88,51.97 284.88,51.16 285.13,50.92 285.13,44.57 285.63,44.07 285.63,38.06 286.26,37.43 287.59,36.1 287.59,34.71 288.32,33.98 288.32,30.4 287.94,30.03 287.94,28.34 286.88,27.28 286.88,26.24 v1(285.66,25.02) ; 259.45,79.25 259.67,79.47 259.67,80.1 260.51,80.94 260.51,81.57 260.86,81.93 260.86,83.12 261.75,84.01 261.75,85.75 v3(262.45,86.45)
I2C_CLICK_SCL: length 7.7
  TOP w0.114: v1(105.98,4.66) 105.92,4.61 R9232.2 C6352.1 104.35,4.32 104.35,4.91 R6351.2
  BOTTOM w0.114: CON6351.2 107.98,6.13 106.51,4.66 v1(105.98,4.66)
I2C_CLICK_SDA: length 9.1
  TOP w0.114: R6355.2 C6354.1 R9234.2 103.92,3.9 103.82,4 103.82,4.46 103.77,4.51 v1(103.77,4.54)
  BOTTOM w0.114: v1(103.77,4.54) 103.91,4.54 104.05,4.4 104.57,4.4 105.1,4.4 105.78,5.09 106.41,5.09 107.48,6.15 CON6351.3
I2C_DREAM_CL_SCL: length 11.4
  TOP w0.114: U6004.3 238.41,5.3 238.59,5.12 v1(238.92,5.12) 239.35,5.12 239.76,4.71 v1(240.21,4.71) 240.55,4.38 R9514.2
  BOTTOM w0.114: CON10002.5 244.83,7.48 244.43,7.08 244.43,5.15 243.64,4.36 240.57,4.36 v1(240.21,4.71)
I2C_DREAM_CL_SDA: length 11.2
  TOP w0.114: v1(240.22,4.08) 239.92,4.38 R9513.2 238.82,4.38 238.26,4.95 U6004.2
  BOTTOM w0.114: CON10002.4 245.33,5.36 244.08,4.1 240.24,4.1 v1(240.22,4.08)
I2C_DREAM_INT#: length 132.4
  TOP w0.114: v1(265.81,76.41) 265.81,76.39 R9351.1 ; v1(290.3,58.08) 290.3,57.43 288.54,55.67 288.54,51.52 287.07,50.05 281.99,50.05 276.48,44.54 276.48,43 275.39,41.91 273.81,41.91 271.05,44.67 271.05,45.81 268.64,48.22 268.13,48.22 267.88,47.97 267.88,46.7 v1(269.48,45.1) v1(269.48,41.67)
  IN2 w0.089: v1(245.93,6.95) 246.37,7.39 250.22,7.39 250.47,7.64 251.18,7.64 252.25,8.71 252.25,15.49 252.38,15.62 252.38,16.19 251.92,16.65 251.31,16.65 250.96,17.01 250.96,18.65 252.92,20.61 252.92,23.17 252.25,23.84 252.25,26.76 253.07,27.57 253.07,29.73 254.34,31 255.4,31 256.88,32.48 258.35,32.48 258.73,32.86 261.3,32.86 262.55,34.12 263.08,34.12 263.68,34.71 263.68,34.98 264.35,35.66 265.13,35.66 265.64,36.17 266.02,36.17 266.36,36.51 266.36,37.49 267.55,38.67 268.02,38.67 268.35,39.01 268.35,40.19 269.48,41.32 v1(269.48,41.67) ; v1(290.3,58.08) 288.53,59.86 288.53,60.35 286.19,62.69 281.88,62.69 280.56,64.02 280.56,64.92 279.89,65.59 279.89,66.95 279.53,67.3 278.42,68.42 277.72,69.12 276.04,69.12 275.56,69.6 275.17,69.6 274.38,70.4 273.76,70.4 271.55,72.61 271.06,72.61 267.07,76.6 266.02,76.6 265.84,76.41 v1(265.81,76.41)
  BOTTOM w0.114: v1(245.93,6.95) 245.83,7.04 CON10002.3
I2C_NXP_SCL_L: length 313.2
  TOP w0.114: v1(341.28,17.47) 340.77,16.96 R3612.1 ; v1(187.41,42) 188.07,41.34 188.07,41.16 v1(188.99,40.24) 190.14,39.09 190.14,27.47 191.69,25.92 196.24,25.92 198.55,23.61 198.55,17.34 197.93,16.73 197.93,14.25 201.22,10.96 204.17,10.96 208.44,6.69 v1(210.27,6.69) ; Q9042.3 193.98,151.69 193.21,150.93 192.98,150.93 192.31,150.26 v1(192.31,149.95)
  IN2 w0.089: v1(192.31,149.95) 193.15,149.11 193.15,132.88 195,131.03 195,130.18 194.71,129.9 194.71,119.23 193.61,118.13 193.61,103.83 192.51,102.72 192.51,97.56 191.44,96.5 191.44,95.46 188.6,92.61 188.6,90.66 186.07,88.14 186.07,85.38 184.59,83.91 184.59,71.08 187.33,68.35 187.33,60.8 187.87,60.25 187.87,59.87 187.64,59.64 187.64,57.53 187.92,57.24 187.92,53.82 187.53,53.43 187.53,50.31 187.92,49.93 187.92,46.49 187.58,46.15 187.52,46.09 187.52,45.39 186.95,44.82 186.95,42.46 v1(187.41,42)
  IN3 w0.089: v1(210.27,6.69) 210.73,6.24 234.68,6.24 235.62,5.3 238.16,5.3 239.39,6.53 241.98,6.53 243.61,4.89 250.09,4.89 250.84,5.64 253.23,5.64 253.82,5.05 261.67,5.05 262.35,5.73 265.51,5.73 266.1,5.15 296.4,5.15 299.38,8.13 313.94,8.13 317.21,11.41 324.44,11.41 325.19,12.15 327.81,12.15 328.33,12.66 328.33,14.44 329.22,15.33 332.65,15.33 334.04,13.93 338.98,13.93 339.63,14.58 339.63,15.82 v1(341.28,17.47)
I2C_NXP_SCL_L_AUDIO: length 2.1
  TOP w0.114: U3600.6 340.43,14.64 340.7,14.9 v1(340.7,15.08) 340.7,15.16 340.77,15.24 R3612.2
I2C_NXP_SDA_L: length 318
  TOP w0.114: v1(340.08,14.93) 340.03,14.88 U3600.7 ; v1(187.41,37.56) 187.81,37.15 187.81,26.7 190.96,23.55 190.96,23.31 191.22,23.05 196.17,23.05 196.51,22.72 196.51,18.19 195.82,17.5 195.82,13.48 198.85,10.44 v1(198.85,9.72) ; v1(194.09,153.63) 194.42,153.96 194.42,155.13 194.29,155.26 192.82,155.26 192.68,155.12 Q9042.6
  IN2 w0.089: v1(187.41,37.56) 187.25,37.56 185.9,38.91 185.9,45.27 186.3,45.67 186.3,67.72 182.84,71.19 182.84,87.19 184.17,88.53 185.01,88.53 187.57,91.08 187.57,93.04 190.41,95.89 190.41,96.97 191.35,97.91 191.35,103.02 192.58,104.26 192.58,119.1 193.68,120.2 193.68,129.17 193.2,129.66 193.2,131.37 192,132.57 192,140.83 191.17,141.66 191.17,149.43 192.57,150.84 192.57,151.61 192.82,151.86 192.82,152.36 v1(194.09,153.63)
  IN3 w0.089: v1(340.08,14.93) 340.08,14.55 339.12,13.59 333.9,13.59 332.5,14.99 329.36,14.99 328.67,14.3 328.67,12.52 327.95,11.81 325.33,11.81 324.59,11.06 317.5,11.06 314.22,7.79 299.6,7.79 296.52,4.71 253.68,4.71 253.09,5.3 250.98,5.3 250.23,4.55 243.47,4.55 242.37,5.65 240.98,5.65 240.82,5.81 239.43,5.81 238.47,4.85 235.43,4.85 234.4,5.88 204.93,5.88 201.1,9.72 v1(198.85,9.72)
I2C_ROM_DREAM_SCL: length 9.9
  BOTTOM w0.114: CON3002.3 15.57,59.45 15.57,59.45 15.57,60.73 14.41,61.89 12.1,61.89 11.28,62.71 R3084.1 10.83,63.46 v1(10.83,63.97) 11.07,64.21 Q3007.1
I2C_ROM_DREAM_SDA: length 9.1
  BOTTOM w0.114: CON3002.4 16.37,59.47 16.37,59.48 16.37,60.52 R3083.1 14.03,63.15 14.03,64.89 v1(14.38,65.24) 14.11,65.51 Q3007.4
I2C_SCL_AMP: length 43.7
  TOP w0.114: v1(192.17,153.87) 192.17,153.75 192.56,153.35 193.07,153.35 193.88,154.17 193.88,154.62 Q9042.4 ; R3681.2 191.41,152.1 v1(191.51,152.2)
  IN3 w0.089: v1(223.68,159.02) 223.68,158.21 220.66,155.18 205.37,155.18 204.73,155.82 200.48,155.82 200.33,155.67 198.79,155.67 198.41,156.05 v1(198.1,156.05)
  BOTTOM w0.102: U3603.G1 223.68,158.71 v1(223.68,159.02)
  BOTTOM w0.114: U3602.G1 198.58,155.56 v1(198.1,156.05) 197.72,155.67 197.21,155.67 196.7,155.16 R3647.2 195.8,155.62 194.22,155.62 194.01,155.82 193.02,155.82 192.68,155.47 Q3602.4 192.68,154.38 v1(192.17,153.87) 191.93,153.63 191.93,152.62 v1(191.51,152.2)
I2C_SCL_SENSOR: length 324.1
  IN3 w0.089: v1(260.81,32.37) 260.81,31.33 260.27,30.78 257.07,30.78 256.58,31.28 251.81,31.28 250.39,29.86 239.58,29.86 233.79,24.07 222.51,24.07 216.95,18.5 215.25,18.5 212.58,15.84 207.64,15.84 202.72,20.77 182.46,20.77 178.93,17.23 175.77,17.23 174.44,15.9 143.99,15.9 142.18,17.71 107.18,17.71 104.09,20.8 102.64,20.8 99.29,24.15 99.29,40.65 94.11,45.82 94.11,46.45 90.61,49.95 89.56,49.95 89.44,50.06 67.65,50.06 65.78,48.2 55.45,48.2 53.85,46.59 34.43,46.59 32.13,48.9 26.14,48.9 17.91,57.12 17.91,62.47 v1(16.18,64.21)
  BOTTOM w0.114: Q3008.6 v1(16.18,64.21) ; v1(260.81,32.37) 260.81,33.42 262.23,34.83 262.23,35.47 262.77,36.01 262.77,37.41 263.38,38.02 263.38,38.82 265.38,40.82 v1(265.38,42.25) 265.38,43.25 266.93,44.79 267.75,44.79 269.91,46.95 269.91,47.97 269.02,48.86 266.84,48.86 265.44,50.26 265.44,52.07 264.8,52.7 264.8,53.96 264.26,54.5 R9362.1
I2C_SCL_SENSOR_R: length 9.4
  BOTTOM w0.114: CON3002.7 18.77,59.45 18.77,59.45 18.77,60.75 18.09,61.43 16.14,61.43 14.96,62.61 R3086.1 14.48,63.48 v1(14.48,63.97) 14.72,64.21 Q3008.1
I2C_SDA_AMP: length 41
  TOP w0.114: Q9042.1 192.68,152.38 192.82,152.24 192.82,151.81 v1(193.12,151.51)
  IN3 w0.089: v1(223.04,159.02) 223.04,158.26 220.57,155.78 219.45,155.78 218.84,156.39 204.84,156.39 203.99,157.24 199.32,157.24 198.65,156.57 197.91,156.57 197.64,156.3 197.64,155.87 v1(198.1,155.41)
  BOTTOM w0.114: U3602.F1 198.36,155.15 v1(198.1,155.41) 197.26,155.41 196.26,154.4 R3646.2 195.75,154.65 195.1,154.65 194.6,154.14 194.6,153.43 Q3602.1 v1(193.98,151.95) 193.53,151.51 v1(193.12,151.51) 193.18,151.45 R3680.2 ; v1(223.04,159.02) 223.04,158.71 222.82,158.49 U3603.F1
I2C_SDA_SENSOR: length 326.9
  IN3 w0.089: v1(16.18,65.51) 18.27,63.42 18.27,57.02 26.19,49.1 32.18,49.1 34.51,46.77 53.77,46.77 56.12,49.11 57.95,49.11 58.69,48.38 65.71,48.38 67.57,50.24 89.52,50.24 89.63,50.13 90.69,50.13 94.29,46.52 94.29,45.9 99.47,40.72 99.47,24.41 102.64,21.23 103.94,21.23 107.28,17.88 142.26,17.88 143.77,16.37 171.84,16.37 172.14,16.07 174.27,16.07 175.61,17.41 178.69,17.41 182.25,20.97 202.76,20.97 207.72,16.02 212.43,16.02 220.66,24.25 233.66,24.25 239.45,30.04 250.32,30.04 251.73,31.45 256.7,31.45 257.19,30.96 260.13,30.96 260.48,31.31 260.48,32.07 v1(260.18,32.37)
  BOTTOM w0.114: R9363.1 264.11,54.3 264.58,53.83 264.58,52.6 265.21,51.97 265.21,50.17 266.75,48.63 268.92,48.63 269.68,47.88 269.68,47.05 267.65,45.02 266.83,45.02 264.57,42.76 264.57,42.73 263.15,41.31 263.15,38.12 262.54,37.51 262.54,36.11 262,35.57 262,35.06 260.18,33.24 v1(260.18,32.37) ; v1(16.18,65.51) 16.18,66.17 15.99,66.35 v1(15.89,66.35) 15.29,66.35 15.21,66.27 Q3008.3
I2C_SDA_SENSOR_R: length 8.6
  BOTTOM w0.114: Q3008.4 17.42,65.51 17.84,65.09 v1(17.84,64.35) 17.59,64.11 R3085.1 19.57,61.03 19.57,59.53 19.57,59.53 CON3002.8
I2C_TS_SCL: length 401.9
  TOP w0.114: v1(45.7,64.84) 45.7,62.01 45.09,61.41 45.09,60.07 43.54,58.52 43.54,54.75 v1(40.77,51.98)
  IN1 w0.076: v1(28.99,55.72) 30.94,53.76 37.01,53.76 39.24,51.53 40.32,51.53 v1(40.77,51.98) ; v1(45.7,64.84) 46.42,64.84 46.58,64.68 49.84,64.68 56.01,58.51 56.01,56.63 56.96,55.68 56.96,53.68 57.85,52.8 59.05,52.8 60.2,51.65 62.43,51.65 63.13,50.95 68.27,50.95 69.28,51.96 80.4,51.96 80.85,51.51 89.16,51.51 94.13,46.55 96.06,46.55 100.53,42.08 100.53,32.15 102.15,30.53 102.15,26.43 111.42,17.16 171.22,17.16 172.22,18.16 178.55,18.16 181.04,20.65 191.48,20.65 191.9,21.07 201.14,21.07 205.1,17.11 205.77,17.11 206.7,16.18 217.41,16.18 218.59,15 225.2,15 226.32,13.88 230.31,13.88 232.54,11.65 232.54,11.64 237.92,11.64 238.92,10.63 242.6,10.63 244.74,8.5 247.65,8.5 249.34,10.19 255.97,10.19 256.37,10.59 256.37,11.78 257.41,12.83 258.82,12.83 259.98,11.67 262.73,11.67 264.22,10.19 272.45,10.19 278.88,16.62 278.88,17.46 v1(278.83,17.51)
  IN4 w0.076: v1(281.92,64.25) 281.15,63.48 278.93,63.48 275.9,66.51 274.89,66.51 274.1,67.3 272.6,67.3 270.11,69.78 269.53,69.78 268.51,70.8 267.9,70.8 261.73,76.98 261.22,76.98 260.19,78.01 v3(260.19,79.53)
  BOTTOM w0.102: 259.92,79.36 259.92,79.05 259.92,79.04 259.92,78.43 258.63,77.15 258.63,77.04 258.26,76.66 258.15,76.66 257.11,75.62 U9002.BC22
  BOTTOM w0.114: 28.99,55.73 29.57,55.14 R3030.1 ; 28.99,55.73 v1(28.99,55.72) ; 28.99,55.73 28.99,56.23 C3039.2 29.57,57.29 29.39,57.47 CON3001.5 ; v1(278.83,17.51) 278.47,17.88 278.47,21.13 279.52,22.19 280.32,22.19 281.68,23.55 281.68,23.74 282.89,24.94 283.63,24.94 284.59,25.91 284.59,27.95 285.02,28.37 285.02,31.21 285.38,31.57 285.38,34.14 285.83,34.59 285.83,35.35 285.17,36.01 284.03,36.01 282.58,37.46 282.58,41.88 283.79,43.09 283.79,43.45 283.43,43.82 283.43,48.46 282.28,49.61 282.28,53.58 281.65,54.21 281.65,54.75 279.49,56.9 279.49,61.41 281.92,63.84 v1(281.92,64.25) ; v3(260.19,79.53) 260.09,79.53 259.92,79.36
I2C_TS_SDA: length 402
  TOP w0.114: v1(40.04,51.94) 43.16,55.06 43.16,58.66 44.72,60.23 44.72,61.56 45.14,61.98 v1(45.14,65.17)
  IN1 w0.076: v1(45.14,65.17) 45.14,64.84 45.63,64.35 49.69,64.35 54.82,59.22 54.82,57.29 56.63,55.48 56.63,52.92 58.24,51.32 62.3,51.32 63.01,50.61 68.57,50.61 69.59,51.63 80.26,51.63 80.71,51.18 89.02,51.18 93.99,46.22 95.92,46.22 100.2,41.94 100.2,32.02 101.82,30.39 101.82,26.29 111.28,16.83 171.36,16.83 172.26,17.73 178.73,17.73 181.32,20.32 191.62,20.32 192.04,20.74 200.86,20.74 204.92,16.68 205.6,16.68 206.52,15.75 217.38,15.75 218.46,14.67 225.07,14.67 226.18,13.55 230.08,13.55 232.33,11.31 237.78,11.31 238.78,10.3 242.42,10.3 244.56,8.17 247.78,8.17 249.47,9.86 256.11,9.86 256.7,10.45 256.7,11.65 257.55,12.5 258.69,12.5 259.84,11.34 262.6,11.34 264.08,9.86 272.58,9.86 279.23,16.5 279.23,17.89 v1(279,18.12) ; v1(40.04,51.94) 39.3,51.94 36.36,54.88 31.81,54.88 v1(31.17,55.51)
  IN4 w0.076: v1(281.59,64.84) 280.63,63.87 279,63.87 275.08,67.79 272.57,67.79 270.25,70.11 269.67,70.11 268.65,71.13 268.07,71.13 261.79,77.41 261.4,77.41 260.55,78.25 260.55,79.85 260.43,79.97 v3(260.43,80.2)
  BOTTOM w0.102: U9002.BF23 258.23,76.35 258.84,76.95 258.84,77.06 260.12,78.34
  BOTTOM w0.114: v3(260.43,80.2) 260.55,80.08 260.55,79.38 260.12,78.95 260.12,78.35 260.12,78.34 ; R3031.1 30.72,55.07 v1(31.17,55.51) 31.17,56.48 30.83,56.82 C3040.2 30.56,57.11 30.19,57.49 CON3001.6 ; v1(281.59,64.84) 282.18,64.84 282.35,64.66 282.35,63.74 279.86,61.25 279.86,57.07 282.31,54.61 282.57,54.61 282.84,54.35 282.84,54.04 282.68,53.89 282.68,49.72 283.79,48.61 283.79,43.97 284.16,43.6 284.16,42.94 282.94,41.72 282.94,37.8 284.37,36.37 285.32,36.37 286.19,35.5 286.19,34.43 285.77,34.01 285.77,31.13 285.4,30.76 285.4,28.09 285.06,27.75 285.06,25.71 283.82,24.47 283.08,24.47 282.15,23.54 282.15,23.38 280.58,21.81 279.66,21.81 278.85,20.99 278.85,18.27 v1(279,18.12)
I2CB_SCL_G: length 13
  TOP w0.114: R2033.2 215.5,93.21 215.5,95.42 214.28,96.64 214.28,102.29 215.8,103.81 v1(215.84,103.81)
  BOTTOM w0.114: v1(215.84,103.81) 215.87,103.81 U2000.R7
I2CB_SDA_G: length 8.8
  TOP w0.114: v1(215.79,102.13) 214.51,100.85 214.51,96.73 215.93,95.31 R2034.2
  BOTTOM w0.102: U2000.R6 216.21,102.55 v1(215.79,102.13)
I2CC_SCL: length 2.5
  BOTTOM w0.203: PR9823.1 PR9813.1 199.52,51.19 PU9802.4
I2CC_SCL_GFX: length 87.7
  TOP w0.114: Q2020.4 207.1,51.08 207.42,50.76 207.42,49.75 207.8,49.37 207.8,48.73 207.42,48.35 v1(206.86,48.35)
  IN2 w0.089: v1(216.03,97.91) 215.83,97.91 215.42,97.5 215.42,92.72 214.76,92.06 214.76,91.56 215.25,91.07 215.25,90.33 214.76,89.85 214.76,87.92 216.87,85.82 216.87,85.25 217.96,84.16 217.96,82.64 224.75,75.86 224.75,68.89 225.23,68.41 225.23,67.8 225.81,67.22 227.53,67.22 228.38,66.37 228.38,55.57 226.52,53.71 226.52,52.77 223.85,50.1 215.94,50.1 215,51.04 213.36,51.04 212.6,50.28 208.91,50.28 207.6,48.97 207.6,48.64 207.31,48.35 v1(206.86,48.35)
  BOTTOM w0.102: v1(216.03,97.91) 216.39,97.55 216.39,97.2 216.39,97.19
  BOTTOM w0.114: v1(216.03,97.91) 215.85,98.09 215.85,98.61 216.28,99.04 U2000.R2 ; 216.39,97.19 216.39,97.07 216.11,96.79 216.11,96.15 216.41,95.84 216.41,93.73 216.37,93.68 216.37,93.22 R2074.2

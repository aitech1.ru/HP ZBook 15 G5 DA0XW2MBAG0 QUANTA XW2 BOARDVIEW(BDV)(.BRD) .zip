# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N18140958: length 4.5
  TOP w0.114: v1(235.49,89.24) 235.62,89.12 R2118.1 R2117.2 233.85,88.33 C2217.2 R2140.1
N18141435: length 3.6
  TOP w0.114: R2141.1 233.79,72.2 233.89,72.1 R2122.2 C2219.2 235.35,70.08 R2123.1
N18332322: length 5.3
  BOTTOM w0.102: U9002.BE33 261.76,72.32 262.2,72.32 262.39,72.51 262.6,72.51 263.74,73.65 263.78,73.65 264.52,74.39 264.88,74.39
  BOTTOM w0.114: TP9021.1 265.41,74.92 264.88,74.39
N18377760: length 3
  TOP w0.114: R3648.2 199.68,153.75 199.68,152.92 v3(199.22,152.47)
  BOTTOM w0.114: U3602.A4 199.78,153.03 v3(199.22,152.47) 199.57,152.11 v1(199.68,152.11)
N18379805: length 2.2
  TOP w0.114: v1(221.9,156.68) 221.51,157.07 R3649.2 220.55,157.07 v3(220.41,157.21)
  BOTTOM w0.102: v3(220.41,157.21) 220.57,157.05 U3603.A4
N18439683: length 14.3
  IN1 w0.254: v1(252.94,12.22) 253.52,12.8 253.52,14.11 254.16,14.75 254.16,17.42 251.39,20.19 251.39,20.62 v1(251.18,20.83)
  BOTTOM w0.254: v1(251.18,20.83) 251.15,20.86 251.15,21.91 251.08,21.98 PR11002.1 ; PC11005.1 252.64,12.49 252.67,12.49 v1(252.94,12.22) 252.51,11.78 PC11004.2 251.64,11.78 PR11005.1
N18439702: length 15.3
  IN1 w0.254: v1(252.98,11.48) 253.85,12.35 253.85,13.97 254.57,14.69 254.57,17.59 251.79,20.36 251.79,20.8 v1(251.82,20.83)
  BOTTOM w0.254: PR11001.1 251.66,21.98 251.57,21.89 251.57,21.29 251.82,21.04 v1(251.82,20.83) ; PR11004.1 251.75,11.01 251.75,11 PC11004.1 252.51,11 v1(252.98,11.48) 253.29,11.17 PC11003.2
N18441298: length 20.6
  TOP w0.381: D2004.2 216.49,79.34 218.97,79.34 R2148.2 C2231.2 R2147.2 219.57,82.93 219.57,85.68 220.08,86.2 v1(221.42,86.2) ; Q2019.5 Q2019.2 218.54,90.08 219.08,89.55 v1(219.41,89.55)
  IN2 w0.381: v1(219.41,89.55) 219.69,89.83 220.35,89.83 220.53,89.65 220.53,88.78 221.42,87.89 v1(221.42,86.2)
N19453152:
  vias: v1(233.08,72.23)
N19516437: length 13.2
  BOTTOM w0.114: v1(292.89,40.6) 292.39,41.1 PR25007.1 PR25026.1 PR25005.2 PR25003.2 PR25025.1 PR25011.1 292.39,47.59 292.89,47.59 293.25,47.22 293.25,46.85 293.61,46.5 293.61,45.77 PR25017.1 PC25002.2 293.82,44.13 294.78,44.13 PR25015.2
N19743923: length 4.9
  BOTTOM w0.114: CON5000.18 38.8,44.36 v1(37.57,45.58) R5001.1
N19870020: length 5.8
  BOTTOM w0.114: v1(33.42,136.5) R6096.2 R6005.1 31.53,137.14 31.64,137.25 Q6002.6 31.64,138.89 31.78,139.03 32.16,139.03 32.29,138.9 Q6002.5
N19870172: length 2.2
  TOP w0.114: v1(253.4,43.14) R6179.2 252.52,43.38 Q6003.2
N19870194: length 6.7
  TOP w0.114: Q6008.2 256.96,45.44 v1(256.57,45.05) 256.06,45.57 R6178.2 R6177.2 254.02,45.18 252.48,45.18 252.25,45.4 Q6003.3
N19870369: length 2.9
  TOP w0.114: LED6000.2 363.63,152.01 363.63,151.26 R6094.2
N19870371: length 3.4
  TOP w0.114: LED6000.1 364.16,154.16 v1(363.25,153.25) 362.84,152.84 R6095.2
N19873939: length 2.5
  TOP w0.508: PC13006.1 194.07,38.91 194.24,39.08 v1(194.27,39.08) PR13000.2
N19874615: length 2.3
  TOP w0.114: v1(216.41,44.53) PC13028.2
  TOP w0.508: PC13028.2 217.89,44.53 PR13011.1
N19874621: length 2.4
  BOTTOM w0.508: PC13022.1 221.53,43.01 222.45,42.09 PR13009.2
N19874656: length 2.4
  TOP w0.508: v1(196.47,36.54) PR13003.1 197.06,37.56 197.32,37.82 PC13013.2
N19883422: length 5
  TOP w0.508: PR26010.2 216.06,33.31 v1(215.56,33.81)
  BOTTOM w0.254: PU13002.21 215.06,35.89 215.3,35.65 215.3,35.04 215.58,34.76
  BOTTOM w0.508: PC13035.2 215.96,33.41 v1(215.56,33.81) 215.58,33.83 v1(215.58,34.56) 215.58,34.76
N19883517: length 2.4
  BOTTOM w0.254: PU13002.6 211.37,34.32 210.55,33.49 210.47,33.49 v1(210.47,33.49) 209.66,33.49 PR13016.2
N19883529: length 2.3
  TOP w0.114: PR13017.1 213.43,34.8 213.43,34.8 v1(213.43,34.8)
  TOP w0.508: PR13017.1 215.03,34.8 215.2,34.63 PC13036.1
N19883555: length 2.4
  BOTTOM w0.114: PC13042.2 211.85,40.76 v1(211.36,40.76)
  BOTTOM w0.508: PC13042.2 212.54,40.65 PR13019.1
N20025646: length 28.5
  TOP w0.203: v1(237.4,7.08) 237.56,6.91 PC11021.2 238.16,6.91 238.27,7.03 239.47,7.03 PC11022.1 239.93,7.08 240.19,6.82 PR11026.2
  IN4 w0.203: v1(237.4,7.08) 237.24,7.23 236.49,7.23 235.86,7.86 228.43,7.86 224.77,11.52 221.65,11.52 218.6,14.57 218.6,16.73 v1(218.47,16.85)
  BOTTOM w0.178: PR11017.1 218.47,17.44 v1(218.47,16.85)
N20025647: length 28.1
  TOP w0.203: v1(237.42,7.71) 237.44,7.69 PC11021.1 238.23,7.69 PC11020.1 239.63,8.65 239.99,8.3 PR11024.2
  IN4 w0.203: v1(219.11,16.85) 218.98,16.73 218.98,14.58 221.74,11.83 224.92,11.83 228.61,8.14 235.97,8.14 236.61,7.51 237.22,7.51 v1(237.42,7.71)
  BOTTOM w0.178: v1(219.11,16.85) 219.11,17.31 PR11016.1
N20025709: length 1.9
  BOTTOM w0.508: PR11010.1 247.44,18.14 v1(247.53,18.05) 247.81,17.77 PC11012.1
N20059068: length 7.3
  TOP w0.114: PD11008.3 255.05,7.84 254.13,8.76 PD11007.1 255.37,11.5 v1(255.85,11.5)
  BOTTOM w0.114: PR11008.1 255.56,11.78 v1(255.85,11.5)
N20282259: length 4.8
  BOTTOM w0.114: U6001.M6 268.57,31.93 267.64,32.85 267.45,32.85 v1(267.29,33.01) 266.86,33.44 266.86,33.9 C6032.2 266.39,33.9 266.35,33.86 R6187.2
N20549842: length 6.1
  BOTTOM w0.114: v1(352.58,77.95) R4104.1 R4107.1 352.57,79.86 R4111.2 351.07,79.86 351.06,79.85 350.17,79.85 350.17,80.61 350.04,80.74 Q4103.3
N20618845: length 5.4
  BOTTOM w0.102: U9002.BC1 249.71,83.06 249.71,84.29 249.9,84.48 249.9,85 249.71,85.18
  BOTTOM w0.114: TP9039.1 247.63,86.76 249.17,85.21 249.68,85.21 249.71,85.18
N21534191: length 3.5
  BOTTOM w0.114: JCN9000.4 261.74,16.6 261.69,16.65 261.69,17.14 261.27,17.57 R9001.2 260.59,18.2 v1(260.41,18.03)
N21542905: length 5.2
  TOP w0.114: R7206.2 342.2,128.75 341.89,128.44 v1(341.18,128.44) 340.91,128.71 R7154.2 R7155.1 340.91,131.69 Q7146.3
N21677295: length 5.3
  TOP w0.114: v1(288.58,15.58) 290.48,15.58 290.69,15.37 PR16001.2
  TOP w0.254: PU16000.11 292.73,15.87 292.1,15.25 291.85,15.25 PC16000.2 291.72,15.13 PR16001.2
N21677318: length 2.4
  BOTTOM w0.114: v1(296.15,16.69) PR16005.1
  BOTTOM w0.508: PR16005.1 PC16011.2
N21830961: length 3.2
  TOP w0.114: v1(21.62,123.66) 22.76,124.8 R4025.2
  BOTTOM w0.114: U4000.6 21.8,123.84 v1(21.62,123.66)
N22420667: length 2
  TOP w0.381: R2519.1 245.7,103.34 R2520.1 244.73,103.77 244.8,103.85 C2553.1
N22581784: length 2.8
  TOP w0.114: U6500.6 296.05,54.93 296.2,55.08 296.73,55.08 v1(297.19,55.54) 297.46,55.81 R6508.1
N22581796: length 4
  BOTTOM w0.114: Q6500.3 303.42,43 303.05,42.64 R6511.2 303.83,41.1 R6512.1 304.07,40.6 v1(303.69,40.22)
N22581800: length 4
  BOTTOM w0.114: Q6500.2 304.83,43.65 305.09,43.4 v1(305.09,43.02) C6503.2 R6512.2
N22650661: length 7.5
  TOP w0.114: R9502.1 241.51,4.38 241.1,4.79 240.77,4.79 v1(240.19,5.37) 239.99,5.58 238.56,5.58 238.2,5.94 237.58,5.94 236.96,6.57 236.56,6.57 236.3,6.31 236.3,5.88 236.54,5.65 U6004.5
N22855262:
  vias: v1(140.42,144.54)
N22855291: length 2.2
  TOP w0.114: v1(141.76,142.3) v1(142.49,142.3)
  TOP w0.254: v1(141.76,142.3) 141.1,142.97 PR20008.2
  BOTTOM w0.254: v1(141.76,142.3) PR20004.1
N22855292: length 32.2
  TOP w0.254: v1(137.07,142.68) 137.07,142.46 137.45,142.08 138.78,142.08 PR20013.1 PR20010.1 139.41,141.44 140.91,141.44 141.06,141.59 PC20011.2 141.38,141.95 v1(141.76,141.57) ; v1(140.49,159.09) 140.64,159.09 140.88,158.86 141.54,158.86 PC20012.2 142.15,159.23 PR20014.1
  IN3 w0.254: v1(137.07,142.68) 136.9,142.85 136.37,142.85 135.45,143.77 135.45,149.84 138.37,152.76 138.37,154.9 140.02,156.55 140.02,158.75 140.37,159.09 v1(140.49,159.09)
  BOTTOM w0.254: PR20005.1 v1(141.76,141.57)
N22855294: length 24.2
  TOP w0.254: PC20011.1 PR20008.1 139.81,142.97 139.28,143.49 PR20012.2 139.28,144 139.17,144.11 137.83,144.11 v1(137.64,143.92) 137.07,143.35 v1(137.07,143.31) ; v1(140.49,158.46) 140.61,158.34 PR20011.1
  IN3 w0.254: v1(137.07,143.31) 136.94,143.19 136.52,143.19 135.8,143.91 135.8,149.7 138.72,152.62 138.72,154.76 140.49,156.54 v1(140.49,158.46)
N22855298: length 2.3
  TOP w0.114: v1(137.07,141.44) 137.57,141.44 v1(137.7,141.57)
  TOP w0.254: PR20010.2 v1(137.7,141.57)
  BOTTOM w0.254: v1(137.7,141.57) 137.31,141.18 PR20009.2
N22855301: length 2.7
  TOP w0.254: v1(137.7,142.58) PR20013.2 PR20012.1
  BOTTOM w0.254: v1(137.7,142.58) 137.69,142.58 PR20009.1
N22855337:
  vias: v1(148.75,145.33)
N22855368: length 32.3
  TOP w0.254: v1(145.92,141.25) 146.08,141.41 147.05,141.41 v1(147.2,141.26) 147.35,141.41 149.04,141.41 v1(149.26,141.19) 149.85,141.19 PC20021.2 150.26,140.77 PR20025.1 151.68,141.55 PR20028.1 ; v1(147.48,158.43) 147.47,158.42 148.37,158.42 PC20022.2 149.01,158.05 PR20029.1
  IN3 w0.254: v1(147.48,158.43) 146.63,157.58 146.63,153.65 143.58,150.6 143.58,146.13 144.01,145.7 144.01,142.49 144.47,142.02 145.1,141.4 145.78,141.4 v1(145.92,141.25)
  BOTTOM w0.254: PR20019.1 v1(149.26,141.19)
N22855370: length 27.2
  TOP w0.254: PR20027.2 150.77,142.81 PC20021.1 149.89,142.33 149.9,142.34 PR20023.1 149.9,142.99 149.46,143.43 148.78,143.43 148.62,143.27 148.62,142.48 147.92,141.78 146.09,141.78 v1(145.96,141.92) ; PR20026.1 147.74,157.93 v1(147.48,157.67)
  IN3 w0.254: v1(147.48,157.67) 146.97,157.16 146.97,153.51 143.92,150.46 143.92,146.27 144.35,145.84 144.35,142.63 145.24,141.74 145.78,141.74 v1(145.96,141.92)
N22855374: length 4.3
  TOP w0.254: PR20028.2 150.9,142.03 PR20027.1 152.24,142.81 152.57,142.47 v1(152.57,142.14) v1(152.57,141.16)
  BOTTOM w0.254: PR20024.1 v1(152.57,141.16)
N22855375: length 1.7
  TOP w0.254: PR20025.2 152.18,140.77 v1(152.57,140.39)
  BOTTOM w0.254: PR20024.2 v1(152.57,140.39)
N22855427: length 1.3
  TOP w0.508: PR20033.2 157.93,144.91 158.01,145 PC20034.1
  vias: v1(157.21,145.25)
N22855458: length 31.7
  TOP w0.254: v1(154.85,141.16) 154.98,141.3 158.04,141.3 v1(158.15,141.19) 158.19,141.15 PC20035.2 159.15,140.77 PR20040.1 160.57,141.55 PR20043.1 ; PR20044.1 156.89,158.05 PC20036.2 156.28,158.46 v1(155.35,158.46)
  IN3 w0.254: v1(154.85,141.16) 154.69,141.31 154.22,141.31 153.37,142.16 153.37,146.73 152.43,147.67 152.43,150.55 154.46,152.58 154.46,157.57 v1(155.35,158.46)
  BOTTOM w0.254: PR20035.1 v1(158.15,141.19)
N22855460: length 26.9
  TOP w0.254: 158.79,141.94 159.66,142.81 PR20042.2 ; 158.79,141.94 PC20035.1 ; 158.79,141.94 PR20038.1 158.28,143.44 157.64,143.44 157.23,143.04 157.23,142.2 156.87,141.85 v1(156.45,141.85) 156.27,141.66 155.09,141.66 v1(154.85,141.91) ; v1(155.35,157.7) 155.58,157.93 PR20041.1
  IN3 w0.254: v1(154.85,141.91) 154.6,141.66 154.36,141.66 153.71,142.3 153.71,146.88 152.77,147.82 152.77,150.4 154.81,152.43 154.81,157.15 v1(155.35,157.7)
N22855464: length 4
  TOP w0.254: v1(161.46,141.16) v1(161.46,141.92) PR20042.1 159.79,142.03 PR20043.2
  BOTTOM w0.254: PR20039.1 v1(161.46,141.16)
N22855465: length 1.7
  TOP w0.254: v1(161.38,140.39) 160.99,140.77 PR20040.2
  BOTTOM w0.254: PR20039.2 v1(161.38,140.39)
N22855516:
  vias: v1(166.96,145.4)
N22855547: length 31.4
  TOP w0.254: PR20058.1 169.71,141.43 PR20055.1 168.56,141.02 PC20045.2 167.3,141.02 v1(167.29,141.03) 167.04,141.28 165.2,141.28 v1(165.16,141.24) 165.11,141.28 163.99,141.28 v1(163.86,141.16) ; PR20059.1 165.01,158.05 PC20046.2 164.38,158.43 v1(163.51,158.43)
  IN3 w0.254: v1(163.86,141.16) 163.7,141.32 162.96,141.32 161.64,142.63 161.64,152.67 162.63,153.66 162.63,157.55 v1(163.51,158.43)
  BOTTOM w0.254: v1(167.29,141.03) PR20050.1
N22855549: length 26.5
  TOP w0.254: 167.93,141.81 PR20053.1 167.44,143.3 166.78,143.3 166.53,143.04 166.53,142.25 166.02,141.75 164.03,141.75 v1(163.86,141.92) ; 167.93,141.81 168.81,142.68 PR20057.2 ; 167.93,141.81 PC20045.1 ; PR20056.1 163.71,157.93 163.48,157.7 v1(163.48,157.7)
  IN3 w0.254: v1(163.86,141.92) 163.61,141.66 163.1,141.66 161.99,142.78 161.99,152.53 162.97,153.52 162.97,157.19 v1(163.48,157.7)
N22855553: length 4.2
  TOP w0.254: v1(170.6,141.04) v1(170.6,142.03) 170.6,142.22 170.14,142.68 PR20057.1 168.93,141.9 PR20058.2
  BOTTOM w0.254: PR20054.1 v1(170.6,141.04)
N22855554: length 1.7
  TOP w0.254: PR20055.2 170.21,140.65 v1(170.6,140.26)
  BOTTOM w0.254: PR20054.2 v1(170.6,140.26)
N22855607: length 1.7
  TOP w0.254: PR20023.2 149.12,142.26 149.05,142.19 v1(149.05,142.05)
  BOTTOM w0.254: v1(149.05,142.05) 149.26,142.25 PR20018.1
N22855616: length 1.7
  TOP w0.254: v1(157.94,142.03) 158.01,142.09 PR20038.2
  BOTTOM w0.254: v1(157.94,142.03) 158.15,142.23 PR20034.1
N22855622: length 1.8
  TOP w0.254: PR20053.2 167.16,141.94 v1(167.11,141.9)
  BOTTOM w0.254: PR20049.1 167.29,142.08 v1(167.11,141.9)
N22857752:
  vias: v1(122.84,117.69)
N22857755: length 0.9
  BOTTOM w0.114: PC21010.1 v1(124.74,127.46)
N22857779: length 0.9
  BOTTOM w0.114: PC21023.1 v1(125.9,106.65)
N22857845:
  vias: v1(172.6,148.2)
N22857847:
  vias: v1(178.59,146.75)
N22936532: length 2.9
  TOP w0.381: C2529.1 221.84,143.33 ; 221.84,143.33 R2511.1 222.8,144.3 R2512.1 ; 221.84,143.33 221.84,142.52 v1(221.9,142.46)
N22985955: length 3.1
  TOP w0.381: R2510.1 199.71,144.16 R2509.1 C2527.1
  TOP w0.508: v1(200.57,142.33) 200.84,142.6 C2527.1
N22992688: length 3.1
  TOP w0.114: v1(247.22,123.43) 246.75,122.96 C2536.1 246.16,123.16 R2514.1 R2515.1
N23148426: length 4.1
  TOP w0.114: v1(192.18,95.34) 191.89,95.05 Q9002.3 191.13,95.05 190.99,94.91 190.99,94.67 191.12,94.55 Q9002.2 191.83,94.55 191.93,94.45 191.93,93.69 191.81,93.57 R9308.1
N23208307: length 8
  TOP w0.114: R4019.1 15.4,113.25 v1(14.76,113.88) 14.76,114.14 11.86,117.04 CON4000.14
N23208323: length 2.9
  TOP w0.114: R4020.2 v1(10.7,134.71) 10.7,134.49 CON4000.13
N23249859: length 6.9
  TOP w0.203: R3640.1 v1(362.11,14.57) 362.87,14.57 365.77,11.67 CON3601.3
N23300592: length 3.1
  BOTTOM w0.114: U2007.1 204.39,88.08 204.63,87.85 204.63,87.54 v1(204.86,87.31) 204.63,87.09 204.63,86.83 204.8,86.66 U2006.4
N23309364: length 6.7
  BOTTOM w0.114: Q2006.2 196.37,88.11 196.88,87.59 v1(197.14,87.59) 197.45,87.91 D2008.3 199.01,87.91 199.04,87.93 R2101.2 199.93,87.47 200.18,87.21 200.69,87.21 201.12,86.78 U2007.4
N23324590: length 6.6
  BOTTOM w0.114: v1(194.49,88.33) 194.49,88.15 195.22,87.43 Q2000.2 195.88,87.86 195.76,87.98 195.76,89.27 195.87,89.37 Q2006.3 195.87,90.38 C2161.2 196.87,90.77 196.88,90.76 R2050.2
N23331618: length 6
  BOTTOM w0.114: R404.1 82,57.62 81.7,57.92 81.7,59.23 81.92,59.45 v1(81.92,59.81) 81.92,60.58 81.69,60.81 81.69,61.65 81.73,61.69 CON400.39
N23445462: length 6.3
  TOP w0.114: v1(108.49,97.37) 108.49,98 PR23007.1 108.99,98.25 109.38,98.64 110.4,98.64 110.66,98.38 PR23020.1 110.9,98.13 111.05,98.28 111.05,98.49 110.66,98.89 PR23021.1 111.03,99.15 111.14,99.04 PU23000.1
N23692787: length 3.2
  BOTTOM w0.508: PR9004.1 207.8,48.54 PC9013.2 PR9001.2
N23796258: length 3.5
  TOP w0.114: Q9001.3 133.27,112.34 133.13,112.49 132.73,112.49 132.62,112.37 Q9001.2 v1(132.62,111.09) 132.62,110.21 R9002.1
N23796391: length 2.6
  TOP w0.114: v1(129.48,111.31) R9301.1 LED9000.2
N24173296: length 9
  BOTTOM w0.114: PR25014.1 PC25001.2 PR25016.1 PR25008.1 294.79,32.1 294.8,32.09 PD25000.3 295.84,31.5 295.94,31.6 PR25004.1 PR25001.1 PR25002.1 v1(298.61,32.6)
N24218229: length 2.4
  TOP w0.114: PR12010.1 267.74,3.77 v1(267.88,3.9) 268.26,4.28 PQ12003.3
N24218333: length 3
  BOTTOM w0.114: v1(259.37,23.46) 259.17,23.26 PR12000.2 PC12001.2 PR12001.2
N24414354: length 6.8
  TOP w0.114: CON4000.9 v1(13.83,115.79) 13.83,115.65 16.67,112.81 R9549.2
N24414492: length 3.7
  TOP w0.114: R9550.2 13.51,134.73 v1(13.37,134.58) 13.83,134.13 CON4000.11
N24794111: length 3.5
  BOTTOM w0.114: CON400.55 v1(77.73,61) 77.73,59.54 R403.1
N24857035: length 3.6
  BOTTOM w0.114: C7319.2 33.88,67.54 33.81,67.6 33.5,67.6 v1(32.98,67.08) 32.98,67.45 32.82,67.6 32.49,67.6 32.14,67.96 U7301.8
N24857037: length 3.6
  BOTTOM w0.114: U7301.7 32.07,68.36 32.58,67.85 32.87,67.85 32.97,67.94 v1(32.97,68.36) 33.48,67.85 33.78,67.85 33.88,67.95 C7321.2
N25358852: length 3
  TOP w0.114: R909.2 C858.2 253.12,32.96 252.91,32.76 R908.1 v1(252.59,31.84)
N25359574: length 2.9
  BOTTOM w0.114: U6001.A6 268.57,21.93 268.33,21.7 v1(268.33,21.55) 268.38,21.5 C6007.2
N25362513: length 9.5
  TOP w0.114: R912.2 R911.2 244.51,40.86 v1(244.13,40.48) 243.82,40.17 v1(243.82,39.33) ; U49.5 246.4,36.5 246.16,36.74 246.16,37.1 245.71,37.54 245.1,37.54 244.81,37.25 v1(244.81,37.05)
  BOTTOM w0.114: v1(243.82,39.33) 244.13,39.03 244.13,38.83 244.81,38.15 v1(244.81,37.05)
N25369401: length 4.1
  TOP w0.381: R17898.2 251.64,79.13 v1(251.64,79.31) 251.92,79.59 C9235.2
  BOTTOM w0.254: U9002.BB7 251.07,79.57 U9002.AY8 251.25,79.31 v1(251.64,79.31)
N25375127: length 8.2
  BOTTOM w0.102: 244.38,85.31 245.47,85.31 246.09,84.69 246.09,84.1 247.53,82.67 247.53,81.86 247.77,81.62 248.08,81.62 248.14,81.68 248.46,81.68 248.72,81.41 248.72,81.08 248.71,81.06 U9002.AW2
  BOTTOM w0.114: TP22011.1 244.38,85.31
N25377172: length 4.1
  BOTTOM w0.114: R17985.1 125.56,90.43 125.6,90.39 R17907.1 125.6,89.08 v1(125.38,88.86) 124.49,88.86 124.24,89.11 Q9035.2
N25434094: length 6.7
  TOP w0.114: PQ12009.1 297.1,34.62 PR12032.2 295.54,34.91 295.05,35.4 PR12030.2 294.57,36.89 294.57,37.91 v1(294.29,38.19) 294.16,38.32 PR12031.2
N25434098: length 5.1
  TOP w0.114: v1(295.56,35.52) 295.56,36.68 PR12028.2 PR12030.1 295.05,37.82 PR12023.1 295.43,38.58 295.31,38.7 PR12022.1
N25434108: length 3.5
  TOP w0.114: PR12031.1 294.16,39.99 PR12020.1 293.22,40.96 v1(293.12,41.06) 293.05,40.98 291.75,40.98
N25434127: length 5.3
  TOP w0.114: v1(301.53,38.44) 301.35,38.62 PQ12005.1 300.56,38.75 PR12021.1 300.54,40.01 PR12019.1 299.24,39.83 PR12017.1
N25434139: length 8.9
  TOP w0.114: PR12022.2 PC12008.2 297,39.98 v1(297.14,39.84) 297.14,39.54 297.63,39.05 PR12017.2 298.41,38.59 PQ12005.3 301.53,37.61 PQ12006.1
N25434159: length 5.9
  TOP w0.114: PR12024.2 304.71,42.26 v1(304.58,42.13) 304.2,41.75 303.66,41.75 303.35,41.44 303.35,41.03 303.08,40.76 PQ12007.1 301.28,40.76 301.22,40.82 PR12021.2
N25434165: length 6.5
  TOP w0.114: PQ12005.2 299.68,36.59 299.5,36.41 299.5,35.9 299.75,35.66 299.75,34.99 PR12029.2 300.1,34.54 301.34,33.3 PR12025.2 v1(301.34,31.66)
N25434218: length 5.3
  TOP w0.114: PR12019.2 299.18,40.79 298.74,40.35 297.66,40.35 PR12018.1 296.66,40.5 296.07,40.5 v1(295.74,40.83) 295.61,40.96 PR12020.2
N25434240: length 3.1
  TOP w0.114: PQ12009.2 297.44,35.6 v1(297.09,35.6) 297.01,35.6 296.2,36.4 PR12028.1
N25489287: length 1.9
  TOP w0.254: PR11039.1 245.17,8.7 v1(244.81,9.06) 244.36,9.51 PR11038.2
N25500449: length 6.4
  TOP w0.508: 230.28,16.09 229.52,16.85 v1(228.76,16.85) 227.72,16.85 PQ12011.3 225.91,16.45 PR12036.2
N25500523: length 4.5
  TOP w0.508: PR12034.1 225.29,12.12 v1(225.51,11.9) PC12010.2 PR12035.2 226.3,12.93 PQ12011.2
N25553256: length 3.1
  TOP w0.114: Q9040.3 247.29,49.91 247.22,49.98 246.87,49.98 246.79,49.9 Q9040.2 v1(246.79,48.86) 246.79,48.24 R17943.1
N25553310: length 3.4
  TOP w0.114: Q9036.3 237.52,44.37 R17938.1 236.76,43.15 236.63,43.28 v1(236.63,43.65) 237.01,44.03 Q9036.2
N25553361: length 3.7
  TOP w0.114: Q9037.2 244.71,51.98 244.62,51.89 244.29,51.89 244.21,51.98 Q9037.3 244.21,52.86 v1(243.57,53.51) 243.19,53.13 R17939.1
N25553432: length 3
  TOP w0.114: Q9038.2 240.44,41.87 240.57,42 240.82,42 240.94,41.87 Q9038.3 241.19,41.61 v1(241.71,42.13) 241.85,42.26 R17941.1
N25553485: length 2.8
  TOP w0.114: R17942.1 261.82,16.1 v1(262.08,15.84) Q9039.2 263.05,15.84 263.18,15.71 263.18,15.47 263.05,15.34 Q9039.3
N25557141: length 2.7
  BOTTOM w0.114: R17951.1 319.51,60.49 319.87,60.14 319.87,58.84 320.05,58.66 U500.33
N25557143: length 1.6
  BOTTOM w0.114: R17952.1 321.01,60.26 U500.34
N25557296: length 4.1
  BOTTOM w0.114: R17949.1 344.88,47.15 344.88,46.52 344.55,46.19 343.8,46.19 342.98,45.38 342.75,45.38 342.57,45.2 U501.33
N25557298: length 1.9
  BOTTOM w0.114: U501.34 343.65,44.24 343.69,44.29 343.69,45.41 R17950.1
N25688589: length 3.2
  TOP w0.114: v1(117.23,99.02) 117.07,99.18 PR23023.1
  TOP w0.203: PR23023.1 PR23022.1 115.22,99.18 115.08,99.04 PU23000.5
N25688835: length 3
  BOTTOM w0.114: v1(110.65,93.18) PR23024.1
  BOTTOM w0.203: PR23025.1 PR23024.1 110.06,92.39 109.77,92.1 PU23001.5
N25796977: length 1.1
  TOP w0.508: v1(236.51,144.36) 236.69,144.55 PR26011.2
N25924440: length 7.3
  BOTTOM w0.114: PQ10005.3 332.05,141.22 332.21,141.39 333.25,141.39 333.35,141.48 PQ10005.6 333.35,142.6 333.56,142.81 333.88,142.81 v1(335.73,140.96) 336.01,140.69 PR10005.2
N25934937: length 5.2
  TOP w0.508: v1(343.35,148.27) 343.35,147.97 343.41,147.92 PR26017.1 343.41,146.8 PR10010.2
  BOTTOM w0.381: PQ10009.2 345.02,147.37 344.72,147.37 343.82,148.27 v1(343.35,148.27)
N25934984: length 1
  TOP w0.508: PR26017.2 344.19,148.23 PQ26006.3
N25938819: length 5
  BOTTOM w0.114: PR23028.2 PC23018.2 198.86,13.53 199.07,13.32 199.07,11.93 199.31,11.68 PU23002.4
N25938833: length 8.7
  BOTTOM w0.114: PU23002.3 199.02,11.03 198.74,11.32 198.74,13.04 197.21,14.57 197.21,15.81 196.85,16.18 PC23015.1 195.97,16.18 195.95,16.2 PR23026.1 PR23027.1
N26150460: length 2.8
  BOTTOM w0.114: PR26018.1 228.59,80.14 228.46,80.27 228.46,81.16 228.04,81.58 PU25002.4
N27027955: length 2.1
  BOTTOM w0.114: PD25000.2 295.45,29.19 295.31,29.05 PR25012.1 296.08,28.55 v1(296.2,28.67)
N27029563: length 1.4
  BOTTOM w0.114: PQ10017.3 339.48,149.12 PR10024.2
N27029564: length 13.1
  TOP w0.406: PQ10011.4 v1(335.79,136.39)
  IN3 w0.508: v1(335.79,136.39) 335.79,142.81 336.54,143.55 v1(336.48,145.73)
  BOTTOM w0.356: v1(336.48,145.73) 336.86,146.11 PR10029.1 337.4,146.11 337.67,145.84 v1(337.9,145.84) 338.18,146.11 PQ10017.6
N27029566: length 2.9
  BOTTOM w0.114: PR10032.1 338.93,149.25 338.83,149.15 PQ10017.2 PQ10017.5
N27029568: length 19.2
  IN3 w0.089: v1(343.44,150.48) 342.02,149.06 337.17,149.06 334.78,146.67 334.78,145.38 v1(334.47,145.07)
  BOTTOM w0.114: PQ10014.2 342.93,148.09 342.91,148.11 342.91,148.91 343.1,149.1 PR10025.1 343.1,150.15 v1(343.44,150.48) ; PQ10015.2 334.75,144.79 v1(334.47,145.07) 334.35,145.2 PD2.2
N27029569: length 1.6
  BOTTOM w0.114: PQ10018.3 334.66,146.51 334.42,146.27 333.92,146.27 333.59,146.59 PR10026.1
N27029586: length 2.8
  BOTTOM w0.114: PR10033.1 335.07,149.26 335.31,149.01 PQ10018.5 PQ10018.2
N27029588: length 23.5
  TOP w0.406: v1(335.79,132.93) PQ10012.4
  IN1 w0.508: v1(335.79,132.93) 337.47,134.61 337.47,136.74 336.2,138.01 336.2,142.84 337.73,144.36 337.73,146.52 336.84,147.41 336.84,148.81 337.47,149.44 v1(337.47,150.33)
  BOTTOM w0.356: PQ10018.6 336.54,148.44 336.84,148.74 PR10030.1 337.47,149.17 v1(337.47,150.33)
N27029591: length 11.6
  BOTTOM w0.114: PQ10018.4 334.66,148.02 334.05,147.41 v1(333.79,147.41) 332.77,147.41 332.14,146.78 332.14,144.87 332.47,144.54 332.95,144.54 333.18,144.77 333.92,144.77 334.19,144.49 335.82,144.49 337.09,143.22 PQ10015.1
N27029606: length 2.6
  BOTTOM w0.114: v1(341.89,147.03) 341.76,147.16 PQ10014.1 340.27,147.16 339.85,146.74 PQ10017.4
N27168565: length 13.2
  IN3 w0.089: v1(261.24,16.96) 261.73,16.47 270.57,16.47 v1(271.05,16.96)
  BOTTOM w0.114: JCN9000.23 271.24,16.76 v1(271.05,16.96) 271.31,17.22 R9016.2 ; JCN9000.3 v1(261.24,16.96)
N27205864: length 8.2
  TOP w0.114: R17984.2 261.37,33.08 261.37,32.71 261.24,32.57 261.24,31.95 261.62,31.57 262.38,31.57 262.6,31.35 263.1,31.35 263.45,31 263.45,30.75 263.75,30.45 264.05,30.45 264.43,30.07 264.43,29.77 264.75,29.45 v1(264.75,29.43) 265.84,29.43 266.05,29.22 v3(266.29,29.22)
  BOTTOM w0.114: U6001.J3 v3(266.29,29.22)
N27414743: length 4.1
  BOTTOM w0.114: R9316.1 133.25,107.41 134.03,106.64 R9028.1 134.03,106.25 v1(134.78,105.5) 134.37,105.09 Q9004.2
N27414752: length 3.7
  BOTTOM w0.114: Q9003.2 130.62,105.24 130.72,105.33 R9313.2 131.6,104.95 Q9004.3 131.6,103.34 v1(131.35,103.09)
N27585860: length 1.7
  BOTTOM w0.203: v1(126.88,140.88) PC19006.1 127.34,141.65 127.36,141.62 PR19027.2
N27585915: length 3
  BOTTOM w0.114: PC19012.1 121.61,144.08 121.61,143.9 121.62,143.9 121.62,143.54 121.61,143.54 121.61,142.75 v1(121.57,142.71)
  BOTTOM w0.203: PR19054.2 PC19012.1
N27755546: length 4
  TOP w0.114: PR16008.1 298.37,16.35 v1(299.75,16.35)
  TOP w0.254: PR16008.1 297.24,15.89 296.75,16.37 PU16000.6
N27758362: length 3.6
  BOTTOM w0.114: v1(116.67,95.09) 116.89,95.31 PQ26002.3
  BOTTOM w0.508: PR26001.1 120.1,95.35 118.56,95.35 118.52,95.31 PQ26002.3
N27758389: length 5.2
  BOTTOM w0.114: v1(119.67,98.01) 119.03,98.64 PQ26001.3 118.57,99.71 116.82,99.71 PR26004.2 PR26003.1
N27758591: length 3.1
  BOTTOM w0.114: v1(120.3,102.45) 120.05,102.2 120.05,101.28
  BOTTOM w0.508: PQ26000.1 120.05,101.28
N27758609: length 2.4
  BOTTOM w0.114: PQ26001.2 118.02,102.2 118.01,102.21 PR26002.2 118.01,103.46 v1(118.14,103.6)
N27758909: length 2.8
  BOTTOM w0.114: PQ26005.3 116.75,87.85 v1(116.49,87.59) 116.29,87.39 115.28,87.39 PR26006.1
N27758919: length 2.9
  BOTTOM w0.114: v1(114.76,90.74) 114.76,90.92 115.08,91.24 PR26008.2
  BOTTOM w0.508: PQ26005.2 116.62,90.22 PR26008.2
N27758929: length 4.6
  BOTTOM w0.114: PR26008.1 115.48,91.89 114.96,91.89 v1(114.76,92.09)
  BOTTOM w0.508: PR26008.1 PR26009.2 118.59,92.02 PQ26004.3
N27758969: length 3.5
  BOTTOM w0.114: v1(115.35,94.96) 115.35,94.71 116.5,93.55 PR26007.2
  BOTTOM w0.508: PQ26004.2 117.94,93.53 PR26007.2
N28417448: length 1.3
  TOP w0.254: PR18000.2 306.25,67.65 306.23,67.63 PU18000.6
N28417565: length 2.3
  BOTTOM w0.508: PC18013.2 301.36,65.19 v1(300.95,65.19) 300.74,64.99 PR18004.1
N29149167: length 2.1
  BOTTOM w0.254: D9001.1 199.41,24.08 v1(199.04,23.71) 198.83,23.93 R9280.1
N29485598: length 2.2
  BOTTOM w0.114: LED9002.2 v1(299.88,29.84) 299.72,29.68 R9374.1
N29485608: length 2.8
  BOTTOM w0.114: v1(271.54,46.81) R9375.1
  BOTTOM w0.203: LED9003.2 270.67,45.9 270.83,45.73 R9375.1
N29486150: length 3.9
  TOP w0.114: U12003.1 49.86,63.35 50.04,63.54 50.04,63.79 49.68,64.15 R18003.2 R18004.2 v1(48.8,65.47)
N29486152: length 9.5
  TOP w0.114: U12003.2 49.77,62.7 49.97,62.5 49.97,61.51 50.2,61.29 C12037.2 R18006.2 48.23,60.93 47.94,61.23 47.94,61.99 48.22,62.27 48.22,64.15 v1(48.17,64.2) 47.86,64.2 47.48,63.82 D9003.2
N29490156: length 6.5
  TOP w0.076: v3(266.94,29.22) 266.94,29.35 266.61,29.68 266.61,30 266.42,30.19 266.4,30.19 266.27,30.32
  TOP w0.114: R18008.2 264.19,33.64 v1(264.19,33.11) 265.34,31.96 265.34,31.71 266,31.05 266,30.59 266.27,30.32
  BOTTOM w0.114: U6001.J4 v3(266.94,29.22)
N29550422: length 3.7
  TOP w0.114: Q9046.2 54.39,60.42 54.26,60.3 54,60.3 53.89,60.41 Q9046.3 53.89,61.62 v1(53.69,61.81) 53.69,61.99 R18011.2
N30251420: length 2.9
  TOP w0.114: v1(183.17,157.44) PR20060.2 183.8,158.11 183.95,158.26 184.77,158.26 184.96,158.07 PU20004.12
N30251430: length 2.4
  TOP w0.114: PR20061.2 182.99,155.03 v1(183.06,155.11) 183.09,155.13 183.09,155.36 183.78,156.05 PU20004.15
N30251475: length 4.8
  TOP w0.114: v1(188.88,159.86) 188.85,159.83 PR20062.2 188.85,157.54 188.09,156.78 188.09,156.4 187.74,156.05 PU20004.6
N30251477: length 3.6
  TOP w0.114: PU20004.9 186.46,159.08 186.44,159.09 PR20063.2 186.44,160.01 186.34,160.11 185.45,160.11 v1(185.2,159.86)
N30251495: length 19.7
  TOP w0.114: PU20004.10 185.96,158.26 v1(185.38,158.84) ; v1(181.9,157.19) 182.07,157.02 183.34,157.02 183.37,157.05 PU20004.13 ; PU20004.7 187.73,156.55 187.87,156.68 187.87,157.57 v1(187.74,157.7) ; v1(181.61,154.15) PR20072.1 183.66,154.52 183.66,155.32 183.89,155.55 PU20004.16
  IN1 w0.076: v1(187.74,157.7) 186.52,157.7 v1(185.38,158.84) 184.74,158.21 182.91,158.21 v1(181.9,157.19) 182.4,156.68 182.4,154.95 v1(181.61,154.15)
N30251533: length 45.5
  TOP w0.114: v1(181.9,156.55) 182.16,156.55 PR20066.1 183.42,156.55 PU20004.14 ; PR20067.2 v1(149.64,153.13)
  IN2 w0.089: v1(181.9,156.55) 181.64,156.3 181.21,156.3 179.52,157.99 173.98,157.99 172.88,159.09 166.48,159.09 166.21,158.82 163.69,158.82 163.58,158.93 163.27,158.93 162.75,158.41 161.11,158.41 160.7,158.82 158.09,158.82 157.86,159.06 156.78,159.06 156.54,158.82 155.69,158.82 155.32,159.19 153.62,159.19 153.25,158.82 149.58,158.82 148.62,157.87 148.62,154.14 v1(149.64,153.13)
N30251545: length 43.1
  TOP w0.114: v1(189.29,158.46) 189.42,158.32 PR20068.1 190.02,158.08 188.88,156.94 188.63,156.94 188.32,156.63 188.32,156.12 187.75,155.55 PU20004.5 ; PR20069.2 v1(157.51,153.13)
  IN3 w0.089: v1(157.51,153.13) 157.51,153.25 160.31,156.05 160.31,157.94 160.77,158.41 162.69,158.41 163.42,159.14 163.8,159.14 164.16,158.78 169.2,158.78 169.58,159.16 180.25,159.16 180.63,159.55 188.2,159.55 v1(189.29,158.46)
N30251549: length 28.9
  TOP w0.114: PU20004.8 v1(187.21,158.08) 187.61,158.49 PR20070.1 ; PR20071.2 v1(165.77,153.13)
  IN3 w0.089: v1(165.77,153.13) 165.77,153.38 167.55,155.16 168.82,155.16 172.5,158.84 180.17,158.84 180.7,159.37 186.96,159.37 187.36,158.97 187.36,158.23 v1(187.21,158.08)
N30251553: length 54.1
  TOP w0.114: v1(181.9,157.82) 182.96,158.89 183.1,158.89 PR20064.1 184.44,159.35 184.82,158.98 184.82,158.79 185.46,158.15 PU20004.11 ; PR20065.2 137.7,153.13 v1(137.57,153.25)
  IN2 w0.089: v1(181.9,157.82) 180.25,157.82 179.9,158.17 174.06,158.17 172.95,159.27 166.4,159.27 166.13,159 163.76,159 163.35,159.42 161.39,159.42 160.97,159 158.17,159 157.93,159.24 156.71,159.24 156.47,159 155.76,159 155.4,159.37 153.55,159.37 153.18,159 149.5,159 147.19,156.68 142.22,156.68 139.05,153.51 137.83,153.51 v1(137.57,153.25)
N30292191: length 17.7
  TOP w0.254: PQ11005.6 223.17,17.73 223.06,17.62 PR11042.1 222.29,18.11 223.12,18.94 223.12,19.29 223.3,19.47 224.39,19.47 224.62,19.7 224.62,21.07 225.15,21.6 225.81,21.6 v1(226.35,22.14)
  BOTTOM w0.254: v1(226.35,22.14) 225.13,22.14 223.15,24.12 v1(223.15,26.91) 222.83,27.23 222.13,27.23 221.9,27 PQ11000.4
N30292231: length 4.8
  TOP w0.114: v1(227.24,21.68) 226.09,20.54 PQ11004.1 225.3,20.54 224.97,20.21 224.97,19.39 224.61,19.03 PQ11005.4
N30292255: length 4.2
  TOP w0.114: v1(223.12,18.23) 223.27,18.38 PQ11005.5 PQ11005.2 PR11040.1
N30292285: length 6
  TOP w0.114: PD11006.2 220.88,21.46 221.04,21.3 221.37,21.3 221.53,21.46 221.53,21.69 v1(222.28,22.44) 222.36,22.37 PR11043.1 223.47,21.46 223.81,21.12 PQ11004.2
N30295612: length 2.7
  TOP w0.114: PQ11005.3 226.27,19.03 226.76,19.52 PR11041.2 227.23,20.4 v1(227.24,20.41)
N30474489: length 3.2
  TOP w0.114: U6500.16 293.99,50.33 292.64,48.99 v1(292.61,48.99) R6513.2
N30634969: length 6.7
  TOP w0.114: D3002.2 53.89,46.69 53.78,46.8 C3085.2 53.79,47.4 54.2,47.81 54.2,48.66 R3082.1 53.62,49.24 52.89,49.24 v1(52.84,49.29) 52.11,48.56 R3027.2 52.11,48.11 51.85,47.84 Q3000.2
N30635290: length 8.7
  TOP w0.114: R3025.1 56.29,45.43 v1(55.91,45.05) 55.59,45.37 D3002.1 55.2,46.14 54.43,46.91 54.43,49.58 54.02,49.99 R3082.2 53.25,49.99 53.11,50.12 R3024.1
N30700095: length 5.2
  BOTTOM w0.114: R9031.1 R9032.1 v1(275.04,20.67) R17992.2 276.12,20.67 276.34,20.46 276.34,19.49 R17987.2
N30710492: length 5.1
  BOTTOM w0.114: R3092.2 R3091.1 58.32,46.95 v1(57.94,47.33) 57.18,48.09 57.18,48.99 57.31,49.11 Q3009.5
N30714432: length 6.1
  TOP w0.114: Q3010.3 48.4,46.46 v1(48.17,46.7) 48.17,46.93 48.69,47.45 R3017.2 R3023.2 50.19,47.45 51.22,48.48 R3027.1 51.33,47.99 51.35,47.97 Q3000.3
N30715592: length 4.8
  TOP w0.305: 51.72,46.57 52.19,46.57 52.35,46.42 Q3000.6 52.76,46.03 53.62,45.17 R3016.2 ; 51.72,46.57 51.85,46.45 Q3000.5 ; 51.72,46.57 50.71,46.57 v1(50.55,46.42)
N30790939: length 2.2
  TOP w0.114: v1(30.64,130.01) 30.25,130.4 R4014.2
  BOTTOM w0.114: Q4000.2 31.02,130.39 v1(30.64,130.01)
N30790954: length 2.8
  TOP w0.114: v1(31.91,128.36) 31.07,128.36 v1(31.02,128.31) 30.25,129.08 R4013.2
  BOTTOM w0.114: Q4000.5 v1(31.02,128.31)
N30794855: length 2.7
  TOP w0.114: Q9001.6 131.48,113.82 131.04,114.25 LED9000.1 v1(129.46,114.25)
N30917415: length 4.3
  TOP w0.114: R2231.2 229.41,84.15 R2232.2 228.28,83.37 v1(227.39,82.47) 227.16,82.24 U2008.1
N31652171: length 1.4
  BOTTOM w0.114: PC19008.1 124.24,141.29
  BOTTOM w0.203: 124.24,141.29 v1(124.24,141.9) 124.37,142.03 PR19039.2
N32334351: length 3.3
  BOTTOM w0.114: PR10004.1 PR10000.1 340.78,138.89 v1(341.41,138.27) 341.92,137.76 PQ10002.2
N32334559: length 21.3
  IN2 w0.508: v1(334.06,138.93) 334.94,138.05 v1(334.94,132.98)
  IN4 w0.508: v1(334.06,138.93) 336,137 342.55,137 342.93,136.62 v1(342.93,136.23)
  BOTTOM w0.508: PC25009.1 333.5,138.38 v1(334.06,138.93) 334.66,139.54 PQ10003.3 ; PR10003.1 PR10007.1 v1(334.94,132.98)
  vias: v1(345.22,135.85)
N32334561: length 2.2
  BOTTOM w0.508: PQ10002.3 343.95,138.9 344.08,139.03 v1(344.08,139.41) 343.69,139.79 v1(343.19,139.79)
N32334573: length 4.8
  BOTTOM w0.508: PR10005.1 336.58,138.65 336.33,138.39 PQ10003.2 335.85,137.5 v1(335.31,136.97) 335.31,136.82 334.94,136.45 PR10001.1
N32336654: length 3.7
  BOTTOM w0.114: v1(354.24,139.16) 354.11,139.03 353.19,139.03 352.71,139.51 352.11,139.51 PR10012.2 351.83,139.23 PR10015.1
N32336656: length 3.2
  BOTTOM w0.114: v1(349.41,139.59) 349.04,139.22 PR10020.1 349.53,138.77 349.54,138.78 PR10017.2 350.53,138.78 PR10015.2
N32336668: length 16
  BOTTOM w0.114: PQ10010.2 v1(345.73,135.19) 345.73,132.55 346.62,131.66 349.92,131.66 350.68,132.42 350.68,134.34 PR10018.1 353.23,136.62 353.6,137 PQ10008.3
N32338342: length 2.5
  TOP w0.114: PR10027.2 338.09,146.62 338.24,146.78 v1(338.24,147.08) 337.73,147.08 337.62,146.98 337.29,146.98 337.12,147.15 PQ10019.3
N32338344: length 13.6
  TOP w0.114: v1(336.07,150.33) 335.82,150.08 PQ10019.6
  TOP w0.508: v1(334.37,141.19) 334.5,141.06 PQ10013.4
  IN1 w0.508: v1(336.07,150.33) 336.07,147.36 337.14,146.28 337.14,144.6 334.37,141.84 v1(334.37,141.19)
  BOTTOM w0.114: v1(336.07,150.33) PR10031.1
N32338348: length 3.5
  TOP w0.114: PQ10019.5 PQ10019.2 336.47,146.97 336.33,146.83 335.85,146.83 335.53,146.51 PR10034.1
N32338352: length 15.1
  TOP w0.114: v1(334.37,145.81) 334.09,145.81 332.69,144.41 PD3.2 ; v1(341.41,150.46) 341.97,149.9 PR10028.1 341.47,149.45 341.2,149.19 PQ10016.2
  IN3 w0.089: v1(334.37,145.81) 334.37,146.98 336.71,149.32 340.27,149.32 v1(341.41,150.46)
N32338380: length 3.3
  TOP w0.114: v1(339.63,149.32) 339.5,149.19 PQ10016.1 337.95,149.82 337.39,149.82 337.12,149.55 PQ10019.4
N32372408: length 5.9
  TOP w0.114: PQ23005.5 109.08,90.44 109.25,90.61 109.61,90.61 109.73,90.48 PQ23005.6 109.73,88.38 v1(109.76,88.36) 109.89,88.23 110.26,88.23 PR23009.2 PR23012.1
N32372455: length 6
  BOTTOM w0.114: PQ23008.5 113.19,90.36 113.06,90.48 112.68,90.48 112.54,90.34 PQ23008.6 112.54,88.34 112.56,88.32 PR23018.1 112.56,87.87 PR23015.2 v1(110.9,87.09)
N32372459: length 2.8
  BOTTOM w0.114: PR23016.2 113.56,93.06 v1(113.57,93.05) 113.84,92.79 PQ23008.3
N32372479: length 124.5
  TOP w0.114: v1(115.63,96.74) 118.13,96.74 119.78,95.09 120.96,95.09 ; v1(113.39,95.57) 113.22,95.57 112.69,96.09 PR23008.1 ; v1(187.66,138.95) 187.66,137.84 188.8,136.69 188.8,134.81 189.36,134.25 190.58,134.25 190.79,134.46 190.89,134.46 191.13,134.71 191.34,134.71 191.85,135.21 191.85,136.11 191.47,136.49 PQ23003.2
  IN3 w0.089: v1(115.63,96.74) 115.63,98.64 118.58,101.59 124.06,101.59 131.84,109.36 137.25,109.36 138.89,111.01 142.38,111.01 143.31,110.07 147.2,110.07 148.64,108.63 152.76,108.63 153.47,107.91 157.16,107.91 157.84,108.6 170.67,108.6 172.24,110.17 172.24,114.64 172.5,114.9 174.1,114.9 174.45,115.25 174.45,121.07 176.18,122.8 176.61,122.8 176.76,122.95 176.92,122.95 177.63,123.66 178.49,123.66 179.36,124.53 179.36,127.04 186.67,134.35 186.67,137.29 187.68,138.3 187.68,138.93 v1(187.66,138.95)
  BOTTOM w0.114: v1(115.63,96.74) 115.09,96.74 113.92,95.57 v1(113.39,95.57)
N32372487: length 117.8
  TOP w0.114: PQ23004.2 191.01,144.21 190.05,143.25 188.65,143.25 v1(188.63,143.22)
  IN3 w0.089: v1(111.08,95.87) 111.23,96.03 112.76,96.03 118.5,101.77 123.99,101.77 131.76,109.54 137.17,109.54 138.82,111.18 142.45,111.18 143.38,110.25 147.27,110.25 148.72,108.8 152.83,108.8 153.54,108.09 157.09,108.09 157.77,108.78 170.6,108.78 171.99,110.17 171.99,115.28 172.52,115.81 173.92,115.81 174.28,116.17 174.28,121.14 174.57,121.44 174.57,122.56 175.61,123.6 175.78,123.6 176.61,124.42 178.21,124.42 179.18,125.39 179.18,127.11 186.49,134.43 186.49,139.03 188.22,140.76 188.22,142.81 v1(188.63,143.22)
  BOTTOM w0.114: PR23011.1 108.36,94.38 109.86,95.87 v1(111.08,95.87)
N32372499: length 122.8
  TOP w0.114: PR23010.2 184.92,143.21 184.69,142.98 184.69,140.93 185.33,140.3 186.98,140.3 v1(187.66,139.61) ; PQ23005.3 108.43,93.2 v1(110.62,95.39)
  IN3 w0.089: v1(187.66,139.61) 188.07,139.21 188.07,138.37 186.85,137.15 186.85,134.28 179.53,126.96 179.53,124.07 178.23,122.77 176.83,122.77 176.69,122.62 176.26,122.62 174.63,121 174.63,114.52 174.19,114.07 172.61,114.07 172.42,113.88 172.42,110.1 170.75,108.42 157.92,108.42 157.23,107.74 153.4,107.74 152.69,108.45 148.57,108.45 147.12,109.9 143.24,109.9 142.3,110.83 138.96,110.83 137.32,109.18 131.91,109.18 124.14,101.41 118.65,101.41 116.57,99.33 116.57,95.54 115.78,94.76 111.26,94.76 v1(110.62,95.39)
N32372521: length 6.4
  TOP w0.114: v1(115.73,89.63) 115.21,89.63 PR23017.1 PR23013.2 114.58,88.74 114.12,88.74 113.84,89.02 PQ23007.6 113.84,90.47 113.7,90.61 113.32,90.61 113.19,90.48 PQ23007.5
N32374859: length 2.7
  TOP w0.114: v1(90.48,62.07) 90.33,62.22 PR14016.2 89.8,63.48 PQ14002.3
N32376959: length 4.2
  TOP w0.114: PR22004.1 285.52,30.44 v1(285.27,30.19)
  TOP w0.178: PU22001.5 284.79,33.47 285.52,32.74 PC22014.1 PR22004.1
N32376975: length 2
  TOP w0.178: PU22001.12 283.98,36.78 283.93,36.83 283.93,36.9 v1(283.75,37.07) 284,37.33 PC22016.1
N32376979: length 1.9
  TOP w0.178: PC22017.1 284.97,37.12 v1(285.02,37.07) 284.84,36.9 284.84,36.83 284.79,36.78 PU22001.10
N32376989: length 3.2
  TOP w0.178: PU22001.3 283.98,33.03 v1(283.91,32.96) 283.25,32.3 PC22021.1 PR22007.1
N32380200: length 3
  BOTTOM w0.114: PQ26003.1 121.83,94.2 v1(121.44,94.58)
  BOTTOM w0.508: PQ26003.1 120.12,93.53 120.05,93.61
N32431871: length 3.3
  BOTTOM w0.114: PR11012.1 PR11015.2 255.05,14.44 v1(254.67,14.82) 254.51,14.66 PD11005.2
N32460418: length 2.7
  BOTTOM w0.114: v1(236,16.47) 236.23,16.7 PR11014.1
  BOTTOM w0.508: PR11014.1 236.93,17.6 PC11019.1
N32461932: length 2.9
  TOP w0.114: v1(236.51,7.33) 236.24,7.07 PR11030.1 235.36,7.07 234.41,6.11 PU11001.3
N32555675: length 3.5
  BOTTOM w0.114: PR15001.2 v1(206.92,33.28)
  BOTTOM w0.254: PR15001.2 PC15000.1 206.41,30.92 PU15000.11
N32555692: length 1.8
  TOP w0.508: PC15012.2 v1(203.87,31.28) PR15005.1
N32555708: length 3.2
  BOTTOM w0.254: PR15007.1 205.01,25.77 204.76,26.02 v1(204.76,26.56) 204.99,26.33 205.75,26.33 205.91,26.49 PU15000.6
N32555744: length 2.8
  BOTTOM w0.254: PU15000.3 207.41,26.57 v1(208.22,25.76) 208.82,25.16 PR15009.1
N32555746: length 2.6
  BOTTOM w0.254: PR15010.1 207.8,25.11 206.92,26 v1(206.92,26.02) 206.92,26.3 206.91,26.31 PU15000.4
N32555758: length 4.4
  BOTTOM w0.254: PR15008.2 203.99,25.97 203.49,26.48 v1(203.49,26.84) 204.2,26.84 205.37,28.01 PU15000.7
N32576682: length 2.8
  BOTTOM w0.254: PQ14001.3 99.47,72.1 v1(99.09,71.72) 99.09,71.09 99.35,70.84 PR14014.1
N32604102: length 2.7
  TOP w0.114: R8098.1 356.08,105.75 v1(355.89,105.55) 355.89,105.37 354.98,104.46 Q8012.2
N32605621: length 2
  TOP w0.114: v1(340.65,98.77) 340.52,98.9 R8574.2
  BOTTOM w0.076: U8500.A10 341.03,97.68 341.03,98.39 v1(340.65,98.77)
N32605622: length 2
  TOP w0.114: v1(340.65,98.13) 340.65,98.26 340.56,98.34 340.47,98.34 340.43,98.39 340.24,98.39 340.11,98.26 R8575.2
  BOTTOM w0.076: U8500.A11 340.47,97.55 340.62,97.55 340.69,97.62 340.69,97.69 340.87,97.87 340.87,98.06 340.8,98.13 v1(340.65,98.13)
N32606041: length 5.9
  TOP w0.114: R8573.1 340.15,95.1 340.15,94.67 339.99,94.51 338.71,94.51 338.35,94.15 338.35,93.42 338.64,93.13 339.05,93.13 v1(339.12,93.05)
  BOTTOM w0.076: U8500.L11 339.89,93.13 339.76,93.13
  BOTTOM w0.114: 339.76,93.13 339.2,93.13 v1(339.12,93.05)
N32606042: length 5.8
  TOP w0.114: v1(339.12,93.69) 338.79,93.36 338.73,93.36 338.58,93.52 338.58,94.05 338.8,94.28 340.08,94.28 340.38,94.58 340.38,95.1 340.52,95.24 R8572.1
  BOTTOM w0.076: U8500.K11 340.21,93.09 339.88,93.41 339.76,93.41
  BOTTOM w0.114: v1(339.12,93.69) 339.4,93.41 339.76,93.41
N32608552: length 30.2
  TOP w0.114: R7205.2 354.59,144.28 355.17,144.87 v1(355.17,144.92)
  IN4 w0.076: v1(338.61,132.43) 338.88,132.17 346.36,132.17 346.62,131.92 348.65,131.92 354.11,137.38 354.11,143.85 v1(355.17,144.92)
  BOTTOM w0.114: Q7120.3 339.88,133.4 339.85,133.43 R7141.1 339.12,132.96 339.25,132.83 R7142.2 v1(338.61,132.43)
N32654425: length 12.1
  BOTTOM w0.102: 267.42,71.85 266.53,71.85 266.06,71.37 264.84,71.37 264.27,70.8 263.91,70.8 263.46,70.35 U9002.BE39
  BOTTOM w0.114: 267.42,71.85 267.53,71.85 267.71,72.02 268.47,72.02 270.81,74.37 271.56,74.37 v1(271.58,74.39) 271.74,74.54 273.3,74.54 R9065.1
N32913947: length 8.6
  BOTTOM w0.254: 250.08,83.75 250.44,83.75 U9002.BE1 250.69,83.5 U9002.BE2 250.35,83.13 U9002.BD1 250.08,83.4 250.08,83.75 ; 250.08,83.75 250.08,83.95 250.22,84.09 250.22,85.31 249.84,85.69 249.21,85.69 248.76,86.13 248.76,86.63 249.09,86.96 v1(249.09,87.83) R9191.1
N32915328: length 2.1
  TOP w0.114: v1(251.3,81.74) 251.3,82.45 R9189.1
  BOTTOM w0.102: v1(251.3,81.74) 251.3,81.75 U9002.BE5
N32915331: length 3
  TOP w0.114: v1(251.94,81.7) 251.75,81.89 251.75,83.21 R9190.1
  BOTTOM w0.114: v1(251.94,81.7) 252.13,81.89 252.13,82.23 251.72,82.64 U9002.BE4
N32919695: length 6.3
  BOTTOM w0.114: U9001.A37 179.53,126.58 179.53,126.88 179.99,127.34 179.99,127.47 182.51,129.99 v1(183.17,129.99) 183.19,130.01 R9050.2
N33014852: length 9.6
  BOTTOM w0.076: 355.64,107.16 353.85,107.16 352.71,108.29 352.71,108.88 352,109.59 352,110.02 v1(351.7,110.33) 352,110.63 352,110.98 351.34,111.64 350.48,111.64 350.39,111.72 349.98,111.72 U8001.U2
  BOTTOM w0.114: R8023.1 355.74,107.16 355.64,107.16
N33014907: length 6.4
  BOTTOM w0.076: R8024.1 353.6,107.79 352.97,108.42 352.97,108.88 352.15,109.69 352.15,111.04 351.39,111.8 350.68,111.8 350.53,111.95 U8001.U1
N33019370: length 13.6
  TOP w0.114: v1(352.05,104.36) 352.25,104.36 353.59,105.7 R8025.2 R8028.1 352.84,106.77 v1(352.71,106.64) 352.71,106.46 R8026.2 351.5,104.98 351.19,104.66 350.63,104.66 349.97,105.32 349.97,106.57 349.38,107.15 R8029.1
  BOTTOM w0.114: R8027.1 354.12,104.23 352.18,104.23 v1(352.05,104.36)
N33282670: length 2.4
  TOP w0.114: v1(127.82,110.17) 127.82,111.05 R6404.1 127.72,111.15 U6402.1
N33283807: length 7.2
  BOTTOM w0.114: R5104.2 318.29,49.25 v1(318.29,48.55) 318.29,48.48 320.83,45.94 321.82,45.94 322.1,45.65 CON5100.75
N33283853: length 16.2
  TOP w0.114: v1(316.76,30.7) 316.62,30.55 316.62,22.34 v1(317.96,21) 318.45,20.51 318.45,19.6 317.76,18.91 D5100.1
  BOTTOM w0.114: CON5100.10 316.41,29.4 316.76,29.75 v1(316.76,30.7)
N33283871: length 2.6
  BOTTOM w0.114: CON5100.12 314.33,29.9 314.1,29.67 v1(313.85,29.67) R5102.1
N33283909: length 2.2
  BOTTOM w0.114: TP5100.1 313.84,43.9 CON5100.68
N33296743: length 3.1
  BOTTOM w0.114: U4000.36 29.41,121.84 29.62,121.63 29.62,120.87 29.5,120.74 v1(29.5,120.23) R4000.1
N33310214: length 3.1
  BOTTOM w0.114: CON5101.75 324.24,22.65 325,23.41 v1(325.18,23.41) 325.79,22.8 R5109.2
N33310227: length 2.5
  TOP w0.114: v1(317.1,6.31) 317.44,6.65 D5101.1
  BOTTOM w0.114: CON5101.10 317.01,6.4 v1(317.1,6.31)
N33310234: length 4.8
  TOP w0.114: v1(319.95,8.22) R5106.1 319.14,7.8 318.55,7.2 317.43,7.2 317.18,6.95 v1(317.1,6.95)
  BOTTOM w0.114: CON5101.12 317.05,6.9 v1(317.1,6.95)
N33310253: length 2
  BOTTOM w0.114: TP5102.1 314.08,20.9 CON5101.68
N33315294: length 6.1
  TOP w0.114: R7304.2 286.65,10.39 R7300.1 286.65,11.97 v1(285.91,12.71)
  BOTTOM w0.114: U7300.7 284.71,12.35 285.07,12.71 v1(285.91,12.71)
N33315355: length 3.9
  BOTTOM w0.114: U7300.23 285.36,19.54 285.05,19.85 284.78,19.85 C7303.1 284.02,20.38 283.24,21.16 R7302.2
N33315356: length 6.9
  BOTTOM w0.114: v1(284.16,22.62) 284.22,22.56 R7303.2 284.99,22.32 284.77,22.09 284.77,20.77 285.05,20.48 R7301.2 285.27,20.11 285.58,19.8 287.15,19.8 287.31,19.64 U7300.26
N33316932: length 5.9
  BOTTOM w0.114: R4007.2 19.28,127.11 v1(19.29,127.12) 19.47,127.3 C4008.2 19.47,128.24 19.97,128.74 19.97,130.52 Y4000.1
N33316952: length 3.8
  TOP w0.114: Q4001.2 29.13,129.5 29.37,129.26 29.37,128.23 R4012.1 R4011.2 30,127.09 v1(30.13,126.96)
N33316977: length 3.5
  TOP w0.114: R4008.2 TP22070.1 31.15,124.24 v1(30.64,123.74)
  BOTTOM w0.114: U4000.30 30.14,124.24 v1(30.64,123.74)
N33316979: length 2.9
  BOTTOM w0.114: U4000.12 22.47,126.24 22.26,126.46 R4009.1 23.1,128.3 v1(23.1,128.36)
N33316984: length 2.7
  BOTTOM w0.114: v1(21.12,120.75) R4004.1 22,121.63 22.22,121.84 U4000.1
N33317032: length 16.6
  TOP w0.508: U4001.4 28.99,137.5 v1(28.35,136.87) 28.99,136.23 U4001.3 ; U4001.9 28.99,143.85 v1(28.35,144.49) 28.99,145.12 U4001.10
  BOTTOM w0.508: v1(28.35,144.49) C4016.1 C4014.1 C4012.1 v1(27.35,140.04) C4010.1 C4018.1 27.85,136.87 v1(28.35,136.87)
N33317033: length 2.6
  BOTTOM w0.254: R4017.1 21.25,142.47 v1(21.27,142.46)
  BOTTOM w0.508: R4017.1 C4015.1
N33317035: length 2.9
  BOTTOM w0.254: R4018.1 21.25,146.28 v1(20.83,146.7)
  BOTTOM w0.508: C4017.1 R4018.1
N33317047: length 11
  BOTTOM w0.508: C4019.2 20.47,136.69 R4015.2 R4016.2 v1(20.47,141.06) R4017.2 R4018.2
N33317104: length 2.2
  BOTTOM w0.508: v1(21.25,137.92) R4015.1 21.77,137.07 21.95,137.25 C4011.1
N33317105: length 2.4
  BOTTOM w0.508: v1(22.55,139.84) C4013.1 R4016.1
N33344911: length 8.1
  TOP w0.114: TP9008.1 132.62,98.26 136.88,98.26 138.35,99.73 v1(138.35,100.56)
  BOTTOM w0.076: U9001.BT2 138.75,100.96 v1(138.35,100.56)
N33344918: length 7.6
  TOP w0.114: TP9007.1 134.3,98.49 136.66,98.49 137.77,99.6 v1(137.77,99.9)
  BOTTOM w0.076: v1(137.77,99.9) 138.84,99.9 U9001.BR1
N33344928: length 6.6
  BOTTOM w0.114: U9001.A36 179.4,125.66 179.79,126.04 179.79,126.68 180.29,127.19 182.1,129 182.86,129 v1(183.17,128.69) 183.47,129 R9049.2
N33351835: length 7.9
  BOTTOM w0.102: 243.49,77.35 244.1,77.35 244.71,76.74 245.01,76.74 245.29,76.46 U9002.AH4
  BOTTOM w0.114: R9111.1 239.58,79.7 241.01,78.26 242.4,78.26 243.31,77.35 243.49,77.35
N33355782: length 6.7
  BOTTOM w0.102: U9002.AW48 265.12,64.35 265.12,63.78 265.88,63.02 266.26,63.02 266.27,63.01
  BOTTOM w0.114: 266.27,63.01 268.1,61.18 268.64,61.18 TP9025.1
N33356879: length 7.1
  BOTTOM w0.102: 265.79,72.86 265.46,72.86 264.9,72.3 264.12,72.3 263.55,71.74 263.55,71.37 262.85,70.68 U9002.BD38
  BOTTOM w0.114: TP9030.1 268.15,72.35 266.3,72.35 265.79,72.86
N33510752: length 3.6
  BOTTOM w0.114: CON4201.23 336.25,7.78 335.82,7.36 335.46,7.36 335.46,7.36 334.8,7.36 v1(334.58,7.13) 334.45,7 R4214.1
N33510760: length 1.4
  BOTTOM w0.114: R4214.2 334.79,5.54 TP4201.1
N33531364: length 3.6
  TOP w0.114: U3600.5 340.83,14.53 341.03,14.73 ; R3610.2 341.79,15.79 341.28,15.29 341.28,14.98 341.03,14.73 ; U3600.4 341.23,14.52 341.03,14.73
N33531809: length 7.2
  TOP w0.114: v1(347.17,3.29) 346.56,3.29 345.92,3.94 R3604.2 345.92,4.42 345.24,5.09 344.74,5.09 344.43,5.4 344.43,5.91 343.95,6.39 R3607.1 343.95,7.66 343.73,7.88 U3600.47
N33579886: length 19.6
  TOP w0.114: v1(355,131.54) 355.38,131.92 R7191.2
  IN1 w0.076: v1(360.97,120.74) 361.98,121.76 361.98,126.84 361.22,127.6 360.46,127.6 359.82,128.23 359.82,129 359.47,129.35 359.09,129.35 358.43,130.01 357.03,130.01 355.76,131.28 355.25,131.28 v1(355,131.54)
  BOTTOM w0.114: v1(360.97,120.74) 360.72,120.5 R7100.1 359.74,120.5 D7170.2
N33579897: length 18.2
  TOP w0.114: R7192.2 v1(355,130.9)
  IN1 w0.076: v1(355,130.9) 355.23,131.13 355.7,131.13 356.97,129.86 358.36,129.86 359.02,129.2 359.4,129.2 359.67,128.93 359.67,128.17 360.39,127.45 361.16,127.45 361.83,126.77 361.83,122.87 v1(360.97,122.01)
  BOTTOM w0.114: D7171.2 359.39,123.58 359.82,123.15 R7101.1 360.59,122.9 360.97,122.52 v1(360.97,122.01)
N33708500: length 5
  TOP w0.114: U4103.1 337.28,74.32 336.58,75.02 v1(336.18,75.02) 336.2,75 R4131.2 336.62,74.09 337.04,73.67 U4103.2
N33708566: length 4.5
  TOP w0.114: U4102.2 336.86,70.04 336.42,70.48 R4132.2 336.1,71.29 v1(336.2,71.39) 336.35,71.39 337.05,70.69 U4102.1
N33864211: length 2.5
  BOTTOM w0.114: R3034.2 v1(11.21,53.68)
  BOTTOM w0.508: R3034.2 11.84,54.57 11.92,54.64 U3005.4
N33864385:
  vias: v1(54.52,53.18)
N33864703:
  vias: v1(48.55,58.89)
N33864761: length 2.1
  TOP w0.114: R3026.2 46.01,46.67 v1(45.96,46.62) 45.54,46.62 45.4,46.77 U3003.4
N34047388: length 4.2
  TOP w0.114: R635.2 58.2,46.45 v1(58.71,46.95) 58.34,47.32 58.34,47.75 58.61,48.01 58.88,48.01 59.11,48.24 59.11,48.76 59.23,48.87 U603.10
N34048694: length 2.7
  BOTTOM w0.114: v1(357.54,86.2) 357.27,86.46 R3201.1
  BOTTOM w0.508: R3201.1 356.01,86.46 355.96,86.52 U3201.3
N34892414: length 2.7
  TOP w0.114: LED9004.4 319.96,41.56 319.54,41.13 R9627.2 320.57,40.72 v1(320.68,40.83)
N34892436: length 1.5
  TOP w0.114: R18047.2 320.33,43.7 319.96,43.34 LED9004.3
N35265666: length 3.2
  TOP w0.114: R6358.2 97.72,3.34 98.03,3.04 Q6351.2 98.66,3.04 98.74,2.96 98.74,2.61 98.67,2.54 Q6351.3
N35690359: length 11.6
  TOP w0.254: v1(355.63,19.52) 355.47,19.36 Q3603.3 ; R3638.2 353.1,27.39 353.73,26.76 v1(353.73,26.63) 353.6,26.63 v1(353.22,26.25) 352.95,25.98 U3601.6
  IN1 w0.254: v1(353.22,26.25) 355.63,23.84 v1(355.63,19.52)
N35906868: length 2.6
  TOP w0.508: v1(104.88,62.45) PR14003.1 103.88,61.65 103.67,61.44 PC14006.1
N35907016: length 2.3
  BOTTOM w0.114: v1(99.22,65.11) PC14016.2
  BOTTOM w0.508: PC14016.2 PR14004.1
N36022935: length 4.3
  TOP w0.114: PR22005.1 41.55,58.65 v1(41.76,58.43)
  TOP w0.178: PR22005.1 PC22015.1 41.55,60.55 40.82,61.29 PU22000.5
N36022943: length 2.3
  TOP w0.178: PU22000.12 40.02,65.12 39.66,65.48 v1(39.66,65.75) 39.91,66 PC22019.1
N36022944: length 2.1
  TOP w0.178: PC22020.1 v1(40.93,65.75) 40.93,65.22 40.82,65.11 PU22000.10
N36022949: length 3.3
  TOP w0.178: PR22006.1 PC22018.1 39.16,60.7 v1(39.87,61.42) 40.02,61.57 PU22000.3
N36026151:
  vias: v1(180.7,148.07)
N36026175: length 2.2
  TOP w0.114: v1(185.82,151.09) PC17012.2
  TOP w0.508: PC17012.2 PR17013.1
N36026221: length 6.2
  BOTTOM w0.114: v1(190.58,147.87) 189.31,147.87 188.87,148.31 PR17015.1
  BOTTOM w0.254: PR17015.1 188.12,148.55 187.61,149.06 185.71,149.06 185.32,149.45 PU17000.7
N36430440: length 3.9
  BOTTOM w0.114: R9059.2 234.96,71.93 234.96,71.6 236.93,69.63 U9002.F3
N36430441: length 5.1
  BOTTOM w0.114: R9060.2 235.97,72.51 235.97,71.25 236.58,70.64 237.39,70.64 237.8,70.23 U9002.G3
N36798878: length 1
  BOTTOM w0.114: v1(245.02,152.11) 245.18,151.95 PR8004.2

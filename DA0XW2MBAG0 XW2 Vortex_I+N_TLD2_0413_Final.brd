# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SD_CLK_R: length 2.9
  BOTTOM w0.114: U7301.17 26.78,67.96 v1(25.88,67.07) 25.38,66.56 R7312.1
SD_CMD: length 34.7
  TOP w0.114: 35.81,58.27 36.22,58.68 D7304.2 ; 35.81,58.27 v1(35.8,58.26) ; 35.81,58.27 CON7301.2
  BOTTOM w0.114: v1(35.8,58.26) 35.52,57.98 35.52,57.37 31.4,53.25 27.06,53.25 24.92,55.39 v1(24.92,56.73) 24.92,58.32 24.81,58.43 24.53,58.43 24.42,58.32 24.42,57.25 24.3,57.14 24.02,57.14 23.91,57.25 23.91,62.04 22.64,63.31 22.64,68.16 23.07,68.59 R7311.2
SD_CMD_R: length 2.4
  BOTTOM w0.114: U7301.19 v1(25.81,68.76) 25.43,68.76 25.27,68.59 R7311.1
SD_D0: length 32.8
  TOP w0.114: CON7301.7 35.59,69.77 v1(35.67,69.7) D7300.2 EC9047.1
  IN1 w0.076: v1(28.12,62.73) 28.81,62.73 29.72,63.64 30.13,63.64 35.37,68.88 35.37,68.97 35.11,69.23 35,69.23 30.1,64.32 29.99,64.32 29.8,64.5 29.8,64.64 34.86,69.7 v1(35.67,69.7)
  BOTTOM w0.114: R7313.2 24.86,64.01 25.56,63.31 26.42,63.31 27.01,62.73 v1(28.12,62.73)
SD_D0+: length 36.7
  TOP w0.114: CON7301.11 33.59,56.97 33.46,57.1 33.46,58.54 30.94,61.05 30.94,62.78 31.63,63.46 31.63,71.43 31.52,71.54 31.31,71.54 31.2,71.43 31.2,66.42 31.08,66.31 30.88,66.31 30.77,66.42 30.77,71.67 30.52,71.93 28.81,71.93 28,72.73 28,73.67 27.79,73.88 v1(26.63,73.88)
  BOTTOM w0.114: v1(26.63,73.88) v1(27.17,73.33) 27.39,73.12 27.51,73.12 28.2,72.43 28.2,72.17 28.34,72.03 U7301.26
SD_D0-: length 36
  TOP w0.114: CON7301.12 32.93,59.47 31.45,60.95 31.45,62.68 32.06,63.29 32.06,68.58 32.18,68.7 32.51,68.7 32.62,68.58 32.62,64.9 32.73,64.78 33.04,64.78 33.15,64.9 33.15,71.77 32.67,72.25 28.8,72.25 28.23,72.83 28.23,73.77 27.38,74.61 v1(26.45,74.61)
  BOTTOM w0.114: v1(26.45,74.61) 26.09,74.26 26.09,73.73 27.08,72.73 27.49,72.73 27.94,72.28 U7301.25
SD_D0_R: length 4.9
  BOTTOM w0.114: R7313.1 24.64,65.47 v1(24.8,65.62) 25.43,66.26 26.11,66.26 26.62,66.77 27.82,66.77 27.94,66.89 U7301.16
SD_D1: length 33.7
  TOP w0.114: EC9048.1 D7301.2 35.63,70.82 v1(35.49,70.96) 35.18,71.27 CON7301.8
  IN1 w0.076: v1(28.12,63.39) 27.36,63.39 27.26,63.49 27.26,64.48 27.48,64.7 29.18,64.7 34.57,70.09 34.57,70.2 34.36,70.41 34.26,70.41 29.47,65.63 29.37,65.63 29.16,65.84 29.16,65.94 34.17,70.96 v1(35.49,70.96)
  BOTTOM w0.114: v1(28.12,63.39) 27.59,63.39 v1(27.39,63.18) 27.01,63.57 25.89,63.57 25.66,63.79 R7315.2
SD_D1+: length 36
  TOP w0.114: CON7301.16 35,66.97 v1(35.55,66.42)
  IN4 w0.076: v1(35.55,66.42) 33.94,66.42 33.69,66.66 33.48,66.66 33.41,66.59 33.41,66.08 33.33,66 33.1,66 33.03,66.08 33.03,66.59 32.95,66.66 32.72,66.66 32.65,66.59 32.65,66.08 32.57,66 32.34,66 32.26,66.08 32.26,66.59 32.19,66.66 31.96,66.66 31.88,66.59 31.88,66.08 31.81,66 31.58,66 31.5,66.08 31.5,66.59 31.43,66.66 31.2,66.66 31.12,66.59 31.12,66.08 31.04,66 30.82,66 30.74,66.08 30.74,66.59 30.66,66.66 30.44,66.66 30.36,66.59 30.36,66.08 30.28,66 30.05,66 29.98,66.08 29.98,66.59 29.67,66.89 26.07,66.89 25.18,67.78 25.18,68.71 25.25,68.79 25.64,68.79 25.71,68.86 25.71,69.09 25.64,69.17 25.25,69.17 25.18,69.24 25.18,69.47 25.25,69.55 25.64,69.55 25.71,69.62 25.71,69.85 25.64,69.93 25.25,69.93 25.18,70.01 25.18,70.23 25.25,70.31 25.64,70.31 25.71,70.38 25.71,70.61 25.63,70.69 25.25,70.69 25.18,70.77 25.18,71 25.25,71.07 25.64,71.07 25.71,71.15 25.71,71.38 25.64,71.45 25.25,71.45 25.18,71.53 25.18,71.76 25.25,71.83 25.64,71.83 25.71,71.91 25.71,72.14 25.64,72.21 25.25,72.21 25.18,72.29 25.18,74.15 24.96,74.37 24.43,74.37 v1(24.04,73.98)
  BOTTOM w0.114: U7301.22 26.69,69.96 24.04,72.61 v1(24.04,73.98)
SD_D1-: length 36.3
  TOP w0.114: v1(35.58,64.85) 35.2,64.47 CON7301.15
  IN4 w0.076: v1(24.72,74) 24.72,73.23 24.34,72.85 23.73,72.85 23.65,72.78 23.65,72.55 23.73,72.47 24.64,72.47 24.72,72.4 24.72,72.17 24.64,72.09 23.73,72.09 23.65,72.01 23.65,71.79 23.73,71.71 24.64,71.71 24.72,71.63 24.72,71.4 24.64,71.33 23.73,71.33 23.65,71.25 23.65,71.02 23.73,70.95 24.64,70.95 24.72,70.87 24.72,70.64 24.64,70.57 23.73,70.57 23.65,70.49 23.65,70.26 23.73,70.19 24.64,70.19 24.72,70.11 24.72,69.88 24.64,69.8 23.73,69.8 23.65,69.73 23.65,69.5 23.73,69.42 24.64,69.42 24.72,69.35 24.72,69.12 24.64,69.04 23.73,69.04 23.65,68.97 23.65,68.74 23.73,68.66 24.49,68.66 24.72,68.43 24.72,67.6 25.81,66.51 28.99,66.51 30.65,64.85 v1(35.58,64.85)
  BOTTOM w0.114: v1(24.72,74) 24.72,72.33 26.69,70.36 U7301.23
SD_D1_R: length 4.4
  BOTTOM w0.114: U7301.15 28.34,66.76 28.07,66.49 26.73,66.49 26.07,65.83 v1(26.07,65.62) 26.07,65.2 R7315.1
SD_D2: length 35.1
  TOP w0.114: v1(32.76,53.27) CON7301.9
  BOTTOM w0.114: R7309.2 22.89,70.63 21.9,69.64 21.9,63.18 23.32,61.76 v1(23.32,55.34) 23.32,53.72 23.44,53.61 23.67,53.61 23.78,53.72 23.78,54.79 23.9,54.9 24.1,54.9 24.21,54.79 24.21,53.77 24.33,53.66 25.82,53.66 26.82,52.67 32.15,52.67 v1(32.76,53.27) 32.79,53.27 32.88,53.36 D7302.2 EC9049.1
SD_D2_R: length 2.8
  BOTTOM w0.114: U7301.21 26.36,69.56 v1(25.83,70.09) 25.29,70.63 R7309.1
SD_D3: length 35.7
  TOP w0.114: v1(35.59,53.18) 35.96,52.8 36.35,52.8 ; EC9050.1 D7303.2 36.35,52.8 ; 36.35,52.8 36.35,54.71 35.28,55.77 CON7301.1
  BOTTOM w0.114: R7310.2 23.58,69.61 22.28,68.32 22.28,63.18 23.6,61.86 23.6,56.28 26.93,52.95 31.53,52.95 32.52,53.94 34.83,53.94 v1(35.59,53.18)
SD_D3_R: length 4.5
  BOTTOM w0.114: U7301.20 26.5,69.16 26.45,69.21 25.31,69.21 R7310.1 24.45,70.07 v1(23.15,70.07)
SD_WP: length 18.4
  TOP w0.114: Q7301.2 30.26,77.69 30.27,77.68 R7333.2 R7331.1 v1(31.78,76.8) 31.78,76.49 31.58,76.29 30.44,76.29 30.26,76.11 30.26,75.84 30.44,75.66 31.6,75.66 31.78,75.47 31.78,75.21 31.6,75.02 31.08,75.02 30.89,74.84 30.89,74.57 31.08,74.39 32.1,74.39 32.29,74.2 32.29,73.94 32.1,73.75 29.95,73.75 29.75,73.55 29.75,73.3 29.94,73.12 32.93,73.12 33.27,72.77 CON7301.19
SD_WP_R: length 18.3
  TOP w0.114: R7333.1 30.39,78.46 30.14,78.7 Q7301.3 27.34,77.26 27.13,77.05 26.38,77.05 26.19,76.87 26.19,76.6 26.38,76.42 28.8,76.42 28.99,76.23 28.99,75.97 28.8,75.78 27.79,75.78 27.59,75.58 27.59,75.3 27.79,75.1 v1(30.21,75.1)
  BOTTOM w0.114: v1(30.21,75.1) 30.21,74.79 30.31,74.69 30.31,72.84 29.54,72.07 U7301.29
SDA_BAT_CHG: length 346.1
  TOP w0.114: PR11018.2 247.29,5.52 v1(247.16,5.65)
  IN3 w0.089: v1(12.59,65.51) 12.1,65.02 12.1,61.56 12.8,60.86 12.8,55.28 17.88,50.2 22.14,45.94 28.04,45.94 29.12,44.86 32.23,44.86 33.5,43.59 47.98,43.59 48.23,43.33 65.75,43.33 66.45,44.03 69.5,44.03 70.64,45.18 72.62,45.18 75.38,47.94 88.56,47.94 88.68,47.83 89.46,47.83 91.64,45.65 91.64,43.44 97.17,37.91 97.17,20.18 97.76,19.59 97.76,18.45 102.7,13.51 102.7,7.16 103.04,6.82 175.95,6.82 177.11,6.82 185.24,14.95 196.54,14.95 204.26,7.23 204.62,7.23 219.39,7.23 221.14,8.98 v1(221.27,8.98) 222.41,7.84 223.3,7.84 223.62,7.51 232.32,7.51 232.67,7.87 236.38,7.87 236.61,8.1 238.89,8.1 239.73,7.27 242.28,7.27 243.9,5.65 v1(247.16,5.65) 249.17,5.65 249.98,6.47 254.82,6.47 257.26,8.9 257.26,10.89 257.45,11.08 262.55,11.08 263.74,9.88 271.57,9.88 276.66,14.98 276.66,20.07 274.73,22 v1(274.73,22.06)
  BOTTOM w0.114: v1(221.27,8.98) 221.01,8.98 220.76,8.73 PD12001.3 PR12016.2 ; R6037.2 274.86,21.93 v1(274.73,22.06) 274.2,22.06 272.84,23.43 272.84,23.97 U6001.B12 ; Q3007.3 v1(12.59,65.51)
SDREG2: length 4.2
  BOTTOM w0.114: C7318.1 25.56,73.6 25.66,73.5 v1(25.66,72.99) 25.66,71.9 26.8,70.76 U7301.24
SEL_DP_MUX: length 350.8
  TOP w0.114: Q3001.3 84.49,65.14 84.49,63.46 84.11,63.08 R3042.1 83.85,62.71 83.67,62.53 83.67,60.28 84.39,59.57 84.39,57.84 84.55,57.67 84.55,54.13 86.65,52.03 88.74,52.03 92.53,48.24 92.53,44.73 93.99,43.27 94.36,43.27 98.98,38.65 98.98,19.38 99.35,19.01 v1(99.35,18.94) ; v1(333.03,39.28) 332.44,38.7 332.44,36.95 330.69,35.19 330.69,32.04 330.11,31.46 328.71,31.46 328.33,31.08 328.33,29.2 327.44,28.31 327.44,26.89 326.52,25.97 326.52,19.65 326.02,19.14 326.02,17.34 324.64,15.97 v1(324.64,12.16)
  IN1 w0.076: v1(340.03,49.74) 340.03,49.04 336.07,45.09 336.07,42 334.04,39.97 333.71,39.97 v1(333.03,39.28)
  IN3 w0.089: v1(324.64,12.16) 323.25,12.16 322.84,11.75 317,11.75 313.72,8.47 299.19,8.47 296.27,5.55 266.35,5.55 265.83,6.07 262.21,6.07 261.53,5.39 253.97,5.39 253.38,5.98 250.69,5.98 249.97,5.26 243.73,5.26 242.12,6.87 239.12,6.87 239.05,6.95 238.01,6.95 237.65,6.59 223.28,6.59 v1(222.79,7.08)
  IN4 w0.076: v1(222.79,7.08) 217.7,7.08 215.97,8.8 212.3,8.8 210.62,10.48 208.25,10.48 207.72,11.01 207.04,11.01 205.62,12.44 205.62,14.63 203.07,17.19 187.29,17.19 176.24,6.14 114.85,6.14 112.09,8.9 108.95,8.9 99.35,18.51 v1(99.35,18.94)
  BOTTOM w0.114: R545.2 332.23,38.49 v1(333.03,39.28) ; v1(340.03,49.74) 339.37,49.74 339.11,49.49 v1(338.36,49.49) 338.24,49.37 R517.2
SEL_EDP_MUX: length 49
  TOP w0.114: v1(53.68,58.64) 53.88,58.64 54.39,59.15 Q9046.5 ; U3007.54 64.33,57.6 v1(64.42,57.51) ; v1(81.57,54.9) 81.57,56.74 82.88,58.06 82.88,59.13 81.34,60.67 81.34,61.4 80.56,62.19 R3045.2 80.56,62.96 80.93,63.34 Q3002.3 79.43,63.95 v1(79.2,63.72)
  IN2 w0.089: v1(53.68,58.64) 54.95,57.37 60.33,57.37 61.12,58.16 63.77,58.16 v1(64.42,57.51) 65.18,56.75 65.18,55.46 66.2,54.45 68.58,54.45 70.01,53.02 76.16,53.02 77.84,54.7 81.36,54.7 v1(81.57,54.9)
SEN_A0: length 1.8
  TOP w0.114: v1(222.63,142.54) 222.71,142.46 R2502.1
  BOTTOM w0.127: VRAM2501.J10 223.03,142.95 222.62,142.54 v1(222.63,142.54)
SEN_A2: length 1.6
  TOP w0.114: R2501.1 199.29,142.06 v1(198.79,142.56)
  BOTTOM w0.127: VRAM2500.J10 v1(198.79,142.56)
SEN_B0: length 2.7
  TOP w0.114: v1(244.55,101.76) v1(243.76,102.56) R2521.1
  BOTTOM w0.127: v1(244.55,101.76) VRAM2503.J10
SEN_B2: length 2.4
  TOP w0.114: v1(244.57,124.16) 244.37,124.16 v1(244,123.79) 244,123.55 R2516.1
  BOTTOM w0.127: v1(244.57,124.16) 244.57,124.16 244.57,124.26 VRAM2502.J10
SER_IRQ: length 9.8
  TOP w0.114: v1(259.75,69.81) 261.46,69.81 261.81,70.17 262.47,70.17 263.31,71.01 263.68,71.01 264.14,71.46 265.01,71.46 265.28,71.19 265.89,71.19 266.76,72.06 266.76,72.38 R9056.2
  BOTTOM w0.114: U9002.AW35 259.88,69.69 v1(259.75,69.81)
SKTOCC_N: length 4.7
  BOTTOM w0.114: TP9003.1 138.53,123.76 138.64,123.66 139.13,123.66 U9001.BR33
SLP_A#: length 78.5
  IN1 w0.127: v1(298.2,27.78) 298.2,28.56 297.1,29.67 295.45,29.67 294.44,30.67 292.27,30.67 291.83,31.12 289,31.12 287.31,29.43 284.61,29.43 v1(284.21,29.02) 283.59,29.64 282.29,29.64 279.51,32.43 277.03,32.43 276.19,33.26 275.44,33.26 274.28,34.43 270.91,34.43 270.54,34.8 270.54,35.46 269.86,36.15 267.28,36.15 266.36,37.06 263.65,37.06 263.13,37.58 260.71,37.58 256.42,41.87 v1(255.94,41.87)
  BOTTOM w0.127: PR25013.2 294.29,27.65 294.77,27.17 295.56,27.17 295.84,26.89 297.31,26.89 v1(298.2,27.78) ; v1(255.94,41.87) 255.78,41.87 255.4,41.49 CON401.6 ; v1(284.21,29.02) 283.69,29.54 283.69,30.71 283.78,30.8 283.78,34.29 282.48,35.59 282.48,36.26 281.87,36.88 281.87,39.86 280.52,41.21 280.52,46.63 280.32,46.83 R9095.2
SLP_A#_L: length 41.4
  BOTTOM w0.102: U9002.BE40 264.17,69.84 265.1,70.77 266.91,70.77 266.94,70.79 267.48,70.79 268.07,71.38 268.09,71.38
  BOTTOM w0.114: R9595.1 v1(280.32,50.69) R9095.1 ; 268.74,71.38 268.09,71.38
  BOTTOM w0.127: R9595.1 279.76,52.2 279.76,53.3 280.12,53.66 280.12,54.24 277.53,56.83 277.53,61.46 280.12,64.05 280.12,66.6 279.51,67.21 279.51,69.18 275.28,73.41 273.26,73.41 272.95,73.73 272.21,73.73 272.09,73.61 270.98,73.61 268.74,71.38
SLP_LAN#: length 366.8
  TOP w0.127: v1(44.36,66.44) 44.36,65.72 44.26,65.62 44.26,62.09 44.02,61.85 44.02,60.87 TP22001.1 43.69,60.21 42.75,59.27 PR22005.2
  IN1 w0.127: v1(281.68,25.01) 281.68,25.05 281.48,25.25 278.8,25.25 276.7,23.15 276.08,23.15 275.6,22.67 275.6,22.16 274.2,20.77 274.2,18.99 272.62,17.41 270.92,17.41 270.01,16.5 264.88,16.5 263.3,18.07 260.94,18.07 260.03,18.99 260.03,19.8 260.18,19.95 260.18,21.37 257.94,23.61 257.94,24.15 257.01,25.09 256.71,25.09 253.85,27.95 253.54,27.95 251.88,29.62 232.35,29.62 227.79,25.06 218.53,25.06 213.63,20.16 206.34,20.16 203.36,23.13 199.12,23.13 198.56,23.69 197.99,23.69 195.33,23.69 194.75,23.12 190.35,23.12 189.68,22.44 179.53,22.44 179.16,22.07 159.91,22.07 159.42,22.57 148.39,22.57 148,22.18 137.81,22.18 136.81,23.18 107.5,23.18 104.85,25.83 104.85,30.14 103.51,31.48 103.51,34.53 102.23,35.81 102.23,41.53 101.77,41.99 101.77,42.64 96.69,47.72 94.53,47.72 90.73,51.51 89.64,52.61 81.3,52.61 80.85,53.05 68.61,53.05 67.63,52.06 65.66,52.06 64.55,53.18 63.04,53.18 62.82,53.4 59.99,53.4 58.69,54.7 58.69,57.82 56.12,60.39 56.12,62.29 52.07,66.33 44.46,66.33 v1(44.36,66.44)
  BOTTOM w0.102: 267.77,71.51 267.25,71 266.85,71 266.82,70.97 265.01,70.97 264.38,70.34 U9002.BF40
  BOTTOM w0.127: 267.77,71.51 267.96,71.7 268.6,71.7 270.84,73.94 271.95,73.94 272.07,74.06 273.08,74.06 273.4,73.74 274.95,73.74 275.42,73.74 279.56,69.6 279.84,69.31 279.84,67.34 280.45,66.74 280.45,63.92 277.86,61.33 277.86,56.99 280.47,54.37 280.47,53.74 281.12,53.09 281.12,48.69 281.38,48.44 281.38,46.76 281.46,46.67 R9598.1 281.22,45.82 280.93,45.53 280.93,41.26 282.2,39.99 282.2,37.05 283.66,35.59 285.06,35.59 285.45,35.2 285.45,34.74 284.11,33.4 284.11,30.72 284.64,30.19 284.64,28.67 284.12,28.15 284.12,26.11 283.43,25.42 282.1,25.42 v1(281.68,25.01)
SLP_S3#: length 727.2
  TOP w0.127: PR22008.2 261.33,37.29 v1(260.72,36.69) ; v1(32.29,92.67) 28.73,96.23 28.73,98.9 27.33,100.3 U7005.6 ; v1(86.67,73.37) 87.54,72.51 87.54,69.18 87.94,68.77 87.94,65.27 87.48,64.81 87.48,64.15 87.92,63.72 87.92,62.96 88.04,62.83 PQ14002.2 ; PR22006.2 38.38,59.13 38.51,58.99 40.57,58.99 41.56,58 41.97,58 42.2,58.23 42.2,58.66 42.37,58.84 42.81,58.84 44.35,60.38 44.35,61.71 44.59,61.96 44.59,65.25 44.86,65.52 44.86,66.77 43.97,67.65 43.97,70.86 43.12,71.71 41.19,71.71 40.11,72.79 40.11,78.4 v1(40.16,78.45) ; PU23000.2 111.62,98.39 110.68,97.45 110.68,97.45 106.67,93.44 v1(106.23,93.44) ; v1(355.25,107.53) 355.13,107.53 R8028.2 ; R288.1 265.09,19.27 R9285.1 265.84,18.26 v1(265.84,17.36)
  IN1 w0.127: v1(297.57,27.78) 297.57,28.31 296.54,29.34 295.31,29.34 294.31,30.34 292.13,30.34 291.69,30.79 291.33,30.79 289.08,28.54 285.02,28.54 283.5,27.01 283.5,26.76 v1(282.99,26.25) ; v1(282.99,26.25) 282.99,27.94 279.22,31.71 276,31.71 273.95,33.77 270.64,33.77 269.88,34.53 266.94,34.53 265.2,36.27 264.28,36.27 264.27,36.26 263.71,36.26 263.28,36.69 v1(260.72,36.69) ; v1(282.99,26.25) 282.31,25.58 278.62,25.58 277.95,24.91 276.97,24.91 275.38,23.32 274.72,23.32 273.34,21.93 273.34,20.4 273.03,20.1 273.03,18.62 272.15,17.74 270.54,17.74 270.29,17.49 266.16,17.49 266.03,17.36 v1(265.84,17.36) 265.55,17.36 264.51,18.4 261.49,18.4 260.97,18.93 260.97,19.75 260.51,20.21 260.51,22.19 258.45,24.25 258.45,24.98 257.97,25.47 256.8,25.47 253.98,28.28 253.68,28.28 252.01,29.95 232.21,29.95 227.65,25.39 218.4,25.39 213.49,20.49 206.47,20.49 203.48,23.48 200.58,23.48 199.98,24.08 190.62,24.08 189.73,23.19 188.31,23.19 v1(188.02,23.48) 187.31,22.78 178.62,22.78 178.53,22.86 176.27,22.86 175.67,23.46 171.51,23.46 170.45,22.4 160.05,22.4 159.07,23.38 148.74,23.38 147.86,22.51 137.99,22.51 136.99,23.51 107.63,23.51 105.18,25.97 105.18,30.28 103.84,31.62 103.84,34.67 102.57,35.94 102.57,42.28 v1(102.34,42.51) ; v1(86.67,73.37) 85.4,72.1 83.09,72.1 78.06,67.07 73.36,67.07 72.24,68.19 67.27,68.19 65.44,70.02 56.88,70.02 55.96,69.1 46.41,69.1 43.99,71.52 43.41,71.52 41.18,73.75 41.18,74.26 40.16,75.27 v1(40.16,78.45) 40.16,79.35 32.29,87.23 v1(32.29,92.67)
  IN2 w0.127: v1(86.67,73.37) 86.77,73.37 87.54,74.13 89.41,74.13 93.48,78.2 97.98,78.2 104.68,84.9 104.68,90.77 106.46,92.55 106.46,93.21 v1(106.23,93.44)
  IN3 w0.127: v1(355.25,107.53) 357.16,105.63 357.16,103.09 358.17,102.07 362.11,102.07 363.54,100.64 363.54,84.09 v1(363.41,83.96) 363.41,83.32 361.71,81.63 361.71,69.96 364.61,67.06 364.61,62.99 364.24,62.62 364.24,47.96 358.74,42.46 358.74,38.95 354.27,34.48 352.63,34.48 349.82,31.66 349.82,30.98 348.89,30.06 347.62,30.06 347.07,29.5 345.39,29.5 344.04,28.16 342.3,28.16 341.38,27.24 339.68,27.24 339.19,26.75 337.53,26.75 337.32,26.96 334.93,26.96 334.12,26.15 331.78,26.15 328.78,23.15 325.84,23.15 325.63,23.36 323.76,23.36 320.17,19.78 318.52,19.78 318.01,20.28 311.69,20.28 309.91,22.06 308.13,22.06 302.93,27.27 298.08,27.27 v1(297.57,27.78)
  BOTTOM w0.127: v1(260.72,36.69) 260.16,36.69 259.52,36.05 259.09,36.05 258.29,36.86 258.29,38.83 257.4,39.71 CON401.2 ; v1(363.41,83.96) 361.3,83.96 360.59,84.67 356.65,84.67 356.03,85.3 351.2,85.3 350.43,86.06 R3202.2 351,86.58 351.06,86.52 U3201.4 ; PR23028.1 197.87,16.91 197.09,17.69 190.28,17.69 188.02,19.95 v1(188.02,23.48) ; v1(355.25,107.53) 354.88,107.53 R8024.2 ; PU23001.1 109.77,88.75 109.63,88.61 109.25,88.61 109.13,88.74 PU23001.2 109.13,90.51 108.87,90.77 108.11,90.77 106.97,91.91 106.97,92.7 v1(106.23,93.44) ; v1(102.34,42.51) 97.7,42.51 97.06,43.14 97.06,45.18 103.17,51.29 103.17,61.52 101.79,62.9 101.79,69.02 101.05,69.76 101.05,72.94 100.74,73.24 100.74,75.4 98.2,77.94 96.04,77.94 93.5,75.4 89.31,75.4 87.28,73.37 v1(86.67,73.37) ; R9097.2 278.67,48.83 279.43,48.07 279.43,46.57 279.84,46.17 279.84,40.97 281.13,39.68 281.13,36.58 281.83,35.88 281.83,35.32 283.13,34.02 283.13,31.29 282.51,30.67 282.51,26.74 v1(282.99,26.25) ; v1(297.57,27.78) 297.06,27.27 295.94,27.27 295.44,27.77 PR25012.2
SLP_S3#_KBC: length 5.8
  TOP w0.076: 267.91,24.22 267.91,24.99 v3(268.24,25.32)
  TOP w0.114: R288.2 265.97,20.93 265.97,21.17 267.47,22.67 267.47,23.48 v1(267.49,23.51) 267.91,23.92 267.91,24.22
  BOTTOM w0.114: U6001.D6 v3(268.24,25.32)
SLP_S3#_L: length 33
  BOTTOM w0.102: U9002.BF42 265.36,69.54 265.78,69.95 267.25,69.95 267.27,69.98 268.41,69.98 268.52,69.87 268.64,69.87
  BOTTOM w0.114: 268.64,69.87 269.33,69.87 271.58,72.12 R9593.1
  BOTTOM w0.127: R9097.1 278.67,54.32 278.82,54.47 278.82,54.8 276.98,56.64 276.98,61.85 277.13,62 277.13,62.36 v1(277.68,62.91) 278.76,63.98 278.76,68.94 275.18,72.52 274.14,72.52 273.74,72.13 273.2,72.13 273.2,72.12 R9593.1
SLP_S3_5R: length 426.5
  TOP w0.114: Q8000.2 350.69,97.38 350.17,96.86 350.17,95.19 348.27,93.28 348.27,89.12 348.52,88.86 348.52,88.58 347.49,87.56 347.49,83.8 347.73,83.56 347.73,78.86 346.36,77.48 346.36,76.29 347.59,75.06 347.59,67.24 346.59,66.23 343.54,66.23 342.43,65.12 342.43,64.17 342.04,63.78 340.35,63.78 339.53,62.96 339.53,60.49 340.28,59.74 341.1,59.74 v1(342.04,58.79) 341.48,58.23 338.64,58.23 334.78,54.37 334.78,51.99 335.78,50.99 335.78,50.39 336.59,49.58 336.59,48.02 338.61,46 338.61,45.53 336.71,43.63 336.71,35.19 335.22,33.7 335.22,31.98 336.07,31.12 336.43,31.12 336.71,30.84 336.71,30.44 335.71,29.44 335.71,27.03 335.17,26.49 335.17,23.72 v1(335.21,23.68) ; PQ14002.6 87.52,62.18 87.66,62.32 87.66,62.71 87.55,62.83 PQ14002.5 85.88,62.83 85.76,62.71 PR14017.1 84.64,62.1 84.64,60.39 85.3,59.73 85.3,58.71 85.5,58.51 86.27,58.51 86.65,58.13 86.65,57.67 86.09,57.11 85.12,57.11 84.78,56.77 84.78,54.57 85.14,54.21 85.86,54.21 87.54,52.54 88.55,52.54 92.76,48.33 92.76,44.9 93.53,44.13 94.47,44.13 94.77,43.83 94.77,43.18 99.21,38.74 99.21,20.19 100.39,19.01 100.74,19.01 101.2,18.56 v1(101.2,17.87)
  IN1 w0.076: v1(335.21,23.68) 334.13,22.6 333.13,22.6 332.16,21.63 332.16,13.69 332.57,13.29 332.57,12.93 328.94,9.3 328.94,7.76 325.85,4.68 323.91,4.68 323.18,5.4 321.53,5.4 317.98,8.96 314.04,8.96 313.51,8.43 300.48,8.43 298.15,10.76 295.66,10.76 293.12,8.22 293.12,6.95 291.6,5.42 266.35,5.42 265.86,5.91 262.18,5.91 261.6,5.34 255.19,5.34 254.11,6.42 249.69,6.42 249.33,6.06 246.92,6.06 246.2,5.34 243.87,5.34 242.18,7.03 239.75,7.03 238.33,5.6 235.18,5.6 234.23,6.56 214.55,6.56 213.04,8.07 207.7,8.07 206.28,9.49 v1(206.28,10.63)
  IN3 w0.089: v1(101.2,17.87) 101.99,17.87 102.44,17.41 102.98,17.41 103.5,16.89 103.5,14.6 105.87,12.23 136.5,12.23 137.19,12.92 180.06,12.92 184.07,16.93 197.85,16.93 198.63,16.14 203.94,16.14 205.9,14.19 205.9,11.01 v1(206.28,10.63)
  BOTTOM w0.114: v1(342.04,58.79) 342.14,58.69 343.4,58.69 343.59,58.88 343.59,59.7 343.52,59.78 Q4105.2
SLP_S4#: length 576.8
  TOP w0.127: U7005.7 v1(26.07,100.8) ; v1(355.51,84.55) 354.81,85.24 U7003.4 ; v1(20.23,88.69) 20.43,88.69 20.96,88.15 21.7,88.15 22.95,89.41 22.95,92.36 22.42,92.89 U7004.4
  IN1 w0.127: v1(88.04,53.02) 89.68,53.02 90.87,51.84 93.51,51.84 101.7,43.65 102.27,43.65 102.9,43.02 102.9,36.08 104.17,34.81 104.17,31.75 105.52,30.41 105.52,28.4 106.09,27.83 106.61,27.83 110.34,24.09 136.94,24.09 138.2,22.84 147.73,22.84 148.68,23.79 175.81,23.79 176.41,23.19 178.67,23.19 178.75,23.11 186.32,23.11 187.31,24.09 189.83,24.09 190.15,24.41 203.24,24.41 203.98,23.67 203.98,23.45 205.9,21.53 v1(206.61,21.53) 207.32,20.82 212.93,20.82 218.5,26.38 228.18,26.38 232.08,30.28 252.15,30.28 253.81,28.62 254.12,28.62 256.23,26.51 v1(256.9,26.51) 257.51,25.9 258,25.9 258.78,25.12 258.78,24.38 260.84,22.32 260.84,20.35 261.3,19.89 261.3,19.06 261.63,18.73 264.65,18.73 265.56,17.82 270.15,17.82 270.41,18.07 272.02,18.07 272.7,18.76 272.7,20.23 273.01,20.54 273.01,21.88 v1(272.76,22.13) 272.99,22.35 273.28,22.35 276.17,25.24 277.81,25.24 279.33,26.76 280.57,26.76 v1(281.08,26.25) ; v1(26.07,100.8) 24.45,99.18 21.74,99.18 21.09,99.84 18.93,99.84 18.37,99.28 18.37,90.54 v1(20.23,88.69)
  IN2 w0.127: v1(20.23,88.69) 21.14,87.77 21.14,85.61 31.35,75.4 31.35,69.81 34.09,67.07 34.09,56.14 37.44,52.8 40.91,52.8 42.76,54.64 51.13,54.64 52.15,53.63 63.18,53.63 64.83,51.98 67.73,51.98 68.23,52.48 76.31,52.48 78.04,54.21 86,54.21 87.18,53.02 v1(88.04,53.02) ; v1(325.61,27.4) 325.61,27.2 327.14,25.68 329.92,25.68 330.72,26.48 334.22,26.48 335.27,25.43 338.93,25.43 339.15,25.64 340.38,25.64 341.29,26.55 341.29,27.38 341.31,27.41 341.31,32.24 346.25,37.17 349.4,37.17 350.81,35.77 357.67,35.77 358.91,37.02 358.91,45.73 355.62,49.02 355.62,59.99 352.71,62.9 352.71,64.96 353.47,65.72 353.47,77.53 354.48,78.54 354.48,83.52 v1(355.51,84.55)
  IN4 w0.127: v1(325.61,27.4) 325.1,26.89 320.15,26.89 318.95,28.08 309.05,28.08 308.38,28.75 306.75,28.75 305.98,27.98 304.9,27.98 304.12,28.75 295.06,28.75 294.57,28.26 290.64,28.26 290.34,27.96 285.66,27.96 284.65,26.96 281.78,26.96 v1(281.08,26.25)
  BOTTOM w0.127: v1(281.08,26.25) 281.08,26.41 280.7,26.78 280.7,30.47 282.28,32.04 282.28,33.67 280.98,34.97 280.98,35.5 278.9,37.58 278.9,45.4 276.74,47.56 276.74,51.98 276.41,52.31 R9098.2 ; D9001.3 199.3,26.26 198.94,26.61 R9281.1 196.88,25.34 196.88,22.44 197.9,21.43 206.51,21.43 v1(206.61,21.53) 207.27,22.19 207.27,24.73 PR15004.1 ; CON401.5 255.9,39.78 255.05,38.93 255.05,33.75 255.52,33.27 255.52,29.97 256.32,29.17 256.32,28.01 256.9,27.43 v1(256.9,26.51) ; R6022.1 275.91,23.55 276.64,22.82 276.64,22.18 276.35,21.9 276.35,21.9 275.77,21.33 274.2,21.33 273.4,22.13 v1(272.76,22.13)
SLP_S4#_KBC: length 6.5
  BOTTOM w0.114: R6022.2 275.3,24.33 275.04,24.07 v1(274.49,24.07) 274.48,24.08 274.48,24.47 274.63,24.63 274.63,25.34 274.15,25.82 274.15,26.56 273.89,26.82 272.82,26.82 272.63,26.63 272.13,26.63 U6001.F11
SLP_S4#_L: length 32.1
  BOTTOM w0.102: U9002.BE42 265.31,69.16 265.9,69.75 267.33,69.75 267.36,69.78 268.33,69.78 268.46,69.64 268.64,69.64
  BOTTOM w0.114: R9594.1 269.86,69.64 268.64,69.64 ; 276.41,55.31 276.41,55.6 v1(276.32,55.69)
  BOTTOM w0.127: R9098.1 276.41,55.31 ; R9594.1 270.77,69.92 272.68,71.83 273.83,71.83 274.14,72.14 275.1,72.14 278.43,68.81 278.43,64.51 276.83,62.91 276.83,62.26 276.55,61.98 276.06,61.98 275.76,61.68 275.76,60.47 275.61,60.32 275.61,57.82 276.32,57.1 v1(276.32,55.69)
SLP_S5#: length 58
  TOP w0.127: R9099.2 274.6,71.21 275.57,71.21 278.43,68.36 278.43,67.15 278.17,66.89 278.17,66.15 277.84,65.83 277.84,64.55 277.2,63.9 277.2,62.57 276.37,61.74 v1(276.37,61.54)
  IN2 w0.127: v1(276.37,61.54) 276.24,61.54 275.79,61.09 275.79,60.74 275.6,60.55 275.6,60.14 274.97,59.51 274.97,56.95 274.49,56.46 274.49,54.87 269.71,50.09 269.71,47.41 267.95,45.65 267.95,41.44 266.54,40.03 265.67,40.03 265.16,39.52 264.66,39.52 263.76,38.62 263.76,38.32 261.89,36.46 261.89,36.33 261.4,35.83 261.4,35.34 261.09,35.04 256.7,35.04 v1(256.27,34.53)
  BOTTOM w0.127: v1(256.27,34.53) 256.29,39.48 256.4,39.59 CON401.4
SLP_S5#_L: length 13.7
  TOP w0.114: v1(262.94,68.62) 263.26,68.94 263.26,69.12 263.82,69.69 268.4,69.69 268.73,70.02 v1(268.97,70.02) 269.06,69.92 R9600.1 270.99,69.92 272.79,71.72
  TOP w0.127: R9099.1 273.06,71.99 272.79,71.72
  BOTTOM w0.102: U9002.BC42 263.66,68.7 263.43,68.92 263.24,68.92 v1(262.94,68.62)
SLP_WLAN_N: length 21.4
  BOTTOM w0.102: 268.39,70.76 268.39,70.76 268.02,70.76 267.65,70.39 267.1,70.39 267.08,70.36 265.38,70.36 265.11,70.1 265.11,69.82 264.41,69.12 U9002.BD42
  BOTTOM w0.114: 268.39,70.76 268.84,70.76 271.23,73.15 272.28,73.15 272.4,73.26 272.75,73.26 273,73.01 273,72.94 TP9014.1 273.46,72.79 275.25,72.79 279.05,68.99 279.05,66.65 R9596.1
SM_INTRUDER#: length 132.3
  TOP w0.114: v1(263.55,67.75) 263.6,67.75 264.48,68.63 265.66,68.63 266,68.29 268.97,68.29 269.83,67.43 270.92,67.43 272.29,68.8 272.76,68.8 273.06,69.1 v1(273.08,69.1)
  IN2 w0.089: v1(320.2,32.98) 319.44,33.75 319.44,35.52 318.55,36.41 318.55,37.56 317.77,38.33 317.77,41.89 308.14,51.53 300.01,51.53 298.21,53.33 294.08,53.33 293.86,53.55 292.14,53.55 290.46,55.23 289.83,55.23 288.45,56.61 284.53,56.61 284.52,56.61 284.25,56.67 284.25,56.67 284.18,56.68 284.03,56.71 283.57,56.9 283.45,56.98 283.44,56.99 283.15,57.18 282.79,57.54 282.51,57.96 282.32,58.42 282.28,58.64 281.91,59.01 281.91,61.14 278.81,64.24 278.81,66.52 277.27,68.05 275.6,68.05 275.12,68.54 273.37,68.54 273.08,68.83 v1(273.08,69.1)
  IN4 w0.076: v1(320.2,32.98) 320.71,33.49 322.99,33.49 323.76,34.25 328.48,34.25 329.68,33.06 330.8,33.06 331.38,32.49 335.19,32.49 335.96,31.71 337.24,31.71 338.32,32.79 338.32,33.25 339.08,34.01 342.92,34.01 346.49,30.44 346.49,21 349.61,17.87 349.61,17.39 350.17,16.83 350.25,16.83 v1(350.27,16.8)
  BOTTOM w0.114: v1(263.55,67.75) 263.7,67.61 U9002.BB44 ; R9205.2 273.93,69.69 273.64,69.69 273.08,69.12 v1(273.08,69.1) ; Q9010.3 v1(352.38,15.97) 351.1,15.97 v1(350.27,16.8)
SM_RCOMP_0: length 9.7
  BOTTOM w0.254: U9001.G1 175.84,100.39 176.3,99.93
  BOTTOM w0.381: R9040.1 173.41,93.02 v1(174.18,93.79) 177.25,96.86 177.25,98.98 176.3,99.93
SM_RCOMP_1: length 7.4
  BOTTOM w0.254: U9001.H1 174.95,99.9 175.48,99.37
  BOTTOM w0.381: 175.48,99.37 176.23,98.62 176.23,97.47 v1(175.4,96.63) 173.82,95.05 R9041.2
SM_RCOMP_2: length 6.9
  BOTTOM w0.254: 174.45,99.74 174.45,100.84 U9001.J2
  BOTTOM w0.381: 174.45,99.74 175.72,98.47 175.72,97.85 v1(174.13,96.25) 173.94,96.07 R9042.1
SMBCLK: length 15.4
  TOP w0.114: v3(264.29,84.62) 263.2,83.53 262.64,83.53 Q9008.6
  BOTTOM w0.102: U9002.BE26 259.12,75.1 259.31,75.29 259.55,75.29 259.99,75.73 259.99,76 260.51,76.52 260.51,76.55 261.25,77.29
  BOTTOM w0.114: v3(264.29,84.62) 264.24,84.57 v1(264.24,83.84) 264.38,83.7 264.38,82.37 R9116.1 264.19,82.18 264.19,81.48 262.29,79.57 262.29,78.33 261.25,77.29
SMBDATA: length 13.2
  TOP w0.114: v3(264.69,84.22) 264.69,83.73 Q9008.3
  BOTTOM w0.102: U9002.BF26 259.54,75 260.2,75.65 260.2,75.88 260.82,76.5 260.82,76.54 261.88,77.59
  BOTTOM w0.114: 261.88,77.59 262.54,78.26 262.54,79.21 R9118.1 263.41,79.44 265.32,81.36 265.32,82.41 v1(265.14,82.6) 264.85,82.88 264.85,84.06 v3(264.69,84.22)
SMC: length 5.5
  BOTTOM w0.114: PCN12000.5 220.73,5.14 v1(221.14,5.55) PC12007.2 PR12015.1
SMD: length 6.1
  BOTTOM w0.114: PCN12000.6 219.82,3.29 v1(219.82,5.5) 219.82,5.55 219.11,6.26 PC12006.2 PR12016.1
SMDDR_VREF_CA_A: length 125.8
  IN4 w0.508: v1(132.87,25.24) 132.87,25.87 132.54,26.2 114.54,26.2 110.01,30.72 110.01,37.68 111.24,38.9 111.24,46.57 108.62,49.2 108.62,54.87 109.51,55.76 109.51,76.47 115.77,82.73 115.77,83.57 120.68,88.48 120.68,95.14 128.6,103.06 129.91,103.06 136.26,109.41 139.08,109.41 139.55,108.93 140.13,108.93 v1(141.04,108.02)
  BOTTOM w0.254: v1(141.04,108.02) 141.04,108.09 U9001.BN13
  BOTTOM w0.508: v1(132.87,25.24) 132.93,25.3 C1000.1 133.46,25.87 133.55,25.78 R1012.1
SMDDR_VREF_DQ0_M3: length 13.3
  BOTTOM w0.114: TP9006.1 128.07,105.98 130.21,108.12 136.73,108.12 137.34,108.73 139.75,108.73 U9001.BP13
SMDDR_VREF_DQ1_M3: length 139.7
  IN4 w0.508: v1(139.07,108.03) 138.85,108.03 138.49,108.39 136.68,108.39 130.33,102.04 129.08,102.04 121.7,94.66 121.7,87.22 110.52,76.05 110.52,55.34 109.63,54.45 109.63,49.62 112.26,46.99 112.26,38.48 111.03,37.25 111.03,31.14 114.78,27.4 133.61,27.4 134.63,26.38 141.33,26.38 142.02,25.69 142.02,24.6 144.18,22.44 148.88,22.44 v1(149.89,21.43)
  BOTTOM w0.254: U9001.BR13 139.42,108.38 v1(139.07,108.03)
  BOTTOM w0.508: v1(149.89,21.43) C1088.1 150.4,22.43 150.61,22.22 R1039.1
SML0ALERT#: length 9.8
  BOTTOM w0.102: U9002.BF24 258.64,75.79 258.91,76.05 258.91,76.14 259.27,76.51 259.44,76.68 259.44,76.81 260.36,77.73 260.37,77.73 260.74,78.09 260.74,78.66 260.91,78.82
  BOTTOM w0.114: 260.91,78.82 261.14,79.05 261.14,79.08 261.53,79.47 261.53,80.1 261.25,80.38 R9121.1 261.25,81.6 261.38,81.73 261.38,82.67 v1(261.76,83.04) 261.99,83.28 262.12,83.28 R9120.1
SML2ALERT#: length 11.6
  BOTTOM w0.102: U9002.AB47 258.23,59.13 258.86,58.51
  BOTTOM w0.114: R9195.1 261.25,51.25 260.58,51.93 R9193.1 259.34,51.93 257.97,53.3 257.97,56.6 258.96,57.59 258.96,58.41 258.86,58.51
SP_CLK: length 6.9
  TOP w0.114: v1(264,29.1) 263.53,29.57 262.45,29.57 v1(262.39,29.63) 262.18,29.84 262.18,30.48 261.94,30.71 261.49,30.71 261.1,31.11 R6224.2
  BOTTOM w0.114: v1(264,29.1) 264.54,28.56 265.65,28.56 U6001.H2
SP_DATA: length 4.9
  TOP w0.114: R6225.2 262.13,31.04 262.67,30.5 263.12,30.5 263.6,30.02 v1(263.87,30.02)
  BOTTOM w0.114: U6001.J2 265.65,29.21 264.92,29.21 264.1,30.02 v1(263.87,30.02)
SPI1_CLK: length 51.5
  TOP w0.114: R6190.1 306.17,47.1 303.05,43.98 v1(296.42,43.98) 295.92,43.98 295.71,43.78 294.6,43.78 294.44,43.93 294.44,45.14 294.04,45.55 v1(294.04,46.34) 294.16,46.47 R17980.1
  IN1 w0.076: v1(294.04,46.34) 293.54,45.85 292.41,45.85 292.34,45.93 292.34,46.24 292.26,46.32 292.03,46.32 291.95,46.24 291.95,45.96 291.84,45.85 289.38,45.85 287.2,48.02 286.06,48.02 285.96,47.92 285.96,47.46 285.88,47.39 285.66,47.39 285.58,47.46 285.58,47.94 285.5,48.02 285.27,48.02 285.2,47.94 285.2,47.46 285.12,47.39 284.89,47.39 284.82,47.46 284.82,47.92 284.72,48.02 284.16,48.02 282.67,49.51 280.81,49.51 277.85,52.47 277.32,52.47 274.12,55.67 v1(274.12,56.74)
  BOTTOM w0.114: v1(274.12,56.74) 272.92,56.74 v1(272.42,57.24) 271.58,58.08 R9200.1 ; R6016.2 293.8,47.06 294.03,46.83 294.03,46.35 v1(294.04,46.34)
SPI1_CLK_EC: length 74.7
  TOP w0.114: v1(290.74,17.62) 289.85,18.51 289.85,19.39 290.23,19.78 v1(290.61,19.78)
  BOTTOM w0.114: U6001.F12 272.57,27.05 274,27.05 274.63,26.43 v1(274.63,26.13) 277.02,23.73 v1(277.02,23.2) 277.02,22.06 276.79,21.83 276.79,19.17 276.36,18.73 276.36,17.04 277.9,15.5 279.22,15.5 279.79,14.92 287.51,14.92 288.25,15.66 289.47,15.66 290.61,16.8 290.61,17.49 v1(290.74,17.62) ; R6016.1 295.09,47.97 295.48,47.97 295.82,47.64 296.53,47.64 297.42,46.75 297.42,45.58 298.94,44.06 298.94,42.25 299.32,41.87 300.18,41.87 300.95,41.11 300.95,39.64 300.64,39.33 300.64,37.35 302.7,35.3 302.7,32.86 303.22,32.34 303.22,27.59 295.92,20.28 291.12,20.28 v1(290.61,19.78)
SPI1_CLK_ROM: length 12.9
  TOP w0.114: v1(308.17,49.44) 307.71,48.99 R6190.2
  BOTTOM w0.114: U6202.6 313.5,53.84 U6204.6 312.78,53.84 312.37,53.42 312.37,52.89 312.05,52.57 312.05,50.92 310.52,49.39 308.22,49.39 v1(308.17,49.44) 306.94,48.22 TP6201.1
SPI1_CLK_TPM: length 2.9
  TOP w0.114: U6500.19 296.05,49.17 v1(295.54,48.66) 295.26,48.38 294.69,48.38 R17980.2
SPI1_IO2: length 64.4
  IN1 w0.076: v1(300.11,48.66) 300.08,48.63 298.85,48.63 298.4,49.09 296.63,49.09 295.62,48.08 292.12,48.08 290.89,49.32 289.77,49.32 289.21,49.87 285.63,49.87 284.19,51.31 281.56,51.31 278.6,54.27 278.07,54.27 276.74,55.61 276.74,57.19 275.16,58.76 273.81,58.76 v1(273.35,58.3)
  BOTTOM w0.114: v1(300.11,48.66) 299.78,48.99 298.84,48.99 298.63,49.19 298.63,50.38 298.76,50.51 299.5,50.51 299.63,50.38 299.63,49.7 299.75,49.57 300.01,49.57 300.13,49.7 300.13,50.38 300.26,50.51 300.51,50.51 300.64,50.38 300.64,49.75 300.77,49.62 301.02,49.62 301.15,49.75 301.15,54 R6152.1 301.68,55.06 301.24,55.5 R6215.2 301.25,55.83 R6214.2 ; v1(273.35,58.3) 273.35,60.15 273.21,60.29 272.96,60.29 272.83,60.16 272.83,59.15 272.7,59.02 272.54,59.02 272.32,59.24 272.32,60.42 272.19,60.55 271.94,60.55 271.81,60.42 271.81,60.16 271.7,60.05 271.54,60.05 271.32,60.27 270.81,60.27 270.01,61.08 270.01,61.7 R9211.1 269.6,62.12 268.9,62.12 268.49,62.53 R9212.2 268.1,63.62 267.52,63.62 267.51,63.62 266.99,63.62 266.57,64.04 266.57,64.14 265.8,64.91 265.55,64.91 264.99,65.47 U9002.AY48
SPI1_IO3: length 67.3
  TOP w0.114: v1(273.97,58.28) 273.49,58.76 v1(272.19,58.76) 272.14,58.76 270.01,60.89 R9214.1 269.68,62.04 269.68,62.57 269.2,63.06 269.2,63.26 269.2,63.26 269.2,64.62 267.21,66.61 R9216.1 266.48,66.59 265.5,66.59 v1(265.18,66.91)
  IN1 w0.076: v1(273.97,58.28) 275.18,58.28 276.41,57.05 276.41,55.47 277.93,53.94 278.46,53.94 281.42,50.98 283.4,50.98 284.84,49.54 289.03,49.54 290.82,47.75 296.67,47.75 297.92,46.5 306.01,46.5 306.69,47.17 309.5,47.17 v1(309.95,46.72)
  BOTTOM w0.114: v1(309.95,46.72) 310.05,46.72 310.16,46.83 310.78,46.83 311.8,47.85 313.61,47.85 313.87,47.59 315.5,47.59 316.76,48.85 316.76,50.45 317.28,50.97 R6218.2 ; U9002.BA46 264.85,66.58 v1(265.18,66.91)
SPI1_SI: length 55.6
  TOP w0.114: R17983.1 296.33,45.22 v1(297.01,44.53) 297.52,45.05 298.2,45.05 298.85,44.4 302.6,44.4 305.62,47.42 305.62,49.16 306.17,49.71 R6188.1 ; v1(272.02,55.89) 271.96,55.84 v1(270.54,55.84) 269.03,55.84 R408.2 268.51,56.57 267.32,57.75
  IN1 w0.076: v1(297.01,44.53) 296.37,45.18 295.03,45.18 294.74,45.47 289.22,45.47 287.68,47 284.64,47 282.51,49.13 280.66,49.13 277.69,52.09 277.17,52.09 273.36,55.89 v1(272.02,55.89)
  BOTTOM w0.114: v1(297.01,44.53) 297.61,43.93 298.25,43.93 298.51,43.68 298.51,42.08 299.14,41.44 299.86,41.44 R6019.2
SPI1_SI_EC: length 62.7
  BOTTOM w0.076: U6001.H11 271.85,28.24 272.19,27.9 273.44,27.9 273.46,27.93
  BOTTOM w0.114: R6019.1 300.13,39.78 300.13,37.17 301.66,35.65 301.66,32.39 302.8,31.24 302.8,27.78 295.76,20.73 290.86,20.73 289.97,19.85 289.97,18.71 288.73,17.46 283.19,17.46 282.58,16.85 278.25,16.85 277.62,17.49 277.62,17.83 278.09,18.3 278.09,21.34 278.8,22.06 278.8,22.83 279.81,23.84 279.81,25.49 278.55,26.76 278.54,26.76 278.15,27.15 R6229.2 v1(276.33,27.27) 276.28,27.27 275.39,28.16 274.5,28.16 274.27,28.39 273.93,28.39 273.46,27.93
SPI1_SI_ROM: length 15.5
  TOP w0.114: R6202.1 307.84,50.1 v1(307.53,50.41) 307.23,50.1 R6188.2
  BOTTOM w0.114: TP6202.1 305.64,48.52 v1(307.53,50.41) 311.02,50.41 311.52,50.91 311.52,53.62 313.01,55.11 U6204.5 314.32,55.11 U6202.5
SPI1_SI_TPM: length 4
  TOP w0.114: R17983.2 296.96,46.76 v1(296.96,48.66) 297.05,48.75 U6500.21
SPI1_SO: length 48.3
  TOP w0.114: R17982.1 R6189.1 298.22,46.73 299.73,45.22 v1(299.73,45.21) ; R9335.1 v1(270.91,59.26) 272.53,57.64 273.41,57.64 273.44,57.61 v1(273.47,57.61)
  IN1 w0.076: v1(299.73,45.21) 300.9,45.21 300.97,45.28 300.97,45.63 300.87,45.73 297.51,45.73 296.25,46.99 289.78,46.99 289.59,47.18 289.05,47.18 287.45,48.78 284.49,48.78 283.05,50.22 281.11,50.22 278.15,53.18 277.62,53.18 275.61,55.19 275.61,56.77 275.27,57.11 273.96,57.11 v1(273.47,57.61)
  BOTTOM w0.114: R6035.2 301.4,41.26 300.51,42.15 300.51,42.61 300.31,42.81 300.31,44.62 v1(299.73,45.21)
SPI1_SO_EC: length 64.2
  BOTTOM w0.114: U6001.G12 273.13,27.59 273.21,27.52 274.87,27.52 v1(274.99,27.4) 274.99,27.19 275.95,26.23 278.56,26.23 279.43,25.36 279.43,24.22 278.31,23.1 278.31,22.16 277.66,21.51 277.66,18.64 277.2,18.18 277.2,17.38 278.25,16.33 282.65,16.33 283.36,17.04 283.79,17.04 283.95,16.88 283.95,16.45 284.07,16.33 284.27,16.33 284.39,16.45 284.39,16.87 284.5,16.98 284.7,16.98 284.82,16.87 284.82,16.54 284.93,16.42 285.16,16.42 285.27,16.54 285.27,16.89 285.43,17.04 288.9,17.04 291.71,19.85 296.08,19.85 303.64,27.41 303.64,34.95 301.07,37.52 301.07,39.13 301.4,39.46 R6035.1
SPI1_SO_ROM: length 10.3
  TOP w0.114: R6189.2 300.04,46.95 v1(300.72,47.63)
  BOTTOM w0.114: v1(300.72,47.63) TP6203.1 301.61,50.66 302.67,51.72 303.25,51.72 304.1,52.57 U6202.2 305.7,52.57 U6204.2
SPI1_SO_TPM: length 2.3
  TOP w0.114: R17982.2 299,48.13 299.29,48.43 v1(299.29,48.78) 299.16,48.92 298.82,48.92 298.55,49.2 U6500.24
SPI_CS0#: length 58.3
  IN1 w0.076: v1(274.1,57.66) 275.26,57.66 276.03,56.89 276.03,55.31 277.78,53.56 278.31,53.56 281.27,50.6 283.21,50.6 284.64,49.16 288.53,49.16 290.32,47.37 296.41,47.37 297.67,46.12 305.19,46.12 305.26,46.04 305.26,45.89 305.19,45.81 302.55,45.81 302.44,45.71 302.44,45.45 v1(302.67,45.22)
  BOTTOM w0.114: R9199.1 268.51,61.69 269.07,61.69 269.78,60.98 269.78,60.92 270.75,59.96 271.08,59.96 272.32,58.71 272.32,58.1 273.26,57.16 273.69,57.16 274.1,57.57 v1(274.1,57.66) ; v1(302.67,45.22) 302.66,45.22 302.17,45.71 R6030.2 R6201.2 302.17,50.49 TP6204.1 302.98,51.3 U6202.1 305.7,51.3 U6204.1
SPI_CS0#_EC: length 67.7
  BOTTOM w0.114: R6030.1 301.39,45.35 300.77,44.73 300.77,43.04 301.02,42.79 301.02,42.25 301.87,41.4 301.87,39.3 301.53,38.95 301.53,37.65 304.1,35.09 304.1,27.27 296.15,19.32 291.77,19.32 289.07,16.62 286.77,16.62 286.06,15.92 278.07,15.92 276.78,17.21 276.78,18.39 277.22,18.84 277.22,21.66 277.53,21.97 277.53,23.87 277.39,24 R6228.1 277.22,24.35 v1(276.4,25.17) 274.29,27.28 272.13,27.28 U6001.G11
SPI_TPM_CS#: length 51.5
  TOP w0.114: v1(291.37,46.62) 291.37,45.3 292.26,44.41 292.55,44.41 293.28,43.69 Q6501.1 ; R9202.1 264.86,63.94 264.86,63.62 265.01,63.46 265.03,63.46 266.48,62.02 266.48,61.43 269.48,58.43 v1(269.64,58.43) 270.11,58.91 270.27,58.91 270.46,58.72 270.46,58.56 269.99,58.08 269.99,57.92 270.18,57.73 270.34,57.73 270.81,58.21 270.97,58.21 271.16,58.02 271.16,57.86 270.8,57.5 270.8,57.26 271.63,56.43 271.81,56.43 271.94,56.56 271.94,56.99 272.07,57.11 272.32,57.11 272.45,56.99 272.45,56.1 272.57,55.97 272.83,55.97 272.96,56.1 272.96,56.99 273.08,57.11 273.34,57.11 273.46,56.99 273.46,54.57 273.59,54.45 273.84,54.45 273.97,54.57 273.97,56.1 274.1,56.22 274.35,56.22 274.48,56.1 274.48,54.7 274.61,54.57 274.86,54.57 274.96,54.68 v1(274.96,55.97)
  IN1 w0.076: v1(291.37,46.62) 289.68,46.62 289.45,46.85 288.91,46.85 287.36,48.4 284.33,48.4 282.84,49.89 280.97,49.89 278.01,52.85 277.48,52.85 274.96,55.37 v1(274.96,55.97)
SPI_TPM_CS#_L: length 4.6
  TOP w0.114: v1(261.18,67) v1(261.88,67) 262.01,67 262.35,66.66 262.87,66.66 263.92,65.62 R9202.2
  BOTTOM w0.114: 260.68,66.88 260.8,67 v1(261.18,67)
SPI_TPM_CS#_R: length 3.2
  TOP w0.114: R17981.1 295.18,46.75 295.23,46.7 295.23,46.14 295.45,45.92 295.45,45.04 v1(295.28,44.87) 294.89,44.48 Q6501.3
SPI_TPM_CS#_TPM: length 3
  TOP w0.114: U6500.20 296.55,48.83 296.2,48.48 R6502.2 R17981.2
SRTC_RST#: length 134.2
  TOP w0.127: Q6005.3 249.33,48.22 248.89,47.79 248.89,45.53 249.54,44.88 v1(249.54,44.21) ; v1(306.23,17.49) 306.23,16.9 C9190.1 306.98,16.14 R9136.2
  IN2 w0.127: v1(265.45,67.53) 265.59,67.39 265.59,66.72 265.13,66.25 265.13,65.78 263.94,64.59 263.94,64.04 263.48,63.59 263.48,63.57 263.3,63.39 263.3,63.04 262.16,61.9 262.16,61.18 260.51,59.53 259.74,59.53 252.51,52.3 252.51,49.5 252.13,49.11 251.49,49.11 249.79,47.41 249.79,44.46 v1(249.54,44.21)
  IN3 w0.127: v1(280.93,15.46) 280.93,15.29 279.18,13.54 279.18,10 280.19,8.98 284.13,8.98 284.84,8.27 297.2,8.27 302.5,13.56 302.5,14.94 304.16,16.6 305.34,16.6 v1(306.23,17.49)
  IN4 w0.127: v1(280.93,15.46) 280.93,18.91 279.43,20.41 275.62,20.41 275.37,20.66 274.35,20.66 273.46,19.78 270.54,19.78 269.65,18.89 268.26,18.89 267.82,19.32 267.82,20.21 266.61,21.43 265.97,21.43 265.34,20.79 262.67,20.79 261.78,21.68 261.78,22.82 261.14,23.46 259.62,23.46 258.96,24.12 257.36,24.12 v1(257.28,24.2)
  BOTTOM w0.114: 265.99,67.53 v1(265.45,67.53)
  BOTTOM w0.127: v1(257.28,24.2) 256.65,24.2 256.06,24.78 256.06,26.35 254.03,28.39 254.03,31.02 251.29,33.76 251.29,34.38 251.27,34.4 249.74,35.94 249.74,38.88 248.7,39.92 248.7,41.55 249.54,42.39 v1(249.54,44.21)
SSD1_CLK_REQ0#: length 99.1
  TOP w0.114: v3(268.64,79.62) 268.64,79.56 268.38,79.31 v1(268.38,78.96)
  IN2 w0.089: v3(268.64,79.62) 268.64,79.59 268.61,79.56 268.61,79.19 271.43,76.37 271.66,76.37 272.86,75.16 273.95,75.16 275.62,73.49 275.98,73.49 277.18,72.29 278.12,72.29 282.34,68.07 282.34,67.45 283.48,66.31 285.88,66.31 290.86,61.33 290.86,60.9 291.42,60.34 293.05,60.34 293.32,60.06 296.29,60.06 297.95,58.41 299.16,58.41 299.34,58.59 302.33,58.59 302.54,58.38 309.91,58.38 310.29,58.76 310.29,59.15 310.42,59.27 312.33,59.27 314.97,56.62 318.91,56.62 321.63,53.91 322.44,53.91 322.74,53.61 323.42,53.61 323.7,53.33 323.7,51.76 323.46,51.53 323.46,49.86 322.13,48.53 322.13,47.16 321.77,46.8 321.08,46.8 v1(319.73,45.46)
  BOTTOM w0.102: U9002.BF31 261.3,73.79 261.38,73.79 262.11,74.53 262.11,75.23 262.6,75.71 263.45,75.71 263.66,75.5
  BOTTOM w0.114: v3(268.64,79.62) 268.55,79.54 268.45,79.54 268.1,79.19 R9171.1 267.09,78.58 265.58,77.07 265.41,77.07 263.85,75.5 263.66,75.5 ; CON5100.52 316.35,39.9 316.54,40.1 316.54,41.82 316.9,42.18 318.85,42.18 320.05,43.37 320.05,45.14 v1(319.73,45.46)
SSD1_IF: length 91
  TOP w0.114: R9142.1 263.15,58.28 262.29,59.15 262.29,59.7 261.65,60.34 261.65,61.32 259.6,63.38 258.78,63.38 v1(258.73,63.32)
  IN4 w0.076: v1(258.73,63.32) 258.73,62.94 259.08,62.59 259.08,61.5 259.67,60.91 260.38,60.91 260.92,60.37 260.92,59.59 261.36,59.15 261.99,59.15 265.14,56 265.78,56 266.24,55.54 271.35,55.54 272.37,54.52 276.38,54.52 277.73,53.17 278.07,53.17 278.25,52.99 279.77,52.99 280.14,52.62 287.7,52.62 288.06,52.27 291.67,52.27 291.83,52.43 293.59,52.43 294.11,51.91 294.71,51.91 295.03,52.22 299.14,52.22 299.46,51.91 301.82,51.91 302.46,51.27 305.8,51.27 307.03,50.04 308.01,50.04 308.15,50.18 317.68,50.18 v1(317.86,50)
  BOTTOM w0.102: U9002.AJ43 259.31,63.48 258.88,63.48 v1(258.73,63.32)
  BOTTOM w0.114: v1(317.86,50) 317.87,50 317.87,48.63 315.84,46.6 313.44,46.6 313.04,47 312.2,47 311.2,46.01 310.93,46.01 310.42,45.5 310.42,45.06 309.71,44.35 309.71,42.94 309.52,42.75 R5111.1 309.52,41.62 309.66,41.48 Q5101.3
SSD2_CLK_REQ6#: length 113.3
  TOP w0.114: v1(318.9,48.71) 318.9,47.72 320.92,45.7 320.92,43.98 321.3,43.6 321.3,40.83 320.76,40.29 320.19,40.29 318.47,38.57 318.47,36.11 319.18,35.4 319.18,31.13 319.34,30.97 319.34,30.42 319.31,30.39 319.31,25.22 319.81,24.73 319.81,22.76 319.56,22.52 319.56,22.09 v1(319.36,21.88) v1(319.36,21.15)
  IN4 w0.076: v1(318.9,48.71) 316.82,48.71 316.21,49.32 314.05,49.32 313.14,48.4 307.17,48.4 306.29,49.29 302.3,49.29 300.85,50.74 298.97,50.74 298.61,50.38 295.06,50.38 294.13,49.46 292.98,49.46 292.64,49.11 292.08,49.11 291.78,49.42 289.78,49.42 288.77,50.43 285.02,50.43 284.13,51.32 280.25,51.32 279.58,51.32 279.18,51.72 277.73,51.72 277.54,51.9 277.15,51.9 275.82,53.23 271.61,53.23 271.33,53.51 267.7,53.51 267.42,53.79 264.85,53.79 264.03,54.61 262.57,54.61 261.59,55.59 260.69,55.59 260.05,56.22 v1(259.75,56.22)
  BOTTOM w0.102: U9002.AE47 259.21,60.9 258.86,60.54 258.86,60.16 259.29,59.73 259.29,59.38 259.81,58.86 259.81,57.11 ; 259.49,56.22 259.37,56.22 258.99,55.84 258.99,55.72
  BOTTOM w0.114: 259.81,57.11 259.81,56.29 v1(259.75,56.22) 259.49,56.22 ; 258.99,55.72 258.99,55.34 260.38,53.94 260.38,53.67 261.37,52.68 261.37,52.06 R9182.1 ; CON5101.52 317,16.9 317.21,17.11 317.21,19.81 318.19,20.79 319.01,20.79 v1(319.36,21.15)
SSD2_IF: length 106.5
  TOP w0.114: v1(321.11,39.2) 321.11,38.75 322.69,37.18 322.69,25.64 322.23,25.19 322.23,24.58 322.89,23.92 322.89,20.89 323.27,20.51 323.27,18.79 322.76,18.28 v1(321.9,18.28)
  IN1 w0.076: v1(275.21,50.44) 276.26,50.44 277.77,48.94 278.42,48.94 279.5,47.85 281.96,47.85 284.68,45.13 287.71,45.13 289.11,43.73 295.36,43.73 296.03,43.06 300.25,43.06 300.67,42.64 306.86,42.64 307.25,43.02 307.5,43.02 308.13,43.65 308.13,44.69 308.31,44.87 309.34,44.87 313.85,40.36 320.31,40.36 321.11,39.56 v1(321.11,39.2)
  BOTTOM w0.102: U9002.AM46 261.65,63.21 261.78,63.09 261.78,62.75 262.15,62.38 262.15,61.5 262.57,61.08
  BOTTOM w0.114: v1(321.9,18.28) 322.38,18.76 325.41,18.76 325.53,18.63 Q5102.3 326.04,18.9 326.04,19.89 R5103.1 ; v1(275.21,50.44) 273.54,52.11 273.54,53.48 270.8,56.22 269.9,56.22 R9144.1 268.94,54.75 268.31,54.12 267.85,54.12 266.99,54.99 266.99,55.23 266.02,56.2 265.7,56.2 263.41,58.49 263.41,59.27 262.95,59.73 262.95,60.69 262.57,61.08
STRAP0: length 7.7
  BOTTOM w0.114: R2098.1 223.55,93.29 223.55,94.56 R2099.2 221.66,96.44 221.66,98.69 221.28,99.07 U2000.J2
STRAP1: length 11.9
  TOP w0.114: v1(220.85,102.97) 220.63,102.75 220.63,99.79 222.03,98.39 222.03,95.35 R2024.2 221.77,94.59 221.77,93.94 221.52,93.69 221.52,92.9 R2036.1
  BOTTOM w0.114: U2000.J7 v1(220.85,102.97)
STRAP2: length 16.5
  TOP w0.114: R2032.1 223.49,89.18 222.66,90.01 222.66,91.53 222.92,91.78 222.92,92.27 R2030.2 223.55,92.9 223.55,93.77 224.13,94.34 v1(224.13,95.18) 223.08,96.23 222.98,96.23 222.66,96.54 222.66,98.52 221.19,99.99 221.19,101.59 v1(221.72,102.12)
  BOTTOM w0.127: U2000.J6 221.71,102.12 v1(221.72,102.12)
STRAP3: length 17.6
  TOP w0.114: R2097.1 224.4,89.78 223.55,89.78 223.25,90.08 223.25,90.82 223.35,90.92 224.34,90.92 224.95,91.53 224.95,92.27 R2096.2 224.57,92.9 224.57,93.93 v1(224.56,93.94) 224.75,94.13 224.75,96.13 224.42,96.46 223.07,96.46 222.92,96.61 222.92,98.64 221.67,99.89 v1(221.67,101.31)
  BOTTOM w0.102: U2000.J5 v1(221.67,101.31)
STRAP4: length 9
  BOTTOM w0.102: U2000.J3 220.89,99.7 220.89,99.12 220.96,99.04 220.96,98.64 220.94,98.61 220.94,98.31 221.19,98.05 221.19,97.19
  BOTTOM w0.114: 221.19,97.19 221.19,95.19 R2091.2 220.62,94.63 220.62,93.8 220.56,93.74 220.56,93.23 R2092.1 v1(220.12,92.78)
STRAP5: length 6.7
  BOTTOM w0.102: 221.42,97.19 221.42,98.2 221.28,98.34 U2000.J1
  BOTTOM w0.114: R2090.1 222.26,92.78 222.62,93.14 222.62,94.47 R2094.2 221.42,95.67 221.42,97.19
SUS_CLK_WLAN: length 125.8
  TOP w0.114: v1(348.52,46.32) 349.28,47.08 349.28,63.05 349.66,63.43 349.66,65.54 351.02,66.9 351.02,67.41 348.01,70.42 348.01,75.78 v1(346.87,76.93) ; R9122.2 273.1,66.39 275.35,64.14 275.35,58.65 275.54,58.46 275.56,58.44 276.82,57.18 276.82,57.18 277.86,56.14 v1(277.86,55.1)
  IN4 w0.076: v1(348.52,46.32) 348.14,46.7 345.6,46.7 345.22,46.32 339.66,46.32 339.01,46.97 337.72,46.97 337.22,46.47 334.73,46.47 334.04,47.16 334.04,48.96 333.58,49.42 329,49.42 327.37,51.05 317.09,51.05 316.93,50.89 309.28,50.89 308.77,51.4 306.64,51.4 306.08,51.96 305.35,52.69 299.64,52.69 299.43,52.91 294.74,52.91 294.53,52.69 294.3,52.69 293.85,53.15 292.09,53.15 290.99,54.24 283.04,54.24 282.77,53.98 282.77,53.83 282.61,53.66 281.64,53.66 280.21,55.1 v1(277.86,55.1)
  BOTTOM w0.114: R4113.1 348.15,76.79 347.89,77.05 347,77.05 v1(346.87,76.93)
SUSACK#: length 5.7
  BOTTOM w0.102: U9002.BE35 262.46,71.62 262.7,71.62 262.94,71.86 262.94,71.99 263.99,73.04 264.03,73.04 264.71,73.71 265.18,73.71
  BOTTOM w0.114: R9102.1 266.39,73.75 266.35,73.71 265.18,73.71
SUSCLK32: length 9.9
  TOP w0.114: R9122.1 R9100.1 270.69,65.5 268.92,65.5 266.45,67.96 265.72,67.96 265.47,68.2 v1(265.2,68.2)
  BOTTOM w0.114: v1(265.2,68.2) 265.64,68.2 U9002.BE45
SUSCLK32_KBC: length 65.7
  TOP w0.114: R9100.2 272.85,66.05 274.93,63.96 274.93,58.48 275.26,58.15 275.38,58.03 275.9,57.51 276.64,56.76 276.65,56.76 277.4,56.01 v1(277.4,55.54)
  IN1 w0.076: v1(281.72,26.25) 281.65,26.25 280.74,27.17 278.37,27.17 276.87,28.67 275.7,28.67 274.01,30.36 274.01,31.57 273.41,32.17 268.18,32.17 267.95,32.4 v1(267.49,32.4)
  BOTTOM w0.114: U6001.L5 267.92,30.19 268.25,30.52 268.25,31.94 267.79,32.4 v1(267.49,32.4) ; v1(281.72,26.25) 281.85,26.38 281.85,30.81 282.7,31.66 282.7,33.85 281.41,35.14 281.41,35.71 279.33,37.78 279.33,45.58 277.15,47.77 277.15,49.95 277.78,50.59 277.78,52.26 277.4,52.64 v1(277.4,55.54)
SUSWARN#: length 7.9
  TOP w0.114: v3(262.2,70.92) 262.2,71.3 v1(262.36,71.46) 262.45,71.55 262.93,71.55 264.53,73.15 v3(264.65,73.15)
  BOTTOM w0.102: v3(264.65,73.15) 264.67,73.17 264.7,73.17 265,73.48 265.99,73.48
  BOTTOM w0.114: U9002.BC37 262.38,70.67 262.2,70.84 v3(262.2,70.92) ; 265.99,73.48 266.24,73.48 266.48,73.24 267.37,73.24 267.63,73.5 R9102.2
SWP_PWR: length 1.4
  BOTTOM w0.114: CON9500.4 260.43,8.45 260.1,8.78 TP9501.1
SYS_PEX_RST_MON#: length 4.2
  TOP w0.114: R2038.2 220.37,85.56 v1(221.06,85.56) 221.91,85.56 R2023.2 222.48,86.14 U2001.4
SYS_PEX_RST_MON#_R: length 12.9
  TOP w0.114: v1(216.74,104.66) 216.95,104.45 216.95,103.56 217.15,103.36 217.71,103.36 217.91,103.16 217.91,100.95 218.35,100.52 218.35,99.4 219.49,98.26 219.49,96.92 219.74,96.67 219.74,94.71 219.32,94.28 R2035.2
  BOTTOM w0.114: v1(216.74,104.66) U2000.R8
TACH_FAN1_IN: length 361.1
  IN3 w0.076: v3(271.49,25.97) 271.17,25.64 269.25,25.64 268.6,26.29 265.97,26.29
  IN3 w0.089: v1(19.59,94.45) 19.77,94.28 19.77,91.12 20.63,90.26 20.63,85.48 24.25,81.85 24.25,77.91 14.59,68.25 14.59,59.37 25.86,48.1 31.85,48.1 34.12,45.83 57.07,45.83 57.69,46.45 59.56,46.45 60.36,45.65 68.36,45.65 69.64,46.93 72.45,46.93 74.82,49.3 89.13,49.3 89.24,49.19 90.2,49.19 93.35,46.04 93.35,44.82 93.86,44.32 94.54,44.32 98.53,40.33 98.53,21.51 100.14,19.9 100.14,19.74 100.81,19.07 104.24,19.07 107.03,16.28 142.53,16.28 143.68,15.13 179.83,15.13 183.37,18.67 203.73,18.67 207.47,14.94 212.78,14.94 213.87,16.03 216.53,16.03 217.41,16.91 217.41,17.88 222.83,23.31 234.28,23.31 239.96,28.98 250.2,28.98 251.02,28.98 252.19,30.16 256.52,30.16 257.58,29.1 257.82,29.1 259.44,29.1 260.51,28.03 261.4,28.03 262.21,27.22 262.21,26.61 262.53,26.29 265.97,26.29
  BOTTOM w0.114: CON6300.2 29.37,99.79 29.88,99.79 30.7,98.96 30.7,96.98 29.9,96.18 27.91,96.18 C6301.1 C6303.2 R6303.2 24.15,94.45 v1(23.02,94.45) v1(19.59,94.45) ; U6001.E10 v3(271.49,25.97)
TACH_FAN2_IN: length 143.1
  TOP w0.114: v1(326.73,68.85) 326.19,68.85 325.58,68.24 324.52,68.24 323.76,67.48 323.76,64.04 324.24,63.55 324.24,60.08 322.99,58.83 322.99,53.64 322.82,53.46 322.82,51.9 323.16,51.55 323.16,49.66 322.5,49 322.5,47.95 322.7,47.75 322.7,39.31 323.55,38.46 323.55,29.25 324.77,28.03 325.86,28.03 v1(326.5,27.4)
  IN4 w0.076: v3(267.59,25.97) 267.92,25.64 268.41,25.64 268.74,25.31 268.74,24.36 269.28,23.81 272.44,23.81 272.94,24.32 274.85,24.32 275.2,24.68 278.04,24.68 278.97,25.61 283.33,25.61 284.1,26.37 285.72,26.37 286.72,27.37 290.58,27.37 290.88,27.68 294.81,27.68 295.31,28.17 303.33,28.17 304.46,27.04 306.43,27.04 307.39,28 308.28,28 308.78,27.5 318.45,27.5 319.82,26.13 325.33,26.13 326.5,27.29 v1(326.5,27.4) ; v1(332.59,83.15) 332.59,80.18 328.68,76.27 328.68,69.81 327.54,68.67 326.9,68.67 v1(326.73,68.85)
  BOTTOM w0.114: U6001.E5 v3(267.59,25.97) ; CON6301.2 335.78,92.71 335.92,92.57 335.92,90.92 336.33,90.51 336.33,88.64 C6300.2 C6308.1 R6305.2 334.38,88.29 334.12,88.03 334.12,84.67 v1(332.59,83.15)

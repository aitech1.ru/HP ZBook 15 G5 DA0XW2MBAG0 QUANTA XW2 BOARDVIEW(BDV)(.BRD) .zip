# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_PROCHOT#: length 486
  TOP w0.114: PR19004.2 127.92,154.91 127.92,155.28 127.59,155.62 v1(126.7,155.62) ; v1(183.17,31.71) 183.17,31.25 184.11,30.32 184.11,19.1 181.89,16.88 181.89,9.16 182.84,8.22 v1(182.84,8.22) ; v1(321.6,7.71) 322.03,8.14 324.95,8.14 325.15,8.35 325.15,9.72 324.85,10.02 324.34,10.02 323.76,10.61 323.76,16.35 325.09,17.69 325.09,19.85 326.04,20.79 326.04,26.18 326.98,27.12 326.98,27.85 326.23,28.6 325.68,28.6 324.1,30.18 324.1,38.94 323.25,39.79 323.25,46.5 324.35,47.6 324.35,48.73 323.71,49.37 323.71,51.45 324.28,52.03 324.28,59.32 324.79,59.83 324.79,63.79 325.7,64.7 325.7,66.06 325.94,66.3 325.94,67.17 327.31,68.54 v1(327.31,69.18) ; v1(266.35,6.67) 266.86,6.16 PR12010.2 PR12009.2
  IN1 w0.076: v1(321.6,7.71) 320.83,8.47 318.68,8.47 318.04,9.11 313.98,9.11 313.45,8.58 300.66,8.58 298.18,11.06 295.64,11.06 292.81,8.24 292.81,6.85 291.54,5.58 266.83,5.58 266.35,6.06 v1(266.35,6.67)
  IN2 w0.089: v1(183.17,31.71) 184.16,31.71 184.82,32.38 184.82,34.65 184.14,35.33 184.14,47.43 185.28,48.57 185.28,65.87 181.29,69.86 181.29,87.53 179.48,89.33 179.48,93.18 181.95,95.65 182.5,95.65 182.76,95.91 184.61,95.91 189.48,100.79 189.48,120.93 190.6,122.04 191.08,122.04 191.8,122.75 191.8,127.55 190.47,128.88 v1(190.47,129.15) 190.47,132.41 189.67,133.21 189.67,147.4 188.87,148.2 188.87,149.82 189.48,150.43 189.48,150.93 190.28,151.73 190.28,153.46 189.52,154.22 189.52,154.7 186.38,157.84 183.83,157.84 182.37,159.3 176.32,159.3 174.35,161.27 140.68,161.27 139.92,160.51 139.92,157.39 138.18,155.65 133.88,155.65 133.28,156.25 131.1,156.25 131.02,156.17 127.26,156.17 v1(126.7,155.62)
  IN4 w0.076: v1(266.35,6.67) 265.87,6.19 263.3,6.19 263.15,6.34 251.34,6.34 249.84,4.84 241.57,4.84 240.75,5.67 239.73,5.67 238.53,4.46 234.8,4.46 233.71,5.55 217.36,5.55 215.84,7.08 206.79,7.08 202,11.86 202,14.48 201.07,15.41 187.42,15.41 182.54,10.53 182.54,8.51 v1(182.84,8.22)
  BOTTOM w0.114: v1(327.31,69.18) 327.31,69.46 326.68,70.09 325.96,70.09 325.18,70.87 325.18,74.9 324.53,75.54 Q6301.1 ; v1(190.47,129.15) 190.18,128.85 190.18,127.47 189.39,126.68 188.22,126.68 187.9,127 187.18,127 186.76,126.58 R9033.1 R9321.1 185.71,126.57 C9003.1 R9320.2 ; PR19019.1 127.92,154.91 127.92,155.28 127.59,155.62 v1(126.7,155.62)
CPU_PROCHOT#_R: length 293.6
  IN1 w0.076: v1(139.74,121.4) 140.28,120.87 141,120.87 142.27,119.6 142.27,117.18 142.58,116.88 142.58,109.18 141.97,108.57 138.31,108.57 137.55,107.81 134.22,107.81 133.55,107.14 132.35,107.14 131.45,106.24 131.45,105.2 129.49,103.24 126.27,103.24 117.07,94.04 117.07,92.09 116.2,91.21 116.2,88.39 114,86.19 114,79.72 106.02,71.74 104.27,71.74 104.05,71.51 104.05,69.7 v1(103.38,69.04)
  IN2 w0.089: v1(103.38,69.04) 104.05,69.04 107.65,65.45 107.65,49.55 108.49,48.71 108.49,39.46 109.73,38.21 109.73,35.42 113.82,31.33 144.13,31.33 144.95,32.15 180.43,32.15 183.19,34.91 183.19,47.83 184.44,49.08 184.44,65.31 180.45,69.31 180.45,87.18 178.52,89.11 178.52,93.59 181.41,96.48 181.55,96.48 181.78,96.71 181.78,97.05 182.05,97.32 182.83,97.32 183.27,96.89 184.18,96.89 185.17,97.88 185.17,98.58 186.65,100.05 186.65,100.5 188.65,102.5 188.65,121.99 v1(190.2,123.54)
  BOTTOM w0.114: v1(190.2,123.54) 189.51,123.54 187.49,125.56 R9321.2 ; v1(139.74,121.4) 139.74,121.49 139.44,121.8 U9001.BR30
CPU_VCCIO_PWR_GATE#: length 154.9
  IN2 w0.089: v1(239.68,85.69) 239.94,85.43 240.01,85.43 240.93,84.52 v1(242.91,84.52)
  IN4 w0.076: v1(182.61,96.53) 182.68,96.46 185.96,96.46 186.98,97.47 191.32,97.47 194.14,94.65 194.14,89.2 194.98,88.36 194.98,87.28 198.39,83.86 199.17,83.86 200.37,82.66 200.37,81.11 201.99,79.49 204.22,79.49 205.06,80.33 217.42,80.33 219.57,78.19 224.95,78.19 225.44,78.68 228.02,78.68 v1(228.07,78.63)
  BOTTOM w0.102: 244.7,85.63 244.71,85.61 245.72,85.61 246.06,85.28 246.63,85.28 247.05,84.87 247.05,83.44 248.02,82.46 248.17,82.46 248.33,82.31 248.45,82.18 248.61,82.18 248.95,81.84 248.99,81.84 249.47,81.36 U9002.AY3
  BOTTOM w0.114: 244.7,85.63 244.32,85.63 244,85.94 243.49,85.94 242.91,85.36 v1(242.91,84.52) ; v1(239.68,85.69) 239.16,85.69 238.91,85.94 238.37,85.94 238.03,85.6 236.55,85.6 235.35,84.4 234.73,84.4 233.35,83.02 232.09,83.02 231.16,82.09 230.81,82.09 230.28,81.56 230.28,80.55 228.36,78.63 v1(228.07,78.63) ; v1(182.61,96.53) 181.84,97.3 180.41,97.3 180.2,97.09 180.2,95.89 176.6,92.28 176.6,92.28 174.64,90.32 174.64,88.05 173.8,87.22 129.08,87.22 128.38,87.92 127.41,87.92 127.08,88.25 126.11,88.25 R17906.1 125.6,87.74 Q9035.1
CR_RST#: length 4.8
  BOTTOM w0.102: U9002.BD29 259.89,73.67 259.89,73.91 260.08,74.1 260.08,74.14 260.44,74.5 260.44,74.75 262.65,76.95 TP9028.1
CR_WAKE#: length 5.5
  BOTTOM w0.102: TP9040.1 263.71,77.28 262.97,76.54 262.57,76.54 261.5,75.48 261.5,74.78 261.12,74.4 261.05,74.4 260.84,74.2 U9002.BF29
CTRL_1P0:
  vias: v1(17.94,124.3)
DCPRTC: length 5.8
  BOTTOM w0.102: 268.64,68.16 268.55,68.25 267.86,68.25 267.73,68.13 U9002.BG47
  BOTTOM w0.114: U9002.BG47 266.92,68.13 U9002.BF47 ; 268.64,68.16 269.27,67.53 270.63,67.53 271.37,68.27 C9221.2
DDI1_AUX_SRCN: length 3.4
  BOTTOM w0.102: C522.2 332.64,56.47 332.52,56.35 332.22,56.35 331.45,57.12 331.45,57.43 331.1,57.77 330.94,57.77 330.86,57.86 U500.59
DDI1_AUX_SRCP: length 3.4
  BOTTOM w0.102: C521.2 332.64,55.98 332.47,56.15 332.14,56.15 331.25,57.04 331.25,57.34 331.02,57.57 330.93,57.57 330.82,57.46 U500.60
DDI1_AUXN: length 227
  IN1 w0.076: v1(334.58,56.61) 334.31,56.34 320.34,56.34 319.91,56.77 317.19,56.77 316.66,56.24 313.43,56.24 312.7,56.97 309.65,56.97 309.41,56.73 304.9,56.73 304.25,56.09 297.67,56.09 296.91,56.85 295,56.85 293.96,57.89 290.97,57.89 290.78,57.7 289.85,57.7 288.68,58.87 288.68,59.89 285.56,63.01 282.4,63.01 281.15,64.26 281.15,65.18 280.22,66.11 279.66,66.11 277.05,68.71 276.4,68.71 275.31,69.8 274.67,69.8 274.42,70.06 273.73,70.06 272.14,71.64 271.08,71.64 268.81,73.9 268.81,74.23 260.87,82.18 260.87,82.51 258.94,84.44 258.07,84.44 255.56,86.96 250.37,86.96 248.8,88.53 241.84,88.53 237.69,92.68 233.43,92.68 232.82,93.29 232.82,94.3 232.16,94.97 221.89,94.97 219.11,97.75 218.05,97.75 216.64,99.16 214.7,99.16 214.28,98.74 211.62,98.74 209.78,96.9 207.38,96.9 205.86,98.43 202.38,98.43 200.89,99.92 200.74,99.92 200.36,100.29 200.36,101.64 199.31,102.69 199.31,104.58 194.86,109.02 194.86,124.87 191.08,128.66 191.08,129.48 188.09,132.46 184.98,132.46 184.77,132.25 180.58,132.25 180.41,132.08 177.11,132.08 176.54,132.65 175.45,132.65 173.1,130.3 173.1,129.35 172.84,129.09 172.84,128.78 171.9,127.84 171.9,123.85 172.33,123.42 172.38,123.42 173.1,122.7 174,122.7 175,121.71 175,121.53 v1(176.47,120.06)
  BOTTOM w0.102: v1(176.47,120.06) 176.47,119.99 U9001.E27 ; C522.1 333.42,56.42 333.56,56.28 334.45,56.28 334.58,56.4 v1(334.58,56.61)
DDI1_AUXP: length 226.9
  IN1 w0.076: v1(177.12,120.06) 176.72,120.45 176.3,120.45 175.16,121.59 175.16,121.78 174.07,122.86 173.17,122.86 172.45,123.58 172.4,123.58 172.07,123.91 172.07,127.77 173.01,128.71 173.01,129.02 173.27,129.29 173.27,130.23 175.52,132.48 176.47,132.48 177.04,131.92 180.48,131.92 180.65,132.09 184.84,132.09 185.05,132.3 188.02,132.3 190.91,129.41 190.91,128.59 194.7,124.8 194.7,108.96 199.14,104.51 199.14,102.63 200.2,101.57 200.2,100.23 200.67,99.75 200.82,99.75 202.31,98.26 205.79,98.26 207.32,96.74 209.85,96.74 211.69,98.58 214.34,98.58 214.76,99 216.57,99 217.98,97.58 219.05,97.58 221.83,94.8 232.09,94.8 232.66,94.24 232.66,93.22 233.36,92.51 237.62,92.51 241.77,88.37 248.73,88.37 250.31,86.79 255.49,86.79 258,84.28 258.87,84.28 260.71,82.44 260.71,82.11 268.65,74.16 268.65,73.83 271.01,71.48 272.07,71.48 273.66,69.89 274.35,69.89 274.6,69.63 275.24,69.63 276.33,68.54 276.98,68.54 279.59,65.94 280.16,65.94 280.98,65.11 280.98,64.2 282.34,62.84 285.49,62.84 288.51,59.82 288.51,58.8 289.78,57.53 290.85,57.53 291.04,57.72 293.89,57.72 294.93,56.68 296.84,56.68 297.6,55.92 304.32,55.92 304.96,56.57 309.48,56.57 309.72,56.81 312.63,56.81 313.37,56.07 316.72,56.07 317.26,56.61 319.84,56.61 320.27,56.17 334.25,56.17 v1(334.58,55.84)
  BOTTOM w0.102: v1(334.58,55.84) 334.35,56.07 333.52,56.07 333.42,55.97 C521.1 ; v1(177.12,120.06) 177.12,119.99 U9001.D27
DDI1_TXN0: length 208.6
  IN1 w0.076: v1(173.44,128.2) 173.82,128.58 173.82,129.98 175.12,131.28 180.12,131.28 180.37,131.03 184.56,131.03 185.23,131.7 187.57,131.7 189.79,129.48 189.79,128.85 194.14,124.5 194.14,108.65 198.53,104.25 198.53,102.42 199.64,101.32 199.64,99.95 200.38,99.21 200.5,99.21 202.2,97.5 205.72,97.5 207.15,96.06 209.96,96.06 211.84,97.94 214.81,97.94 215.29,98.43 216.32,98.43 218.03,96.72 218.03,95.47 219.37,94.13 225.37,94.13 225.61,93.89 231.1,93.89 233.46,91.53 237.8,91.53 240.84,88.48 240.85,88.48 241.6,87.73 248.59,87.73 250.09,86.24 254.53,86.24 256.53,84.23 256.96,84.23 259.54,81.65 260.26,81.65 263.39,78.51 263.39,78.06 271.04,70.41 272.35,70.41 273.42,69.34 274.03,69.34 274.31,69.06 275.04,69.06 276.14,67.96 276.79,67.96 279.37,65.38 279.83,65.38 280.38,64.82 280.38,63.93 282.02,62.3 285.27,62.3 287.8,59.76 287.8,58.65 289.47,56.99 291.12,56.99 291.31,57.18 293.66,57.18 294.71,56.14 296.62,56.14 297.38,55.37 301.13,55.37 302.31,54.19 310.81,54.19 311,54 312.64,54 314.97,51.67 322.49,51.67 323.47,50.69 323.47,48.58 v1(323.25,48.35)
  BOTTOM w0.079: 173.9,128.03 173.94,128 173.94,126.19 173.87,126.12 173.71,126.12 173.64,126.19 U9001.K37
  BOTTOM w0.102: v1(173.44,128.2) 173.73,128.2 173.9,128.03 ; C514.1 323.08,49.06 323.42,49.06 323.53,48.96 323.53,48.58 323.3,48.35 v1(323.25,48.35)
DDI1_TXN0_C: length 5.2
  BOTTOM w0.102: C514.2 323.37,50.14 323.37,52.29 324.33,53.25 324.33,53.63 324.21,53.76 U500.15
DDI1_TXN1: length 207.7
  IN1 w0.076: v1(322.08,50.56) 322.1,50.54 322.1,50.26 321.84,50 321.32,50 321,50.32 321,50.96 320.7,51.26 314.27,51.26 312.72,52.81 311.65,52.81 310.65,53.81 302.04,53.81 300.86,54.99 294.74,54.99 294.32,55.41 294.32,55.96 293.5,56.79 291.48,56.79 291.29,56.61 283.85,56.61 283.5,56.96 283.15,56.96 281.98,58.12 281.98,61.65 279.99,63.64 279.99,64.66 279.67,64.99 279.22,64.99 276.68,67.53 276.03,67.53 274.94,68.62 272.3,68.62 262.82,78.1 262.82,78.39 261.42,79.79 261.42,79.92 260.08,81.27 259.33,81.27 257.12,83.48 256.18,83.48 253.8,85.85 249.93,85.85 249.74,86.04 248.98,86.04 247.99,87.04 241.76,87.04 240.69,88.1 240.57,88.1 237.61,91.06 231.59,91.06 230.58,92.08 230.58,92.96 230.14,93.4 225.52,93.4 225.17,93.06 217.93,93.06 217.58,93.4 217.58,94.29 215.22,96.66 211.2,96.66 210.14,95.59 207.04,95.59 206.03,96.61 203.92,96.61 203.41,97.12 202.05,97.12 200.99,98.17 200.24,98.17 198.06,100.35 198.06,103.28 193.75,107.6 193.75,124.29 188.11,129.92 185.83,129.92 185.14,130.61 180.21,130.61 179.93,130.89 175.38,130.89 174.21,129.72 174.21,126.39 173.39,125.57 173.39,124.74 v1(174.03,124.09)
  BOTTOM w0.102: C516.1 321.99,51.44 322.13,51.3 322.13,50.61 v1(322.08,50.56)
  BOTTOM w0.114: U9001.J34 174.11,124.09 v1(174.03,124.09)
DDI1_TXN1_C: length 2.9
  BOTTOM w0.102: U500.18 323.01,53.81 323.12,53.7 323.12,53.59 322.13,52.6 322.13,52.37 321.98,52.22 C516.2
DDI1_TXN2: length 203.8
  IN1 w0.076: v1(320.58,48.25) 320.79,48.04 320.79,47.8 320.71,47.72 319.89,47.72 319.56,48.05 319.56,48.95 319.18,49.34 318.53,49.34 318.2,49.01 316.49,49.01 315.72,49.79 314.04,49.79 312.13,51.7 311.03,51.7 310.04,52.69 300.56,52.69 299.36,53.9 291.76,53.9 290.25,55.41 283.49,55.41 283.04,55.87 282.59,55.87 280.8,57.65 280.8,61.22 277.07,64.95 277.07,65.6 276.25,66.42 274.6,66.42 273.64,67.38 271.99,67.38 262.11,77.26 261.63,77.26 260.66,78.22 259.51,78.22 258.93,78.79 258.93,79.57 257.04,81.46 256.94,81.46 256.77,81.46 256.32,81.9 255.76,81.9 253.91,83.76 252.86,83.76 252.64,83.53 252,83.53 251.38,84.15 249.94,84.15 248.87,83.09 248.55,83.09 248.24,83.39 248.18,83.39 247.17,84.4 247.17,84.95 246.21,85.92 241.33,85.92 240.24,87.01 239.71,87.01 238.2,88.52 233.2,88.52 232.31,89.41 224.89,89.41 222.38,91.92 216.22,91.92 215.75,92.39 212.94,92.39 211.69,91.13 207.98,91.13 206.99,92.12 206.99,93.23 204.79,95.43 201.38,95.43 196.92,99.89 196.92,102.39 192.61,106.7 192.61,123.31 189.15,126.77 189.15,127.31 188.49,127.97 187.12,127.97 186.43,128.65 185.52,128.65 184.76,129.42 179.68,129.42 179.32,129.77 176.4,129.77 v1(175.72,129.09)
  BOTTOM w0.079: U9001.H36 175.22,125.89 175.29,125.96 175.51,125.96 175.67,126.13 175.67,126.6 175.42,126.85 175.42,127.26 176.21,128.04 176.21,128.61 175.85,128.96
  BOTTOM w0.102: 175.85,128.96 v1(175.72,129.09) ; C520.1 320.74,49.05 320.81,48.99 320.81,48.48 v1(320.58,48.25)
DDI1_TXN2_C: length 5.2
  BOTTOM w0.102: U500.21 321.81,53.77 320.81,52.77 v6(320.81,50.84) 320.81,49.98 320.67,49.83 C520.2
DDI1_TXN3: length 201.3
  IN1 w0.076: v1(174.83,129.09) 175.01,129.09 175.07,129.16 175.07,129.57 175.84,130.33 179.65,130.33 179.93,130.05 184.91,130.05 185.67,129.29 187.97,129.29 193.19,124.07 193.19,107.04 197.5,102.72 197.5,100.1 201.62,95.98 205.62,95.98 206.98,94.62 210.19,94.62 211.67,96.11 214.98,96.11 215.47,95.62 215.47,93.36 215.79,93.04 216.37,93.04 216.91,92.5 224.07,92.5 224.77,91.8 224.77,90.53 225.34,89.97 234.96,89.97 235.43,89.5 238.1,89.5 240.04,87.56 240.46,87.56 241.53,86.49 247.67,86.49 248.7,85.46 249.54,85.46 249.69,85.31 253.27,85.31 256.06,82.51 257.32,82.51 259.15,80.69 259.19,80.69 259.8,80.08 259.8,79.47 260.26,79.01 261.43,79.01 262.13,78.3 262.13,78.01 272.18,67.96 274.83,67.96 275.82,66.96 276.48,66.96 277.63,65.81 277.63,65.17 281.39,61.41 281.39,57.88 282.85,56.42 283.27,56.42 283.63,56.05 290.46,56.05 292.06,54.45 300.63,54.45 301.81,53.27 301.82,53.27 301.83,53.25 310.35,53.25 311.34,52.26 312.38,52.26 314.13,50.51 316.26,50.51 317.21,49.56 317.98,49.56 318.41,49.99 319.36,49.99 319.41,50.03 319.41,50.29 319.19,50.51 v1(319.08,50.51)
  BOTTOM w0.079: U9001.J38 174.55,127.14 174.55,127.37 174.96,127.77 174.96,128.06 175.22,128.31 175.22,128.71 174.96,128.96
  BOTTOM w0.102: v1(319.08,50.51) 319.1,50.51 319.34,50.75 319.34,51.23 319.25,51.31 C519.1 ; 174.96,128.96 v1(174.83,129.09)
DDI1_TXN3_C: length 3.8
  BOTTOM w0.102: U500.23 321.01,53.87 320.88,53.74 320.5,53.74 320.2,53.43 320.2,53.05 319.92,52.77 319.59,52.77 319.28,52.47 319.28,52.19 319.19,52.09 C519.2
DDI1_TXP0: length 208.6
  IN1 w0.076: v1(173.44,128.84) 173.65,129.05 173.65,130.05 175.05,131.45 180.19,131.45 180.44,131.19 184.49,131.19 185.16,131.87 187.64,131.87 189.96,129.54 189.96,128.91 194.3,124.57 194.3,108.71 198.7,104.32 198.7,102.49 199.8,101.39 199.8,100.01 200.44,99.37 200.57,99.37 202.27,97.67 205.78,97.67 207.22,96.23 209.89,96.23 211.77,98.11 214.74,98.11 215.22,98.59 216.39,98.59 218.19,96.79 218.19,95.54 219.44,94.29 225.44,94.29 225.68,94.05 231.17,94.05 233.53,91.7 237.86,91.7 240.91,88.65 240.92,88.65 241.67,87.9 248.66,87.9 250.16,86.4 254.6,86.4 256.6,84.4 257.03,84.4 259.61,81.82 260.32,81.82 263.56,78.58 263.56,78.13 271.11,70.58 272.42,70.58 273.49,69.51 274.1,69.51 274.38,69.23 275.1,69.23 276.21,68.12 276.86,68.12 279.44,65.55 279.89,65.55 280.55,64.89 280.55,64 282.09,62.46 285.33,62.46 287.97,59.83 287.97,58.72 289.53,57.15 291.06,57.15 291.25,57.34 293.73,57.34 294.77,56.3 296.68,56.3 297.45,55.54 301.2,55.54 302.38,54.36 310.88,54.36 311.07,54.17 312.71,54.17 315.04,51.83 322.56,51.83 323.64,50.75 323.64,48.59 v1(323.88,48.35)
  BOTTOM w0.079: U9001.K36 173.64,125.89 173.72,125.96 173.93,125.96 174.1,126.13 174.1,128.17 174.07,128.2
  BOTTOM w0.102: 174.07,128.2 v1(173.44,128.84) ; C500.1 323.88,48.85 v1(323.88,48.35)
DDI1_TXP0_C: length 5.2
  BOTTOM w0.102: C500.2 323.58,50.19 v6(323.58,51.75) 323.58,52.2 324.54,53.16 324.54,53.68 324.61,53.75 U500.14
DDI1_TXP1: length 207.7
  IN1 w0.076: v1(174.03,124.74) 173.62,124.74 173.55,124.81 173.55,125.5 174.37,126.32 174.37,129.65 175.45,130.72 179.86,130.72 180.14,130.44 185.07,130.44 185.76,129.76 188.04,129.76 193.58,124.22 193.58,107.53 197.9,103.21 197.9,100.28 200.17,98.01 200.92,98.01 201.98,96.95 203.34,96.95 203.85,96.45 205.96,96.45 206.97,95.43 210.21,95.43 211.27,96.49 215.15,96.49 217.42,94.22 217.42,93.34 217.86,92.9 225.24,92.9 225.58,93.24 230.07,93.24 230.41,92.9 230.41,92.01 231.52,90.9 237.54,90.9 240.5,87.94 240.62,87.94 241.69,86.87 247.92,86.87 248.91,85.88 249.67,85.88 249.86,85.69 253.73,85.69 256.11,83.31 257.06,83.31 259.27,81.1 260.01,81.1 261.26,79.85 261.26,79.72 262.66,78.32 262.66,78.03 272.23,68.46 274.87,68.46 275.96,67.37 276.61,67.37 279.16,64.82 279.6,64.82 279.83,64.59 279.83,63.57 281.82,61.58 281.82,58.05 283.08,56.8 283.43,56.8 283.78,56.44 291.36,56.44 291.55,56.63 293.43,56.63 294.16,55.89 294.16,55.34 294.67,54.83 300.79,54.83 301.97,53.65 310.58,53.65 311.58,52.64 312.66,52.64 314.2,51.1 320.63,51.1 320.83,50.89 320.83,50.26 321.25,49.84 321.91,49.84 322.64,50.56 v1(322.74,50.56)
  BOTTOM w0.102: C515.1 322.48,51.44 322.33,51.3 322.33,50.9 322.67,50.56 v1(322.74,50.56)
  BOTTOM w0.114: U9001.J35 174.1,124.74 v1(174.03,124.74)
DDI1_TXP1_C: length 2.9
  BOTTOM w0.102: C515.2 322.48,52.22 322.33,52.36 322.33,52.52 323.32,53.51 323.32,53.73 323.41,53.81 U500.17
DDI1_TXP2: length 203.8
  IN1 w0.076: v1(175.72,128.46) 176.09,128.82 176.09,129.23 176.47,129.61 179.25,129.61 179.61,129.25 184.69,129.25 185.45,128.49 186.37,128.49 187.05,127.8 188.42,127.8 188.99,127.24 188.99,126.7 192.45,123.24 192.45,106.63 196.76,102.33 196.76,99.83 201.32,95.26 204.73,95.26 206.83,93.16 206.83,92.05 207.91,90.97 211.75,90.97 213.01,92.22 215.68,92.22 216.15,91.75 222.31,91.75 224.82,89.24 232.24,89.24 233.13,88.36 238.13,88.36 239.64,86.84 240.17,86.84 241.26,85.75 246.14,85.75 247.01,84.88 247.01,84.33 248.11,83.23 248.18,83.23 248.48,82.92 248.94,82.92 250.01,83.99 251.31,83.99 251.93,83.36 252.7,83.36 252.93,83.59 253.84,83.59 255.69,81.74 256.25,81.74 256.7,81.29 256.97,81.29 258.77,79.5 258.77,78.72 259.44,78.06 260.59,78.06 261.56,77.09 262.04,77.09 271.92,67.21 273.57,67.21 274.53,66.25 276.18,66.25 276.9,65.53 276.9,64.89 280.64,61.15 280.64,57.58 282.52,55.7 282.97,55.7 283.42,55.25 290.18,55.25 291.7,53.74 299.29,53.74 300.5,52.53 309.98,52.53 310.97,51.54 312.06,51.54 313.98,49.62 315.65,49.62 316.42,48.85 318.27,48.85 318.6,49.17 319.11,49.17 319.4,48.88 319.4,47.98 319.83,47.55 320.78,47.55 320.95,47.73 320.95,48.12 321.13,48.3 v1(321.24,48.3)
  BOTTOM w0.079: v1(175.72,128.46) 175.96,128.46 176.05,128.37 176.05,128.11 175.26,127.32 175.26,126.78 175.52,126.53 175.52,126.19 175.44,126.12 175.29,126.12 175.22,126.19 U9001.H37
  BOTTOM w0.102: C517.1 321.13,49.05 321.01,48.94 321.01,48.53 v1(321.24,48.3)
DDI1_TXP2_C: length 5.2
  BOTTOM w0.102: C517.2 321.01,50.29 v6(321.01,52.21) 321.01,52.69 322.21,53.88 U500.20
DDI1_TXP3: length 201.3
  IN1 w0.076: v1(319.74,50.51) 319.57,50.35 319.57,49.97 319.43,49.83 318.48,49.83 318.05,49.39 317.14,49.39 316.19,50.34 314.06,50.34 312.31,52.1 311.27,52.1 310.28,53.09 301.77,53.09 301.75,53.1 301.74,53.1 300.56,54.28 291.99,54.28 290.39,55.88 283.57,55.88 283.2,56.25 282.78,56.25 281.22,57.81 281.22,61.34 277.46,65.1 277.46,65.74 276.41,66.8 275.76,66.8 274.76,67.79 272.11,67.79 261.97,77.94 261.97,78.23 261.36,78.84 260.19,78.84 259.63,79.4 259.63,80.01 259.12,80.52 259.08,80.52 257.25,82.35 256,82.35 253.2,85.14 249.62,85.14 249.47,85.3 248.63,85.3 247.6,86.32 241.46,86.32 240.39,87.39 239.97,87.39 238.03,89.33 235.36,89.33 234.89,89.8 225.27,89.8 224.61,90.47 224.61,91.74 224,92.34 216.85,92.34 216.31,92.88 215.72,92.88 215.31,93.29 215.31,95.55 214.92,95.94 211.74,95.94 210.26,94.46 206.91,94.46 205.55,95.82 201.55,95.82 197.34,100.03 197.34,102.65 193.02,106.97 193.02,124 187.9,129.12 185.6,129.12 184.84,129.88 179.86,129.88 179.58,130.16 175.91,130.16 175.24,129.5 175.24,128.89 v1(174.81,128.46)
  BOTTOM w0.079: v1(174.81,128.46) 174.81,128.13 174.8,128.12 174.8,127.84 174.4,127.43 174.4,126.39 U9001.J37
  BOTTOM w0.102: v1(319.74,50.51) 319.54,50.71 319.54,51.14 319.71,51.31 C518.1
DDI1_TXP3_C: length 3.8
  BOTTOM w0.102: C518.2 319.61,52.09 319.49,52.21 319.49,52.39 319.67,52.57 320.01,52.57 320.4,52.97 320.4,53.35 320.59,53.53 320.96,53.53 321.41,53.98 U500.22
DDI2_AUX_SRCN: length 4.4
  BOTTOM w0.102: U501.59 341.77,34.42 341.66,34.3 341.66,32.42 340.72,31.49 340.72,31.38 340.89,31.21 C554.2
DDI2_AUX_SRCP: length 4.4
  BOTTOM w0.102: U501.60 341.37,34.35 341.46,34.27 341.46,32.51 340.52,31.57 340.52,31.33 340.4,31.21 C553.2
DDI2_AUXN: length 237.8
  IN1 w0.076: v1(325.15,40.96) 325.36,41.16 325.36,41.37 324.42,42.31 315.35,42.31 311.68,45.98 311.68,46.66 309.53,48.81 307.14,48.81 306.86,49.09 299.06,49.09 298.6,49.54 295.33,49.54 294.71,48.92 292.04,48.92 291.33,49.63 291.33,50.06 290.84,50.55 285.62,50.55 284.32,51.84 282.21,51.84 277.21,56.84 277.21,57.43 275.03,59.62 272.92,59.62 272.33,59.02 270.29,59.02 268.13,61.18 268.13,64.6 266.37,66.36 266.37,67.56 265.35,68.58 265.04,68.58 260.3,73.33 260.3,74.18 259.48,75 258.1,75 256.41,76.68 256.41,77.11 256.13,77.38 255.1,77.38 254.01,76.29 252.74,76.29 251.32,77.71 249.69,77.71 248.57,78.83 247.81,78.83 247.53,78.55 241.13,78.55 235.68,84 228.92,84 228.28,84.65 226.88,84.65 225.46,86.06 222.21,86.06 221.69,86.59 221,86.59 220.48,86.06 219.88,86.06 219.27,86.67 213.03,86.67 212.72,86.98 207.6,86.98 206.15,88.43 203.68,88.43 197.28,94.83 196.78,94.83 195.52,96.09 195.52,96.8 187.95,104.37 187.95,121.29 186.68,122.56 186.68,124.72 186.49,124.91 185.68,124.91 185.05,125.53 184.56,125.53 184.13,125.11 181.44,125.11 180.63,124.3 179.71,124.3 178.09,125.92 177.12,125.92 176.93,125.73 176.93,124.4 176.73,124.2 176.73,123.72 179.15,121.3 179.15,119.92 178.73,119.5 177.35,119.5 v1(177.12,119.27)
  BOTTOM w0.102: C554.1 340.99,30.44 340.72,30.16 340.72,29.75 339.99,29.02 335.96,29.02 335.75,28.82 v6(334.8,28.82) 333.09,28.82 330.66,31.25 330.66,32.77 327.29,36.15 327.29,38.01 325.61,39.69 325.61,40.58 325.23,40.96 v1(325.15,40.96)
  BOTTOM w0.127: v1(177.12,119.27) 177.12,119.2 U9001.E26
DDI2_AUXP: length 237.9
  IN1 w0.076: v1(325.81,40.98) 325.52,41.28 325.52,41.43 324.48,42.47 315.42,42.47 311.84,46.04 311.84,46.73 309.59,48.97 307.21,48.97 306.93,49.25 299.13,49.25 298.67,49.71 295.26,49.71 294.64,49.09 292.11,49.09 291.5,49.7 291.5,50.13 290.91,50.71 285.69,50.71 284.39,52.01 282.28,52.01 277.37,56.91 277.37,57.5 275.09,59.78 272.85,59.78 272.26,59.18 270.36,59.18 268.29,61.25 268.29,64.67 266.54,66.43 266.54,67.63 265.41,68.75 265.11,68.75 260.46,73.39 260.46,74.24 259.55,75.16 258.16,75.16 256.57,76.75 256.57,77.18 256.2,77.55 255.03,77.55 253.94,76.46 252.81,76.46 251.39,77.88 249.76,77.88 248.64,79 247.74,79 247.46,78.72 241.2,78.72 235.75,84.16 228.99,84.16 228.34,84.81 226.95,84.81 225.53,86.23 222.28,86.23 221.75,86.76 220.94,86.76 220.41,86.23 219.94,86.23 219.33,86.84 213.1,86.84 212.79,87.15 207.66,87.15 206.22,88.6 203.75,88.6 197.35,95 196.84,95 195.69,96.15 195.69,96.86 188.12,104.43 188.12,121.36 186.85,122.63 186.85,124.78 186.56,125.07 185.74,125.07 185.12,125.7 184.49,125.7 184.06,125.27 181.37,125.27 180.56,124.46 179.77,124.46 178.15,126.08 177.05,126.08 176.76,125.8 176.76,124.47 176.56,124.26 176.56,123.66 178.98,121.23 178.98,119.99 178.66,119.67 176.86,119.67 v1(176.47,119.27)
  BOTTOM w0.102: v1(325.81,40.98) 325.81,39.77 327.49,38.1 327.49,36.24 330.87,32.86 330.87,31.33 333.18,29.02 335.67,29.02 335.87,29.22 339.91,29.22 340.52,29.83 340.52,30.03 C553.1
  BOTTOM w0.127: U9001.F26 176.47,119.2 v1(176.47,119.27)
DDI2_TXN0: length 217.3
  IN1 w0.076: v1(325.58,45.81) 325.58,45.24 325.41,45.06 323.36,45.06 321.49,46.93 319.57,46.93 318.34,48.16 316.71,48.16 316.31,47.75 314.52,47.75 311.81,50.46 311.13,50.46 309.69,51.89 300.11,51.89 298.89,53.11 291.38,53.11 290.41,54.08 288.25,54.08 287.71,54.62 283.17,54.62 282.71,55.08 282.22,55.08 280,57.3 280,60.91 276.91,64 275.46,64 272.87,66.59 270.99,66.59 269.15,68.44 269.15,68.97 268.23,69.89 267.35,69.89 265.52,71.72 265.52,71.74 265.08,72.18 265.08,73.17 261.82,76.43 261.2,76.43 260.21,77.42 259.19,77.42 258.15,78.47 258.15,79.24 256.74,80.65 256.43,80.65 255.97,81.1 253.92,81.1 252.37,82.65 251.75,82.65 251.16,83.25 250.15,83.25 249.11,82.21 248.31,82.21 247.92,82.6 247.61,82.6 245.2,85.02 241.12,85.02 239.91,86.22 239.33,86.22 238.47,87.07 232.72,87.07 231.17,88.62 224.55,88.62 222.44,90.74 215.42,90.74 214.95,91.21 213.18,91.21 212.31,90.34 207.65,90.34 207.22,90.77 205.65,90.77 204.88,91.53 203.74,91.53 202.22,93.05 202.22,94.35 201.92,94.64 201.05,94.64 196.12,99.58 196.12,102.06 192.34,105.84 190.84,105.84 190.41,106.28 190.41,122.39 189.64,123.15 189.64,125.16 187.62,127.18 186.78,127.18 186.13,127.83 180.14,127.83 179,128.97 176.87,128.97 176.73,128.83 176.73,128.53 175.01,126.81 175.01,125.35 175.21,125.15 175.21,124.48 v1(174.82,124.09)
  BOTTOM w0.089: v1(174.82,124.09) 175.14,123.76 U9001.H33
  BOTTOM w0.102: C555.1 329.72,42.48 325.64,42.48 324.92,43.2 324.92,44.54 325.53,45.15 325.53,45.76 v1(325.58,45.81)
DDI2_TXN0_C: length 8.9
  BOTTOM w0.102: C555.2 331.33,42.46 331.65,42.46 331.78,42.59 v1(331.78,42.99) 332.31,42.46 335.78,42.46 337.3,40.93 337.73,40.93 337.83,41.04 U501.15
DDI2_TXN1: length 214
  IN1 w0.076: v1(177.12,128.59) 177.21,128.5 178.81,128.5 179.87,127.45 185.84,127.45 186.49,126.8 187.4,126.8 188.64,125.55 188.64,124.37 189.25,123.76 189.25,122.91 190.02,122.14 190.02,105.12 200.48,94.67 200.48,94.24 203.56,91.15 204.72,91.15 205.5,90.38 206.98,90.38 207.75,89.6 212.38,89.6 213.14,90.36 222.2,90.36 224.31,88.24 229.21,88.24 230.31,87.14 231.26,87.14 232.46,85.94 236.64,85.94 239.77,82.81 242.54,82.81 243.23,82.12 245.28,82.12 246.72,80.69 248.34,80.69 249.22,81.57 249.22,81.75 250.34,82.87 250.93,82.87 251.54,82.26 252.2,82.26 254.01,80.46 255.15,80.46 255.38,80.23 256.6,80.23 257.77,79.06 257.77,78.31 258.33,77.74 258.33,77.4 258.78,76.95 260.1,76.95 261.04,76.01 261.63,76.01 262.36,75.28 262.36,74.5 264.7,72.16 264.7,72.02 264.73,71.99 264.73,71.87 267.11,69.5 268.08,69.5 268.51,69.06 268.51,68.42 270.77,66.16 272.17,66.16 272.68,65.65 273.21,65.65 275.24,63.62 276.75,63.62 279.44,60.93 279.44,57.3 282.05,54.7 282.55,54.7 283.01,54.24 287.53,54.24 289.19,52.59 298.63,52.59 299.71,51.51 309.5,51.51 311.14,49.87 311.82,49.87 316.69,45 321.98,45 322.29,44.68 329.36,44.68 331.45,42.59 333.15,42.59 333.23,42.66 333.23,42.84 v1(333.08,42.99)
  BOTTOM w0.079: v1(177.12,128.59) 177.12,128.5 176.88,128.26 176.75,128.26 176.54,128.04 176.54,127.79 176,127.26 176,127.12 175.9,127.01 U9001.G38
  BOTTOM w0.102: v1(333.08,42.99) 333.66,43.58 333.96,43.58 C548.1
DDI2_TXN1_C: length 3.9
  BOTTOM w0.102: U501.18 337.81,42.24 337.7,42.13 337.28,42.13 v6(336.77,42.64) 335.81,43.6 335.63,43.6 C548.2
DDI2_TXN2: length 217.8
  IN1 w0.076: v1(325.36,44.13) 325.51,44.13 325.61,44.03 325.61,43.78 325.39,43.56 322.64,43.56 321.75,44.45 316.47,44.45 312.48,48.44 311.71,48.44 309.18,50.97 299.34,50.97 298.79,51.51 295.07,51.51 294.13,50.57 292.7,50.57 291.45,51.83 289.14,51.83 287.83,53.14 282.83,53.14 278.87,57.09 278.87,60.52 277.32,62.07 275.37,62.07 274.35,61.05 272.31,61.05 271.54,60.28 270.9,60.28 269.78,61.4 269.78,62.72 270.29,63.23 270.29,64.35 267.63,67.01 267.63,68.14 265.78,69.98 265.53,69.98 261.78,73.73 261.78,75 261.32,75.45 260.82,75.45 259.96,76.32 258.58,76.32 257.69,77.21 257.69,77.61 256.66,78.64 255.98,78.64 254.79,79.83 252.75,79.83 252.1,80.49 250.72,80.49 250.06,81.16 249.59,81.16 248.57,80.13 246.01,80.13 245.87,80.27 245.08,80.27 243.8,81.55 242.15,81.55 241.53,82.17 239.54,82.17 236.32,85.4 232.23,85.4 231.12,86.51 230.08,86.51 229.27,87.32 224.44,87.32 223.02,88.74 218.69,88.74 218.05,88.1 213.97,88.1 213.02,89.05 207.49,89.05 206.72,89.83 205.27,89.83 204.59,90.51 203.41,90.51 199.76,94.16 199.76,94.49 189.47,104.79 189.47,121.91 188.7,122.68 188.7,123.51 188.03,124.18 188.03,125.38 187.17,126.24 186.18,126.24 185.55,126.88 179.04,126.88 178.64,127.27 176.03,127.27 175.42,126.66 175.42,125.55 175.84,125.13 175.84,124.96 v1(175.61,124.74)
  BOTTOM w0.102: v1(325.36,44.13) 325.36,44.14 326.26,45.05 327.06,45.05 327.69,44.41 332.42,44.41 332.51,44.51 C550.1
  BOTTOM w0.114: v1(175.61,124.74) 175.67,124.74 U9001.F35
DDI2_TXN2_C: length 5.9
  BOTTOM w0.102: C550.2 333.68,44.46 333.8,44.46 334.08,44.74 335.55,44.74 v6(336.37,43.92) 336.95,43.34 337.64,43.34 337.73,43.44 U501.21
DDI2_TXN3: length 219.7
  IN1 w0.076: v1(333.58,46.12) 332.7,46.12 332.39,45.81 332.39,45.3 334.13,43.56 334.13,42.7 333.47,42.04 327.65,42.04 326.68,43.02 317.13,43.02 312.41,47.74 311.61,47.74 309.34,50.01 304.44,50.01 304.18,50.27 295.01,50.27 294.77,50.03 292.46,50.03 291.22,51.27 288.83,51.27 287.54,52.56 282.61,52.56 277.92,57.25 277.92,57.73 277.1,58.55 277.1,60.21 276.77,60.54 275.23,60.54 275.04,60.34 272.42,60.34 271.81,59.73 270.67,59.73 268.85,61.55 268.85,64.89 267.08,66.66 267.08,67.85 265.54,69.39 265.25,69.39 261.04,73.61 261.04,74.44 259.77,75.71 258.4,75.71 257.13,76.98 257.13,77.39 256.43,78.1 255.74,78.1 254.66,79.18 252.55,79.18 251.84,79.89 250.64,79.89 250.26,79.5 249.84,79.5 249.59,79.76 249.04,79.76 248.85,79.57 247.05,79.57 246.81,79.33 244.25,79.33 242.92,80.65 241.62,80.65 241.11,81.16 239.67,81.16 235.97,84.85 232,84.85 230.92,85.93 228.37,85.93 227.53,86.77 224.2,86.77 223.57,87.4 213.68,87.4 213.23,87.85 207.81,87.85 206.48,89.18 203.95,89.18 197.5,95.63 197.1,95.63 196.25,96.48 196.25,97.12 188.88,104.48 188.88,121.38 187.48,122.78 187.48,125.04 186.89,125.63 186,125.63 185.35,126.28 184.28,126.28 183.86,125.86 179.17,125.86 178.31,126.72 176.26,126.72 176,126.45 176,125.76 v1(176.37,125.39)
  BOTTOM w0.102: C552.1 334.01,45.91 333.79,45.91 v1(333.58,46.12)
  BOTTOM w0.114: U9001.E36 176.46,125.39 v1(176.37,125.39)
DDI2_TXN3_C: length 4.3
  BOTTOM w0.102: C552.2 335.63,45.89 336.1,45.89 337.17,44.82 337.17,44.46 337.49,44.14 337.64,44.14 337.73,44.24 U501.23
DDI2_TXP0: length 217.3
  IN1 w0.076: v1(174.82,124.74) 175.05,124.96 175.05,125.09 174.85,125.29 174.85,126.88 176.56,128.59 176.56,128.89 176.8,129.14 179.07,129.14 180.21,127.99 186.2,127.99 186.85,127.34 187.69,127.34 189.81,125.23 189.81,123.22 190.57,122.46 190.57,106.35 190.91,106.01 192.41,106.01 196.29,102.13 196.29,99.64 201.12,94.81 201.99,94.81 202.38,94.41 202.38,93.12 203.81,91.7 204.95,91.7 205.71,90.93 207.29,90.93 207.71,90.51 212.24,90.51 213.11,91.37 215.02,91.37 215.49,90.9 222.5,90.9 224.62,88.79 231.24,88.79 232.79,87.24 238.54,87.24 239.39,86.39 239.98,86.39 241.18,85.18 245.27,85.18 247.68,82.77 247.99,82.77 248.38,82.38 249.04,82.38 250.08,83.42 251.23,83.42 251.82,82.82 252.44,82.82 253.99,81.27 256.04,81.27 256.5,80.81 256.81,80.81 258.31,79.31 258.31,78.53 259.26,77.59 260.28,77.59 261.27,76.6 261.89,76.6 265.25,73.24 265.25,72.25 265.69,71.81 265.69,71.79 267.42,70.06 268.29,70.06 269.31,69.04 269.31,68.51 271.06,66.75 272.94,66.75 275.53,64.16 276.98,64.16 280.17,60.97 280.17,57.37 282.29,55.25 282.78,55.25 283.23,54.79 287.78,54.79 288.32,54.24 290.48,54.24 291.45,53.28 298.96,53.28 300.18,52.06 309.76,52.06 311.19,50.62 311.88,50.62 314.59,47.92 316.24,47.92 316.64,48.33 318.4,48.33 319.64,47.09 321.56,47.09 323.42,45.23 325.34,45.23 325.42,45.31 325.42,45.43 325.04,45.81 v1(324.95,45.81)
  BOTTOM w0.089: U9001.H34 175.14,124.41 v1(174.82,124.74)
  BOTTOM w0.102: v1(324.95,45.81) 325.33,45.43 325.33,45.23 324.72,44.63 324.72,43.12 325.56,42.28 v6(327.18,42.28) 329.72,42.28 C546.1
DDI2_TXP0_C: length 8.9
  BOTTOM w0.102: U501.14 337.79,40.64 337.7,40.73 337.22,40.73 335.69,42.25 332.31,42.25 v1(331.78,41.72) 331.78,42.13 331.65,42.25 331.28,42.25 C546.2
DDI2_TXP1: length 213.9
  IN1 w0.076: v1(333.71,43.02) 333.39,42.7 333.39,42.59 333.22,42.42 331.38,42.42 329.29,44.52 322.23,44.52 321.91,44.83 316.63,44.83 311.75,49.71 311.07,49.71 309.43,51.35 299.65,51.35 298.57,52.43 289.12,52.43 287.47,54.08 282.94,54.08 282.48,54.54 281.98,54.54 279.28,57.24 279.28,60.86 276.69,63.45 275.17,63.45 273.14,65.48 272.61,65.48 272.1,65.99 270.7,65.99 268.34,68.35 268.34,68.99 268.01,69.33 267.04,69.33 264.57,71.8 264.57,71.92 264.53,71.95 264.53,72.09 262.2,74.43 262.2,75.21 261.56,75.85 260.97,75.85 260.03,76.79 258.71,76.79 258.17,77.33 258.17,77.67 257.6,78.24 257.6,78.99 256.53,80.06 255.31,80.06 255.08,80.29 253.94,80.29 252.13,82.09 251.47,82.09 250.86,82.7 250.41,82.7 249.39,81.68 249.39,81.5 248.41,80.52 246.65,80.52 245.21,81.96 243.16,81.96 242.48,82.64 239.71,82.64 236.57,85.78 232.39,85.78 231.19,86.97 230.24,86.97 229.14,88.08 224.25,88.08 222.13,90.19 213.21,90.19 212.45,89.44 207.68,89.44 206.91,90.21 205.43,90.21 204.66,90.98 203.49,90.98 200.31,94.17 200.31,94.6 189.86,105.05 189.86,122.07 189.08,122.84 189.08,123.69 188.47,124.3 188.47,125.49 187.33,126.63 186.42,126.63 185.77,127.28 179.8,127.28 178.75,128.34 177.48,128.34 v1(177.1,127.95)
  BOTTOM w0.079: v1(177.1,127.95) 176.95,128.1 176.95,128.1 176.82,128.1 176.69,127.98 176.69,127.72 176.16,127.19 176.16,127.05 176.16,127.05 176.16,126.52 U9001.F37
  BOTTOM w0.102: v1(333.71,43.02) 333.71,43.27 333.81,43.37 334.06,43.37 C547.1
DDI2_TXP1_C: length 3.9
  BOTTOM w0.102: U501.17 337.81,41.84 337.73,41.93 337.19,41.93 335.72,43.4 335.57,43.4 C547.2
DDI2_TXP2: length 217.8
  IN1 w0.076: v1(175.61,124.09) 176,124.48 176,125.2 175.58,125.62 175.58,126.59 176.1,127.11 178.58,127.11 178.98,126.71 185.48,126.71 186.11,126.07 187.1,126.07 187.87,125.31 187.87,124.11 188.54,123.44 188.54,122.61 189.3,121.85 189.3,104.72 199.6,94.42 199.6,94.09 203.34,90.35 204.52,90.35 205.2,89.66 206.65,89.66 207.42,88.89 212.95,88.89 213.91,87.94 218.12,87.94 218.76,88.58 222.95,88.58 224.37,87.16 229.2,87.16 230.01,86.34 231.05,86.34 232.16,85.23 236.25,85.23 239.47,82.01 241.46,82.01 242.08,81.38 243.73,81.38 245.02,80.1 245.8,80.1 245.94,79.96 248.63,79.96 249.66,80.99 249.99,80.99 250.65,80.33 252.03,80.33 252.69,79.67 254.72,79.67 255.91,78.48 256.59,78.48 257.52,77.54 257.52,77.14 258.51,76.15 259.89,76.15 260.75,75.29 261.25,75.29 261.61,74.93 261.61,73.66 265.46,69.81 265.72,69.81 267.46,68.07 267.46,66.94 270.12,64.28 270.12,63.3 269.61,62.79 269.61,61.33 270.83,60.11 271.61,60.11 272.38,60.89 274.42,60.89 275.44,61.91 277.25,61.91 278.71,60.45 278.71,57.03 282.76,52.97 287.76,52.97 289.07,51.67 291.38,51.67 292.64,50.41 294.19,50.41 295.13,51.35 298.72,51.35 299.27,50.8 309.11,50.8 311.64,48.27 312.41,48.27 316.4,44.29 321.68,44.29 322.57,43.4 325.46,43.4 325.77,43.72 325.77,44.03 325.88,44.13 325.94,44.13 325.96,44.11 v1(325.99,44.11)
  BOTTOM w0.102: v1(325.99,44.11) 325.99,44.49 326.35,44.85 326.97,44.85 327.61,44.21 v6(331.22,44.21) 332.16,44.21 332.49,43.88 C549.1
  BOTTOM w0.114: U9001.F34 176,124.31 175.78,124.09 v1(175.61,124.09)
DDI2_TXP2_C: length 5.9
  BOTTOM w0.102: U501.20 337.73,43.04 337.64,43.14 336.86,43.14 335.46,44.54 334.17,44.54 333.88,44.25 333.66,44.25 C549.2
DDI2_TXP3: length 219.7
  IN1 w0.076: v1(333.58,45.48) 333.38,45.68 333.38,45.77 333.2,45.95 332.76,45.95 332.56,45.74 332.56,45.37 334.3,43.63 334.3,42.64 333.53,41.87 327.59,41.87 326.61,42.85 317.06,42.85 312.34,47.58 311.55,47.58 309.27,49.85 304.37,49.85 304.12,50.1 295.08,50.1 294.84,49.86 292.39,49.86 291.15,51.11 288.76,51.11 287.47,52.4 282.54,52.4 277.76,57.19 277.76,57.66 276.93,58.48 276.93,60.14 276.7,60.37 275.3,60.37 275.11,60.17 272.49,60.17 271.88,59.57 270.61,59.57 268.69,61.48 268.69,64.82 266.92,66.59 266.92,67.78 265.47,69.23 265.18,69.23 260.88,73.54 260.88,74.37 259.71,75.54 258.33,75.54 256.97,76.91 256.97,77.33 256.36,77.93 255.67,77.93 254.59,79.01 252.55,79.01 252.55,79.01 252.48,79.01 251.77,79.72 250.7,79.72 250.32,79.34 249.77,79.34 249.52,79.59 249.11,79.59 248.92,79.4 247.12,79.4 246.87,79.16 244.18,79.16 242.86,80.48 241.55,80.48 241.04,80.99 239.6,80.99 235.9,84.69 231.93,84.69 230.85,85.77 228.3,85.77 227.46,86.61 224.13,86.61 223.5,87.24 213.61,87.24 213.16,87.68 207.74,87.68 206.41,89.02 203.89,89.02 197.43,95.47 197.03,95.47 196.08,96.42 196.08,97.05 188.72,104.42 188.72,121.31 187.32,122.71 187.32,124.97 186.82,125.47 185.93,125.47 185.28,126.12 184.35,126.12 183.93,125.69 179.1,125.69 178.25,126.55 176.33,126.55 176.17,126.39 176.17,126.09 176.22,126.04 v1(176.4,126.04)
  BOTTOM w0.102: v1(333.58,45.48) 333.81,45.71 334.01,45.71 C551.1
  BOTTOM w0.114: v1(176.4,126.04) 176.4,126.52 176.54,126.66 176.71,126.66 176.79,126.58 U9001.E37
DDI2_TXP3_C: length 4.2
  BOTTOM w0.102: C551.2 335.57,45.68 336.02,45.68 v6(336.48,45.22) 336.96,44.74 336.96,44.38 337.4,43.94 337.64,43.94 337.73,43.84 U501.22
DDI3_TXN0: length 228.4
  IN4 w0.076: v3(350.04,48.48) 349.89,48.33 349.68,48.33 348.68,47.32 345.49,47.32 345.07,47.74 336.61,47.74 335.46,48.88 335,48.88 333.84,50.04 329.26,50.04 327.54,51.76 315.96,51.76 315.73,51.53 309.53,51.53 309.04,52.02 306.9,52.02 306,52.92 306,52.92 305.6,53.32 299.97,53.32 299.58,53.71 294.17,53.71 294.11,53.77 292.34,53.77 290.91,55.2 287.8,55.2 287.47,54.87 281.86,54.87 279.46,57.27 276.82,57.27 274.29,59.79 273.71,59.79 273.48,59.57 270.76,59.57 268.51,61.81 268.51,64.56 267.02,66.04 265.15,66.04 264.1,67.09 264.1,68.36 262.34,70.12 261.8,70.12 261.45,70.47 261.45,71.01 258.35,74.11 258.35,74.37 256.26,76.46 256.01,76.46 255.69,76.77 254.79,76.77 254.48,76.47 252.94,76.47 251.29,78.12 250.58,78.12 250.49,78.21 249.43,78.21 248.64,79 245.62,79 245.1,79.52 244.15,79.52 243.26,80.41 242.17,80.41 241.86,80.1 240.55,80.1 240.31,80.34 240.31,80.56 236.37,84.5 232.6,84.5 231.9,85.19 230.42,85.19 229.81,84.58 220.83,84.58 220.34,85.07 209.93,85.07 209.27,85.73 207.51,85.73 205.1,88.14 203.71,88.14 200.91,90.94 200.91,91.32 198.9,93.32 198.9,95.84 197.16,97.58 197.16,102.54 196.42,103.28 196.42,106.2 194.65,107.98 194.65,121.96 190.9,125.71 182.8,125.71 182.73,125.77 182.73,125.99 v1(183.02,126.27)
  BOTTOM w0.079: U9001.D34 177.9,123.93 178.57,123.93 178.99,124.35 180.26,124.35 181.45,125.54 182.47,125.54 182.71,125.78 182.71,125.96 v1(183.02,126.27)
  BOTTOM w0.102: C600.1 351.09,48.39 350.96,48.26 350.26,48.26 v3(350.04,48.48)
DDI3_TXN1: length 227.8
  IN4 w0.076: v3(347.63,48.1) 347.76,48.22 347.76,48.75 347.56,48.95 344.54,48.95 343.72,48.12 336.77,48.12 335.62,49.27 335.16,49.27 334.61,49.81 334.16,50.27 334,50.43 329.47,50.43 327.74,52.15 315.8,52.15 315.63,51.98 309.71,51.98 308.86,52.83 306.74,52.83 305.88,53.7 305.36,53.7 304.84,54.22 292.43,54.22 291.06,55.59 287.44,55.59 287.11,55.26 282.12,55.26 279.19,58.19 276.45,58.19 274.39,60.25 273.38,60.25 273.07,59.95 270.92,59.95 269.03,61.83 269.03,64.75 266.99,66.79 266.99,67.02 265.34,68.67 265.05,68.67 260.88,72.84 260.88,73.03 256.34,77.56 255.96,77.56 254.55,78.97 252.54,78.97 251.83,79.68 250.67,79.68 250.29,79.3 249.79,79.3 249.5,79.59 249.03,79.59 248.85,79.42 246.36,79.42 245.59,80.19 245.35,80.19 244.76,80.79 241.25,80.79 240.87,81.17 240.24,81.17 236.48,84.93 232.82,84.93 231.86,85.89 229.83,85.89 229.58,85.65 226.94,85.65 226.35,85.05 221.27,85.05 220.86,85.46 219.46,85.46 218.97,85.95 209.59,85.95 209.21,86.32 207.55,86.32 205.34,88.53 203.85,88.53 201.29,91.1 201.29,91.58 199.31,93.56 199.31,96.22 197.54,97.98 197.54,102.7 196.81,103.44 196.81,106.36 195.03,108.14 195.03,122.21 191.14,126.1 188.24,126.1 187.56,126.79 180.99,126.79 180.75,126.55 180.75,126.35 180.84,126.27 v1(180.99,126.27)
  BOTTOM w0.079: U9001.B34 178.72,125.06 178.83,125.16 179.67,125.16 179.93,125.41 180.31,125.41 180.68,125.78 180.68,126.07 180.87,126.27 v1(180.99,126.27)
  BOTTOM w0.102: C598.1 351.09,50.68 350.96,50.55 350.3,50.55 348.82,49.06 348.28,49.06 347.91,48.69 347.91,48.38 v3(347.63,48.1)
DDI3_TXN2: length 237.3
  IN4 w0.076: v1(176.47,123.21) 176.23,123.44 176.23,123.68 177.36,124.8 177.45,124.8 178,125.35 178,127.26 179.86,129.12 188.52,129.12 189.4,128.25 190.77,128.25 196.22,122.8 196.22,108.81 198.63,106.39 198.63,99.61 200.53,97.72 200.53,93.98 203.91,90.6 206.19,90.6 207.64,89.16 209.56,89.16 210.73,87.99 219.27,87.99 219.86,88.57 220.18,88.57 221.6,87.16 228,87.16 228.08,87.24 230.49,87.24 230.73,87.48 232.29,87.48 233.65,86.12 236.83,86.12 240.18,82.77 242.22,82.77 242.76,82.22 243.46,82.22 243.75,81.93 245.9,81.93 246.49,81.34 246.49,80.83 246.79,80.53 248.37,80.53 249.59,81.75 249.59,81.92 250.48,82.81 250.86,82.81 251.53,82.13 252.1,82.13 254.04,80.19 256.81,80.19 257.69,79.31 257.69,78.38 260.57,75.5 261.17,75.5 261.53,75.15 261.53,73.92 262.17,73.28 262.17,73.17 265.41,69.94 265.77,69.94 267.43,68.29 268.33,68.29 270.27,66.35 271.49,66.35 272.12,65.71 273.13,65.71 275.34,63.49 276.63,63.49 280.45,59.67 280.45,58.64 282.71,56.38 286.42,56.38 286.79,56.75 290.84,56.75 291.13,57.04 292.63,57.04 292.68,57.09 293.76,57.09 294.7,56.15 294.83,56.15 294.83,56.15 296.72,56.15 297.17,55.7 300.98,55.7 301.33,56.06 305.12,56.06 307.03,54.15 307.99,54.15 308.18,54.35 309.58,54.35 309.84,54.08 312.24,54.08 314.12,55.96 320.28,55.96 321.3,54.94 330.14,54.94 330.54,54.55 331.22,54.55 331.65,54.12 332.11,54.12 334.23,52 336.59,52 338.2,50.38 341.51,50.38 341.67,50.55 341.81,50.55 342.31,51.06 347.36,51.06 348.01,50.4 348.01,50.13 347.89,50 v3(347.63,50)
  BOTTOM w0.102: C596.1 351.09,52.96 350.96,52.83 350.05,52.83 347.91,50.7 347.91,50.28 v3(347.63,50)
  BOTTOM w0.114: U9001.E33 176.47,123.27 v1(176.47,123.21)
DDI3_TXN3: length 241.5
  IN4 w0.076: v1(181.01,124.1) 180.91,124.1 180.78,123.97 180.78,123.82 180.88,123.71 181.39,123.71 181.48,123.62 181.48,123.45 181.37,123.34 180.66,123.34 179.64,124.37 179.64,126.25 180.73,127.34 184.95,127.34 185.27,127.66 190.47,127.66 195.67,122.46 195.67,108.58 197.35,106.9 197.35,103.76 198.09,103.02 198.09,99.29 199.88,97.5 199.88,93.76 201.92,91.72 201.92,91.24 204.08,89.08 205.68,89.08 207.68,87.09 209.22,87.09 209.81,86.5 219.22,86.5 219.69,86.02 220.59,86.02 221.13,86.57 221.79,86.57 222.34,86.02 223.86,86.02 224.43,86.59 228.34,86.59 228.45,86.69 230.83,86.69 231.08,86.93 231.98,86.93 233.36,85.56 236.62,85.56 240.47,81.71 241.81,81.71 242.03,81.5 243.41,81.5 243.53,81.38 245.68,81.38 245.94,81.12 245.94,80.61 246.58,79.97 248.62,79.97 249.56,80.91 250.06,80.91 250.75,80.23 252.1,80.23 252.69,79.64 254.74,79.64 256.23,78.16 256.52,78.16 261.47,73.2 261.47,73.09 265.25,69.31 265.59,69.31 267.53,67.36 267.53,67.06 270.02,64.57 270.02,63.29 269.74,63.01 269.74,62.09 270.78,61.05 271.17,61.05 271.68,60.54 272.9,60.54 273.22,60.86 273.28,60.86 275.44,60.86 275.93,60.37 276.59,60.37 276.6,60.38 276.95,60.38 277.94,59.39 278.93,59.39 282.49,55.82 286.68,55.82 287.01,56.15 291.25,56.15 291.59,56.49 292.85,56.49 292.88,56.52 293.55,56.52 294.25,55.82 294.25,55.27 294.73,54.79 298.3,54.79 298.46,54.95 301.06,54.95 301.48,55.37 305.01,55.37 307.01,53.38 309.13,53.38 309.85,52.66 312.95,52.66 315.28,54.99 320.48,54.99 321.07,54.4 329.77,54.4 332.94,51.23 335.16,51.23 337.24,49.15 338.41,49.15 338.45,49.11 343.42,49.11 344.82,50.51 345.82,50.51 345.94,50.38 345.94,50.13 345.82,50 v3(345.47,50)
  BOTTOM w0.079: v1(181.01,124.1) 181.01,123.92 181.08,123.84 181.36,123.84 181.49,123.72 181.49,123.61 181.39,123.51 180.55,123.51 180.35,123.71 179.2,123.71 178.92,123.43 178.8,123.43 178.74,123.48 U9001.B33
  BOTTOM w0.102: v3(345.47,50) 345.71,50 345.84,50.13 345.84,50.73 350.23,55.12 350.96,55.12 351.09,55.25 C594.1
DDI3_TXP0: length 228.4
  IN4 w0.076: v1(182.28,126.27) 182.57,125.99 182.57,125.71 182.73,125.54 190.83,125.54 194.48,121.89 194.48,107.91 196.26,106.13 196.26,103.21 197,102.48 197,97.51 198.74,95.77 198.74,93.25 200.74,91.25 200.74,90.87 203.64,87.97 205.03,87.97 207.44,85.56 209.2,85.56 209.86,84.9 220.28,84.9 220.76,84.42 229.88,84.42 230.49,85.03 231.83,85.03 232.53,84.33 236.3,84.33 240.14,80.49 240.14,80.28 240.48,79.94 241.93,79.94 242.23,80.24 243.19,80.24 244.08,79.35 245.03,79.35 245.55,78.83 248.57,78.83 249.36,78.04 250.43,78.04 250.51,77.95 251.23,77.95 252.88,76.3 254.55,76.3 254.86,76.61 255.62,76.61 255.94,76.29 256.19,76.29 258.18,74.3 258.18,74.04 261.28,70.94 261.28,70.41 261.74,69.95 262.27,69.95 263.94,68.29 263.94,67.02 265.08,65.88 266.96,65.88 268.34,64.49 268.34,61.74 270.69,59.4 273.55,59.4 273.78,59.63 274.22,59.63 276.75,57.1 279.39,57.1 281.79,54.7 287.54,54.7 287.87,55.03 290.85,55.03 292.28,53.6 294.04,53.6 294.1,53.55 299.51,53.55 299.9,53.15 305.54,53.15 305.93,52.76 305.93,52.76 306.83,51.86 308.97,51.86 309.46,51.36 315.79,51.36 316.03,51.6 327.47,51.6 329.19,49.88 333.77,49.88 334.93,48.72 335.4,48.72 336.54,47.58 345,47.58 345.42,47.16 348.75,47.16 349.75,48.16 349.92,48.16 350.04,48.03 v3(350.04,47.84)
  BOTTOM w0.079: U9001.C34 177.96,124.4 177.88,124.31 177.88,124.18 177.97,124.09 178.51,124.09 178.92,124.51 180.19,124.51 181.39,125.7 182.4,125.7 182.55,125.85 182.55,126.01 v1(182.28,126.27)
  BOTTOM w0.102: C599.1 351.09,47.93 350.96,48.06 350.26,48.06 v3(350.04,47.84)
DDI3_TXP1: length 227.8
  IN4 w0.076: v3(348.39,48.1) 348.05,48.1 347.92,48.22 347.92,48.82 347.63,49.11 344.48,49.11 343.65,48.29 336.83,48.29 335.69,49.43 335.23,49.43 334.73,49.93 334.27,50.39 334.07,50.59 329.54,50.59 327.81,52.32 315.73,52.32 315.56,52.15 309.78,52.15 308.93,53 306.81,53 305.95,53.86 305.43,53.86 304.91,54.38 292.5,54.38 291.13,55.76 287.37,55.76 287.04,55.42 282.19,55.42 279.25,58.36 276.52,58.36 274.46,60.42 273.31,60.42 273.01,60.11 270.98,60.11 269.2,61.9 269.2,64.82 267.15,66.86 267.15,67.09 265.4,68.84 265.12,68.84 261.04,72.91 261.04,73.09 256.41,77.73 256.03,77.73 254.62,79.14 252.61,79.14 251.9,79.85 250.6,79.85 250.22,79.47 249.86,79.47 249.57,79.76 248.96,79.76 248.78,79.58 246.43,79.58 245.66,80.35 245.42,80.35 244.82,80.95 241.32,80.95 240.94,81.33 240.31,81.33 236.55,85.09 232.89,85.09 231.93,86.06 229.76,86.06 229.52,85.82 226.87,85.82 226.28,85.22 221.33,85.22 220.93,85.63 219.53,85.63 219.04,86.11 209.65,86.11 209.28,86.49 207.62,86.49 205.41,88.7 203.92,88.7 201.45,91.17 201.45,91.65 199.47,93.63 199.47,96.29 197.71,98.05 197.71,102.77 196.97,103.51 196.97,106.43 195.19,108.21 195.19,122.28 191.21,126.27 188.31,126.27 187.62,126.95 180.92,126.95 180.59,126.62 180.59,126.39 180.47,126.27 v1(180.35,126.27)
  BOTTOM w0.079: v1(180.35,126.27) 180.52,126.11 180.52,125.85 180.24,125.57 179.86,125.57 179.61,125.32 178.96,125.32 U9001.B36
  BOTTOM w0.102: C597.1 351.09,50.22 350.96,50.34 350.39,50.34 348.9,48.86 348.37,48.86 348.11,48.6 348.11,48.38 v3(348.39,48.1)
DDI3_TXP2: length 237.3
  IN4 w0.076: v3(348.39,50) 348.18,50.22 348.18,50.47 347.43,51.22 342.25,51.22 341.74,50.71 341.6,50.71 341.44,50.55 338.27,50.55 336.66,52.16 334.3,52.16 332.18,54.28 331.72,54.28 331.29,54.71 330.61,54.71 330.21,55.11 321.37,55.11 320.35,56.12 314.05,56.12 312.17,54.24 309.91,54.24 309.65,54.51 308.11,54.51 307.92,54.32 307.1,54.32 305.19,56.22 301.26,56.22 300.91,55.87 297.24,55.87 296.79,56.31 294.76,56.31 293.83,57.25 292.61,57.25 292.56,57.2 291.06,57.2 290.77,56.91 286.72,56.91 286.35,56.54 282.78,56.54 280.61,58.71 280.61,59.74 276.7,63.66 275.41,63.66 273.19,65.88 272.19,65.88 271.56,66.51 270.34,66.51 268.4,68.46 267.49,68.46 265.84,70.11 265.47,70.11 262.34,73.24 262.34,73.34 261.69,73.99 261.69,75.22 261.24,75.67 260.63,75.67 257.85,78.45 257.85,79.38 256.88,80.35 254.11,80.35 252.17,82.3 251.6,82.3 250.93,82.97 250.41,82.97 249.42,81.99 249.42,81.82 248.3,80.7 246.86,80.7 246.65,80.9 246.65,81.41 245.97,82.09 243.82,82.09 243.53,82.39 242.83,82.39 242.29,82.93 240.25,82.93 236.9,86.29 233.72,86.29 232.36,87.64 230.66,87.64 230.42,87.4 228.01,87.4 227.93,87.32 221.67,87.32 220.25,88.74 219.79,88.74 219.2,88.15 210.8,88.15 209.63,89.32 207.71,89.32 206.26,90.77 203.97,90.77 200.69,94.05 200.69,97.78 198.8,99.68 198.8,106.46 196.38,108.87 196.38,122.87 190.84,128.41 189.47,128.41 188.59,129.29 179.8,129.29 177.83,127.32 177.83,125.42 177.38,124.97 177.29,124.97 176.07,123.75 176.07,123.46 v1(175.82,123.21)
  BOTTOM w0.102: C595.1 351.09,52.5 350.96,52.63 350.13,52.63 348.11,50.61 348.11,50.28 v3(348.39,50)
  BOTTOM w0.114: U9001.F33 175.82,123.27 v1(175.82,123.21)
DDI3_TXP3: length 241.5
  IN4 w0.076: v3(346.23,50) 346.11,50.13 346.11,50.45 345.88,50.68 344.75,50.68 343.35,49.28 338.52,49.28 338.48,49.32 337.31,49.32 335.23,51.4 333.01,51.4 329.84,54.56 321.14,54.56 320.55,55.15 315.21,55.15 312.88,52.83 309.92,52.83 309.2,53.55 307.08,53.55 305.08,55.54 301.41,55.54 300.99,55.12 298.39,55.12 298.23,54.95 294.8,54.95 294.42,55.34 294.42,55.89 293.62,56.68 292.81,56.68 292.78,56.65 291.52,56.65 291.18,56.31 286.94,56.31 286.61,55.98 282.56,55.98 278.99,59.55 278.01,59.55 277.02,60.54 276.53,60.54 276.52,60.54 276,60.54 275.51,61.03 273.35,61.03 273.15,61.03 272.83,60.71 271.75,60.71 271.24,61.22 270.85,61.22 269.91,62.16 269.91,62.94 270.19,63.22 270.19,64.64 267.7,67.13 267.7,67.43 265.66,69.47 265.32,69.47 261.64,73.15 261.64,73.27 256.59,78.32 256.3,78.32 254.81,79.81 252.75,79.81 252.17,80.39 250.82,80.39 250.13,81.08 249.49,81.08 248.55,80.14 246.64,80.14 246.11,80.68 246.11,81.19 245.74,81.55 243.6,81.55 243.48,81.66 242.09,81.66 241.88,81.88 240.53,81.88 236.69,85.73 233.42,85.73 232.05,87.1 231.01,87.1 230.77,86.86 228.38,86.86 228.28,86.76 224.36,86.76 223.79,86.18 222.41,86.18 221.86,86.73 221.06,86.73 220.52,86.18 219.76,86.18 219.28,86.66 209.88,86.66 209.29,87.25 207.75,87.25 205.75,89.24 204.15,89.24 202.09,91.3 202.09,91.78 200.04,93.83 200.04,97.57 198.25,99.36 198.25,103.09 197.52,103.83 197.52,106.97 195.84,108.65 195.84,122.53 190.54,127.83 185.2,127.83 184.89,127.51 180.66,127.51 179.47,126.32 179.47,124.3 180.6,123.18 181.44,123.18 181.64,123.38 v1(181.64,124.1)
  BOTTOM w0.079: v1(181.64,124.1) 181.64,123.54 181.45,123.35 180.48,123.35 180.28,123.56 179.27,123.56 178.98,123.27 178.43,123.27 U9001.C33
  BOTTOM w0.102: C593.1 351.09,54.79 350.96,54.92 350.31,54.92 346.04,50.65 346.04,50.2 v3(346.23,50)
DDPB_CTRL_CLK: length 1.4
  TOP w0.114: v1(250.1,74.64) 249.97,74.51 R9246.1
  BOTTOM w0.254: U9002.AL13 249.83,74.37 v1(250.1,74.64)
DDPB_CTRL_DATA: length 1.3
  TOP w0.114: R9247.1 248.9,77.49 v1(249.05,77.34)
  BOTTOM w0.114: U9002.AR8 249.37,77.67 v1(249.05,77.34)
DDPC_CTRL_CLK: length 3.4
  TOP w0.114: v1(250.9,75.45) 250.6,75.15 250.6,74.41 249.69,73.5 R9244.1
  BOTTOM w0.114: U9002.AN13 250.58,75.13 v1(250.9,75.45)
DDPC_CTRL_DATA: length 1.3
  TOP w0.114: v1(249.09,75.69) 248.92,75.53 R9245.1
  BOTTOM w0.102: v1(249.09,75.69) 248.75,75.35 U9002.AL10

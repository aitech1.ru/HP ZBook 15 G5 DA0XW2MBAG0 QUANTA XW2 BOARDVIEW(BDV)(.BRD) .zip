# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TB_HTPLG: length 199.8
  TOP w0.114: D8000.2 352.13,100.95 v1(352.38,101.21) 353.5,102.32 357.41,102.32 357.71,102.03 360.88,102.03 v1(361.35,101.56) ; v1(257.49,62.2) 257.49,61.21 257.71,60.99 257.71,60.75 256.93,59.97 256.93,59.42 257.71,58.63 257.71,57.69 258.6,56.79 258.6,55.84 259.6,54.85 R9201.1
  IN3 w0.089: v1(361.35,101.56) 361.35,100.83 361.72,100.45 361.72,100.44 362.88,99.28 362.88,84.65 360.87,82.64 360.87,69.61 362.26,68.22 362.26,65.77 363.77,64.26 363.77,63.35 361.86,61.44 356.87,61.44 355.12,59.69 355.12,55.08 354.46,54.41 354.46,46.54 353.65,45.73 350.25,45.73 v1(349.66,46.32)
  IN4 w0.076: v1(257.49,62.2) 258.08,62.2 258.36,61.91 258.36,61.21 259.16,60.41 259.16,57.16 258.99,56.99 258.99,56.25 259.39,55.84 260.03,55.84 260.51,55.36 261.47,55.36 262.54,54.29 264.04,54.29 264.8,53.53 267.32,53.53 267.54,53.3 271.23,53.3 271.51,53.03 275.73,53.03 277.06,51.7 277.45,51.7 277.64,51.51 279.09,51.51 279.48,51.12 280.33,51.12 283.28,51.12 284.21,50.19 288.72,50.19 289.7,49.21 291.62,49.21 291.95,48.88 292.71,48.88 293.08,49.25 294.21,49.25 295.14,50.18 298.7,50.18 299.05,50.54 300.77,50.54 302.22,49.09 306.2,49.09 307.83,47.46 308.85,47.46 309.48,48.1 313.27,48.1 314.29,49.11 316.11,49.11 316.47,48.76 316.47,48.05 316.26,47.84 316.26,45.81 317.15,44.92 318.74,44.92 319.4,44.26 324.34,44.26 325.05,44.97 334.22,44.97 334.93,45.68 337.55,45.68 338.03,46.17 338.64,46.17 339.27,45.53 349.13,45.53 349.69,46.09 v1(349.66,46.32)
  BOTTOM w0.114: U9002.AE43 v1(257.49,62.2)
TB_PWR: length 182.7
  TOP w0.076: v3(349.38,111.33) 349.4,111.33 349.82,110.9 349.82,110.42 349.92,110.33 349.92,109.82
  TOP w0.114: v1(259.78,62.49) 259.83,62.49 R9220.1 ; R8029.2 349.38,108.65 349.92,109.18 349.92,109.82
  IN2 w0.089: v1(333.61,48.83) 333.25,49.19 333.25,51.6 333.67,52.02 333.67,52.55 333.66,52.56 333.66,52.96 332.4,54.22 332.4,54.99 331.99,55.39 331.23,55.39 330.23,56.4 330.23,56.87 329.41,57.68 328.87,57.68 328.51,58.03 328.51,58.77 326.56,60.72 325.75,60.72 324.02,62.44 324.02,63.16 323.62,63.56 322.69,63.56 321.34,64.91 321.34,67.99 325.29,71.94 325.29,72.85 326.56,74.12 326.92,74.12 327.69,74.89 327.69,75.25 332.39,79.95 332.39,80.1 333.56,81.27 333.56,81.93 336.54,84.91 336.54,89.79 338.08,91.33 338.08,94.12 338.61,94.65 339.47,94.65 340.16,95.34 340.16,99.43 340.9,100.17 340.9,104.87 342.04,106.01 346.82,106.01 349.28,108.48 349.28,108.98 349.83,109.52 349.83,110.88 v3(349.38,111.33)
  IN4 w0.076: v1(259.78,62.49) 260.04,62.24 260.91,62.24 265.94,57.21 266.26,57.21 267.62,55.84 270.67,55.84 271.25,56.43 272.1,56.43 273.84,54.69 276.43,54.69 277.8,53.32 278.13,53.32 278.32,53.14 279.83,53.14 280.2,52.77 287.81,52.77 288.13,52.46 291.52,52.46 291.66,52.6 293.65,52.6 294.18,52.06 294.65,52.06 294.96,52.37 299.21,52.37 299.52,52.06 301.96,52.06 302.6,51.42 305.86,51.42 306.42,50.87 308.53,50.87 309.06,50.33 317.5,50.33 317.57,50.4 317.99,50.4 318.59,49.79 320.5,49.79 322.18,48.11 322.18,47.54 320.8,46.15 319.86,46.15 319.36,45.66 319.36,45.3 319.67,45 322,45 322.87,45.86 322.87,48.58 323.3,49.01 327.03,49.01 327.72,48.33 333.1,48.33 v1(333.61,48.83)
  BOTTOM w0.102: v1(259.78,62.49) 259.93,62.34 U9002.AJ46
  BOTTOM w0.114: U8001.V4 v3(349.38,111.33)
TBT_CIO_PLUG_EVENT: length 9.7
  TOP w0.114: v1(352.18,105) 352.16,105 351.95,104.78 351.87,104.78 351.14,104.05 D8000.1
  BOTTOM w0.076: U8001.AA1 350.34,110.11 350.51,109.93 350.67,109.78 350.67,108.12 350.64,108.09 350.64,107.47 351.21,106.9
  BOTTOM w0.114: R8027.2 352.43,104.74 v1(352.18,105) 352.18,105.94 351.21,106.9
TBT_CLK_REQ5#: length 193.5
  TOP w0.076: 348.06,109.82 348.06,110.01 v3(348.08,110.03)
  TOP w0.114: v1(255.98,70.07) 255.91,70 R9174.1 ; 348.06,109.82 v1(348.06,109.44)
  IN1 w0.076: v1(255.98,70.07) 256.41,69.64 257.17,69.64 260.26,66.55 260.26,66.16 260.92,65.5 261.29,65.5 262.16,64.62 262.16,64.1 263.25,63.01 263.25,59.55 264.1,58.7 264.1,56.69 264.45,56.35 265.7,56.35 273.08,48.96 275.95,48.96 278.66,46.25 280.14,46.25 281.69,44.69 283.85,44.69 284.28,44.26 287.32,44.26 288.77,42.81 294.9,42.81 295.69,42.03 298.28,42.03 298.75,41.56 306.64,41.56 307.02,41.18 310.74,41.18 313.16,38.75 320,38.75 320.48,38.27 330.66,38.27 332.01,36.92 333.69,36.92 334.12,37.35 334.12,37.76 335.54,39.18 v1(335.95,39.18)
  IN2 w0.089: v1(335.95,39.18) 334.33,40.8 334.33,46.19 333.45,47.07 333.45,48.06 332.85,48.66 332.85,51.75 333.25,52.16 333.25,52.59 332.69,53.16 332.69,53.37 332.05,54.01 331.73,54.01 331.28,54.45 331.24,54.45 329.83,55.86 329.83,56.7 329.25,57.28 328.7,57.28 328.12,57.87 328.12,58.61 326.39,60.33 325.58,60.33 323.72,62.19 323.5,62.19 320.94,64.76 320.94,68.14 324.9,72.1 324.9,73.88 326.47,75.45 327.13,75.45 333.17,81.49 333.17,82.2 336.15,85.18 336.15,89.96 337.69,91.49 337.69,94.62 338.73,95.67 338.73,99.43 340.49,101.19 340.49,105.01 342.13,106.66 345.99,106.66 347.63,108.29 347.63,109.58 v3(348.08,110.03)
  BOTTOM w0.089: U8001.Y6 v3(348.08,110.03)
  BOTTOM w0.114: U9002.AN29 v1(255.98,70.07)
TBT_EE_CLK: length 69.6
  IN3 w0.089: v1(310.29,65.17) 310.34,65.11 312.25,65.11 316.06,68.92 316.64,68.92 327.17,79.45 327.17,80.9 329.45,83.17 330.79,83.17 332.44,84.83 333,84.83 336.13,87.96 336.13,90.43 336.51,90.8 336.51,100.08 340.27,103.84 340.27,104.73 341.92,106.38 341.92,108.56 342.88,109.53 v3(342.88,110.07)
  BOTTOM w0.114: TP8010.1 U8000.6 304.72,64.88 305.26,65.42 309.99,65.42 310.24,65.17 v1(310.29,65.17) ; v3(342.88,110.07) 342.93,110.07 U8001.Y16
TBT_EE_CS_N: length 66.7
  IN3 w0.089: v3(342.24,110.68) 342.56,110.36 342.56,109.82 342.02,109.29 341.54,109.29 341.03,108.77 341.03,106.16 339.76,104.89 339.76,104 336.04,100.28 336.04,91 335.66,90.62 335.66,88.15 332.82,85.31 332.26,85.31 330.59,83.64 329.25,83.64 324.77,79.16 324.77,77.82 318.16,71.21 317.82,70.88 316.95,70.88 316.63,71.2 316.5,71.2 316.29,70.99 316.29,70.86 316.61,70.54 316.61,70.42 316.41,70.21 316.28,70.21 315.96,70.53 315.84,70.53 315.63,70.32 315.63,70.2 315.95,69.88 315.95,69.75 315.74,69.55 315.62,69.55 315.3,69.87 315.17,69.87 314.96,69.66 314.96,69.53 315.07,69.43 315.07,68.62 314.48,68.03 314.35,68.03 313.97,68.41 313.85,68.41 313.64,68.21 313.64,68.08 314.02,67.7 314.02,67.57 313.81,67.37 313.69,67.37 313.31,67.75 313.18,67.75 312.97,67.54 312.97,67.42 313.14,67.25 v1(313.14,66.59)
  BOTTOM w0.114: R8034.2 v1(313.14,66.59) 312.31,67.42 U8000.1 ; U8001.W18 v3(342.24,110.68)
TBT_EE_DI: length 71
  IN3 w0.089: v3(342.23,110.05) 341.87,109.69 341.38,109.69 340.6,108.9 340.6,106.59 339.33,105.32 338.94,105.32 338.31,104.69 338.31,103.11 335.64,100.44 335.64,91.16 335.27,90.79 335.27,88.32 332.65,85.7 332.09,85.7 330.43,84.04 329.09,84.04 324.14,79.08 324.14,78.32 318.8,72.99 317.38,72.99 311.83,67.44 309.74,67.44 309.49,67.19 309.49,65.16 v1(309.66,64.99)
  BOTTOM w0.114: U8001.Y18 342.26,110.05 v3(342.23,110.05) ; TP8009.1 303.25,63.61 U8000.5 304.34,63.61 305.34,64.61 307.12,64.61 307.25,64.48 309.28,64.48 309.66,64.86 v1(309.66,64.99)
TBT_EE_DO: length 67.1
  IN3 w0.089: v3(342.89,110.68) 343.21,110.35 343.21,109.19 342.81,108.78 342.81,106.61 340.77,104.57 340.77,103.68 337.35,100.26 337.35,90.98 336.6,90.23 336.6,87.76 333.15,84.32 332.59,84.32 330.77,82.49 329.43,82.49 327.64,80.7 327.64,79.26 323.63,75.25 323.63,74.31 322.94,73.62 322.1,73.62 317.91,69.43 317.91,68.16 317.25,67.5 317.13,67.5 316.68,67.95 316.56,67.95 316.26,67.65 316.26,67.53 316.71,67.08 316.71,66.96 316.41,66.66 316.28,66.66 315.84,67.11 315.71,67.11 315.42,66.81 315.42,66.68 315.59,66.51 315.59,66.34 315.06,65.81 314.31,65.81 v1(313.15,64.66)
  BOTTOM w0.114: U8001.W16 v3(342.89,110.68) ; U8000.2 312.28,66.15 313.15,65.28 v1(313.15,64.66) 313.24,64.66 313.57,64.99 R8037.2
TBT_EE_WP_N: length 69.5
  IN3 w0.089: v3(349.35,110.68) 349.69,110.34 349.69,109.59 347.76,107.66 344.42,107.66 341.28,104.52 341.28,103.64 337.74,100.1 337.74,90.82 336.99,90.07 336.99,87.58 333.33,83.91 332.75,83.91 330.93,82.09 329.59,82.09 328.49,81 328.49,79.38 324.14,75.02 324.14,74.26 322.1,72.23 321.26,72.23 318.42,69.38 318.42,68.04 314.36,63.97 v1(313.09,63.97)
  BOTTOM w0.114: R8036.2 v1(313.09,63.97) 313.09,64.05 312.26,64.88 U8000.3 ; U8001.W4 349.35,110.7 v3(349.35,110.68)
TBT_GPIO0: length 6
  BOTTOM w0.076: U8001.W1 350.41,111.03 350.68,110.76 350.68,110.66 352.46,108.88 v1(352.46,107.91) 352.72,107.66 352.96,107.66 353.46,107.15
  BOTTOM w0.114: R8031.1 353.46,107.15
TBT_GPIO1: length 9.1
  BOTTOM w0.076: U8001.W2 350.01,110.77 350.38,110.77 350.5,110.65 350.5,110.62 351.44,109.68 351.44,109.18 v1(351.57,109.06) 352.08,108.55 352.08,107.53 352.46,107.15 352.71,107.15
  BOTTOM w0.114: R8032.1 355.62,106.26 353.6,106.26 352.71,107.15
TBT_GPIO8: length 7.4
  TOP w0.114: v3(348.08,110.68) 347.73,110.33 347.73,109.72 346.74,108.73 346.74,107.41 v1(346.49,107.15) R8042.2 346.25,106.27 R8041.2
  BOTTOM w0.114: U8001.W6 v3(348.08,110.68)
TBT_HOLD_N: length 13.1
  BOTTOM w0.114: v1(302.47,67.68) 302.69,67.46 302.69,66.95 303.49,66.15 U8000.7 305.23,66.15 307.12,68.04 312.82,68.04 R8039.2
TBT_I2C_SCL: length 26.4
  TOP w0.114: v3(351.09,111.17) 351.21,111.29 351.87,111.29 352.08,111.09 R8022.1 ; v3(344.51,95.65) 344.38,95.52 344.13,95.52 344.08,95.47 TP8525.1
  IN1 w0.076: v3(351.09,111.17) 351.26,111.34 351.8,111.34 352,111.14 352,110.32 351.81,110.13 351.81,106.06 350.86,105.11 350.86,104.04 348.94,102.12 348.94,100.03 349.1,99.86 349.1,97.68 348.42,96.99 346.31,96.99 344.96,95.65 v3(344.51,95.65)
  BOTTOM w0.076: v3(351.09,111.17) 350.98,111.27 349.98,111.27 U8001.V2
  BOTTOM w0.114: U8500.E2 344.91,95.61 344.54,95.61 v3(344.51,95.65)
TBT_I2C_SDA: length 26
  TOP w0.114: v3(351.62,110.91) 351.62,110.71 v1(352.25,110.07) R8021.1 ; TP8524.1 344.91,96.76 344.38,96.23 344.33,96.23 v3(344.1,96)
  IN1 w0.076: v3(344.1,96) 344.35,96.26 344.96,96.26 346.19,97.49 348.3,97.49 348.65,97.83 348.65,99.71 348.51,99.85 348.51,102.3 350.43,104.22 350.43,105.29 351.38,106.24 351.38,110.31 351.57,110.5 351.57,110.86 v3(351.62,110.91)
  BOTTOM w0.076: v3(351.62,110.91) 351.62,111.14 351.27,111.49 U8001.V1
  BOTTOM w0.114: U8500.D2 344.19,96.09 v3(344.1,96)
TBT_MRESET_EC: length 171.2
  TOP w0.076: 272.07,29.81 271.81,29.55 271.17,29.55 v3(270.84,29.22)
  TOP w0.114: v1(326.42,68.29) 325.71,67.58 325.71,66.69 325.41,66.38 324.39,66.38 324.07,66.07 324.07,64.17 324.56,63.68 324.56,59.95 324.05,59.44 324.05,52.12 323.48,51.55 323.48,49.52 322.82,48.86 322.82,48.13 323.02,47.93 323.02,39.69 323.87,38.84 323.87,29.67 v1(324.31,29.22) ; 272.07,29.81 273.08,30.82 273.51,30.82 274.17,31.48 275.04,31.48 R6165.1 275.27,31.87 275.5,32.09 276,32.09 276.52,32.61 R6164.2
  IN1 w0.076: v3(348.09,117.82) 347.5,117.82 346.49,118.84 341.66,118.84 340.46,117.63 340.46,112.03 340.01,111.58 340.01,109.68 340.61,109.08 340.61,106.34 339.82,105.56 339.82,103.18 337.69,101.05 337.69,91.37 336.25,89.93 336.25,85.1 328.96,77.81 328.96,75.02 328.2,74.26 328.2,68.8 327.69,68.29 v1(326.42,68.29)
  IN4 w0.076: v1(324.31,29.22) 324.09,29 309.53,29 308.86,29.67 298.96,29.67 297.86,30.77 290.86,30.77 290.48,31.16 283.31,31.16 282.75,30.6 280.19,30.6 279.76,31.03 278.49,31.03 277.22,29.76 274.94,29.76 274.07,28.89 271.18,28.89 271.17,28.89 v3(270.84,29.22)
  BOTTOM w0.114: U6001.J9 v3(270.84,29.22)
  BOTTOM w0.127: U8001.E5 v3(348.09,117.82)
TBT_PA_USB2_MXCTL: length 9.5
  BOTTOM w0.076: U8001.R2 349.99,112.64 351.57,112.64 352.33,111.88 352.33,110.05 v1(352.84,109.54) 353.22,109.16 353.22,108.68 353.6,108.29 354.87,108.29 355.12,108.04 R8006.1
TBT_PB_USB2_MXCTL: length 6.4
  BOTTOM w0.076: U8001.R1 351.57,112.87 352.49,111.94 352.49,110.42 353.85,109.07 R8007.1
TBT_PERST#: length 150.7
  TOP w0.114: U12001.4 279.42,51.73 R17978.2 280.06,51.02 280.07,51.01 R9586.2 v1(282.23,51.01) 283.36,51.01 283.6,51.25 285.5,51.25 v1(285.96,51.7) ; v1(352.89,98.69) 352.89,97.8 352.28,97.2 351.39,97.2 351.09,97.5 351.09,98.11 350.24,98.95 350.24,101.55 v1(350.06,101.73)
  IN3 w0.089: v1(352.89,98.69) 352.89,97.72 352.28,97.11 352.28,91.02 350.93,89.68 350.93,67.13 350.42,66.62 350.42,58.01 350.57,57.86 350.57,55.77 347,52.2 347,49.62 345.43,48.05 345.43,47.12 342.18,43.88 337.73,43.88 334.05,40.2 326.19,40.2 325.91,40.48 324.22,40.48 322.86,41.84 317.8,41.84 317.28,42.36 312.46,42.36 308.59,46.24 308.59,46.73 306,49.32 302.11,49.32 301.04,50.38 295.15,50.38 293.96,49.19 292.79,49.19 292.67,49.06 289.85,49.06 287.6,51.31 286.62,51.31 286.23,51.7 v1(285.96,51.7) ; v3(349.33,111.98) 349.87,111.44 349.87,109.39 349.49,109.01 349.49,105.58 350.3,104.76 350.3,101.97 v1(350.06,101.73)
  BOTTOM w0.102: v3(349.33,111.98) 349.06,112.25 U8001.T4
TBT_PWR_GOOD: length 5.5
  TOP w0.076: 348.42,109.82 348.4,109.84 348.4,110.33 348.73,110.66 v3(348.73,110.68)
  TOP w0.114: 348.42,109.82 348.57,109.67 348.57,108.94 348.49,108.87 348.49,108.29 v1(348.01,107.81) 347.63,107.43 347.63,107.28 347.5,107.15 R8038.1
  BOTTOM w0.114: U8001.W5 v3(348.73,110.68)
TBT_RBIAS: length 1.2
  TOP w0.114: R8033.1 348,115.54 348.08,115.47 v3(348.08,115.23)
  BOTTOM w0.114: U8001.J6 v3(348.08,115.23)
TBT_REN_09V: length 1.7
  TOP w0.114: R7322.1 359.06,120.11 359.06,120.74 359.2,120.88 Q7151.2
TBT_RSENSE: length 1.2
  TOP w0.114: R8033.2 348.78,115.67 348.73,115.62 v3(348.73,115.23)
  BOTTOM w0.114: U8001.J5 v3(348.73,115.23)
TBT_SNK0_AUX_N: length 79.3
  IN3 w0.076: v1(335.24,58.64) 335.24,58.56 335.11,58.43 334.93,58.43 334.17,59.2 334.17,60.01 331.12,63.06 331.12,67.58 330.9,67.8 330.18,67.8 330.11,67.88 330.11,68.44 330.18,68.51 330.9,68.51 331.12,68.74 331.12,71.54 330.9,71.76 330.18,71.76 330.11,71.84 330.11,72.73 330.18,72.81 330.9,72.81 331.12,73.03 331.12,73.5 336.96,79.34 336.96,81.24 341.34,85.62 341.45,85.62 342.07,85 342.63,85 342.98,85.36 342.98,85.81 342.68,86.12 342.68,86.35 342.96,86.63 343.17,86.63 343.71,86.1 344.08,86.1 344.56,86.58 344.56,86.97 343.68,87.85 343.68,87.96 344.38,88.66 348.67,88.66 351.44,91.43 351.44,97.78 352.75,99.09 352.75,101.24 354.77,103.26 354.77,109.08 355.76,110.07 355.76,110.96 355.89,111.09 356.34,111.09 356.65,110.78 v1(356.65,110.71)
  BOTTOM w0.102: v1(335.24,58.64) 334.98,58.38 334.78,58.38 334.64,58.53 R10026.1 ; v1(356.65,110.71) 356.34,111.01 355.02,111.01 C8027.1
TBT_SNK0_AUX_P: length 79.3
  IN3 w0.076: v1(335.24,58) 335.06,58.18 334.83,58.18 333.92,59.09 333.92,59.91 330.87,62.96 330.87,67.47 330.79,67.55 330.08,67.55 329.85,67.77 329.85,68.54 330.08,68.77 330.79,68.77 330.87,68.84 330.87,71.43 330.79,71.51 330.08,71.51 329.85,71.74 329.85,72.84 330.08,73.06 330.79,73.06 330.87,73.14 330.87,73.6 336.71,79.44 336.71,81.35 341.23,85.88 341.55,85.88 342.17,85.26 342.52,85.26 342.73,85.46 342.73,85.71 342.42,86.01 342.42,86.45 342.86,86.88 343.28,86.88 343.81,86.35 343.97,86.35 344.3,86.68 344.3,86.86 343.42,87.74 343.42,88.06 344.27,88.91 348.56,88.91 351.19,91.54 351.19,97.89 352.5,99.2 352.5,101.35 354.51,103.37 354.51,109.19 355.51,110.18 355.51,111.07 355.78,111.34 v1(356.65,111.34)
  BOTTOM w0.102: R10027.1 334.64,57.94 334.75,58.05 335.19,58.05 v1(335.24,58) ; v1(356.65,111.34) C8025.1
TBT_SNK0_AUXN_R: length 4.1
  BOTTOM w0.102: R10026.2 333.46,58.49 333.31,58.49 333.3,58.49 331.98,58.49 331.82,58.65 R520.1 331.52,58.59 330.94,58.59 330.87,58.66 U500.57
TBT_SNK0_AUXP_R: length 4
  BOTTOM w0.102: R10027.2 333.45,58.16 332.26,58.16 331.86,57.75 R523.1 331.31,58.26 U500.58
TBT_SNK0_HPD: length 70
  IN2 w0.089: v1(350.17,107.2) 347.96,104.99 342.42,104.99 342.42,105 341.76,105 341.08,104.32 341.08,101.39 342.3,100.17 344.08,100.17 345.22,99.02 345.47,99.02 345.85,98.64 345.85,97.37 344.82,96.34 344.12,96.34 343.47,96.99 341.52,96.99 340.77,96.24 340.77,95.2 339.69,94.12 338.89,94.12 338.69,93.92 338.69,90.82 338.94,90.57 339.28,90.57 339.51,90.34 339.51,90.02 339.5,90.02 339.5,90.01 339.12,89.63 339.12,85.43 334.29,80.6 334.29,78.82 328.61,73.14 326.83,73.14 326.03,72.35 326.03,71.46 325.41,70.83 325.41,70.35 v1(324.77,69.71)
  BOTTOM w0.076: 350.5,108.67 350.5,109.73 350.38,109.85 350.01,109.85 U8001.AA2
  BOTTOM w0.102: v1(350.17,107.2) 350.45,107.48 350.45,108.29 350.5,108.34 350.5,108.67
  BOTTOM w0.114: v1(324.77,69.71) 325.41,69.08 R10038.1 ; R8005.1 351.5,105.41 351.59,105.5 351.59,106.16 350.7,107.05 350.32,107.05 v1(350.17,107.2)
TBT_SNK0_HPD_L: length 10.8
  BOTTOM w0.114: R10000.2 324.27,68.16 324.9,68.16 324.98,68.08 324.98,68.07 325.08,67.97 325.09,67.97 325.29,67.77 R10038.2 325.91,67.27 v1(325.91,65.39) 325.91,63.31 326.57,62.65 326.57,61.53 327.01,61.1 U500.49
TBT_SNK0_ML0_N: length 52.9
  IN3 w0.076: v1(349.28,104.36) 349.26,104.36 348.77,103.88 348.77,101.82 346,99.05 346,98.18 345.04,97.22 344.28,97.22 343.95,96.89 343.95,96.32 343.69,96.07 343.69,93.97 343.83,93.83 343.83,93.02 343.44,92.62 343.01,92.62 342.55,92.17 342.55,91.43 341.79,90.66 341.79,87.49 335.69,81.39 335.69,79.52 328.78,72.61 328.78,69.66 328.05,68.92 328.05,64.76 328.2,64.61 328.73,64.61 328.91,64.79 328.91,65.04 328.73,65.22 v1(328.61,65.22)
  BOTTOM w0.102: v1(349.28,104.36) 349.18,104.36 348.88,104.66 348.88,104.82 349.21,105.15 C8014.1 ; v1(328.61,65.22) 328.76,65.06 328.76,64.9 R10019.1
TBT_SNK0_ML0_N_L: length 4.9
  BOTTOM w0.102: U500.53 328.61,59.88 328.68,59.95 v6(328.68,62.8) 328.68,63.31 328.78,63.42 328.78,63.77 328.74,63.81 R10019.2
TBT_SNK0_ML0_P: length 52.9
  IN3 w0.076: v1(348.52,104.36) 348.52,101.92 345.75,99.15 345.75,98.29 344.94,97.47 344.18,97.47 343.69,96.99 343.69,96.43 343.44,96.17 343.44,93.87 343.58,93.73 343.58,93.12 343.33,92.88 342.9,92.88 342.3,92.27 342.3,91.53 341.54,90.77 341.54,87.59 335.44,81.5 335.44,79.62 328.53,72.71 328.53,69.76 327.79,69.03 327.79,64.66 328.1,64.35 328.84,64.35 329.17,64.68 329.17,65.04 v1(329.34,65.22)
  BOTTOM w0.102: C8008.1 v1(348.52,104.36) ; v1(329.34,65.22) 329.19,65.06 329.19,64.87 R10018.1
TBT_SNK0_ML0_P_L: length 4.8
  BOTTOM w0.102: U500.54 329.01,63.18 329.11,63.29 329.11,63.69 329.23,63.81 R10018.2
TBT_SNK0_ML1_N: length 50.8
  IN3 w0.076: v1(346.49,104.23) 346.72,104 346.72,103.55 346.11,102.94 346.11,101.64 342.47,98.01 341.81,98.01 340.65,96.84 340.65,88 333.03,80.38 333.03,79.52 332.9,79.39 329.68,76.17 329.34,75.83 329.34,75.35 327.57,73.57 327.57,71.32 325.79,69.54 325.79,66.66 326.19,66.26 326.7,66.26 326.8,66.15 326.8,65.87 v1(326.6,65.66)
  BOTTOM w0.102: v1(326.6,65.66) 326.42,65.49 R10021.1 ; v1(346.49,104.23) 346.69,104.43 346.69,104.95 C8010.1
TBT_SNK0_ML1_N_L: length 4.9
  BOTTOM w0.102: U500.50 327.41,59.85 327.37,59.89 327.37,61.22 327.03,61.56 327.03,62.74 326.78,63 326.78,63.46 R10021.2
TBT_SNK0_ML1_P: length 50.8
  IN3 w0.076: v1(347.25,104.36) 346.97,104.08 346.97,103.44 346.36,102.83 346.36,101.53 342.58,97.75 341.92,97.75 340.9,96.74 340.9,87.9 333.28,80.28 333.28,79.41 333.08,79.21 329.86,75.99 329.6,75.73 329.6,75.24 327.82,73.46 327.82,71.21 326.04,69.43 326.04,66.77 326.3,66.51 326.8,66.51 327.06,66.26 327.06,65.92 v1(327.31,65.66)
  BOTTOM w0.102: v1(327.31,65.66) 327.44,65.54 R10020.1 ; v1(347.25,104.36) 347.02,104.59 347.02,104.92 C8016.1
TBT_SNK0_ML1_P_L: length 4.9
  BOTTOM w0.102: U500.51 327.81,59.92 327.7,60.02 327.7,61.35 327.36,61.7 v6(327.36,62.17) 327.36,62.88 327.11,63.13 327.11,63.48 R10020.2
TBT_SNK0_ML2_N: length 53.1
  IN3 w0.076: v1(345.22,104.28) 344.94,104.28 344.46,103.8 344.46,103.16 340,98.71 340,89.5 339.55,89.05 339.55,87.75 332.14,80.33 332.14,79.52 325.99,73.37 325.99,71.84 323.76,69.61 323.76,68.52 323.93,68.34 323.93,64.81 324.29,64.45 324.92,64.45 325.03,64.56 325.03,64.93 324.9,65.06 324.9,65.19 324.82,65.27 324.57,65.27 v1(324.52,65.22)
  BOTTOM w0.102: v1(345.22,104.28) 344.99,104.51 344.99,104.92 C8019.1 ; R10023.1 324.68,64.59 324.75,64.66 324.75,64.99 v1(324.52,65.22)
TBT_SNK0_ML2_N_L: length 5.3
  BOTTOM w0.102: R10023.2 324.72,63.48 324.72,62.35 326.24,60.83 326.24,59.85 326.21,59.82 U500.47
TBT_SNK0_ML2_P: length 53
  IN3 w0.076: v1(344.46,104.36) 344.46,104.16 344.2,103.9 344.2,103.27 339.75,98.81 339.75,89.6 339.3,89.15 339.3,87.85 331.88,80.43 331.88,79.62 325.74,73.48 325.74,71.95 323.5,69.71 323.5,68.41 323.68,68.24 323.68,64.7 324.18,64.2 325.03,64.2 325.28,64.45 v1(325.28,65.22)
  BOTTOM w0.102: v1(325.28,65.22) 325.08,65.01 325.08,64.66 325.14,64.59 R10022.1 ; C8018.1 344.66,104.95 344.66,104.56 v1(344.46,104.36)
TBT_SNK0_ML2_P_L: length 5.3
  BOTTOM w0.102: R10022.2 325.05,63.46 325.05,62.49 v6(325.36,62.18) 326.57,60.97 326.57,59.83 326.61,59.8 U500.48
TBT_SNK0_ML3_N: length 50.2
  IN3 w0.076: v1(342.42,104.23) 342.65,104 342.65,103.49 338.39,99.23 338.39,88.13 331.04,80.78 331.04,80.53 324.77,74.26 324.77,72.48 322.66,70.37 322.66,68.88 321.72,67.94 321.72,66.79 322.25,66.26 322.51,66.26 322.66,66.1 322.66,65.83 v1(322.49,65.65)
  BOTTOM w0.102: v1(322.49,65.65) 322.36,65.52 R10025.1 ; C8023.1 342.63,104.95 342.63,104.43 v1(342.42,104.23)
TBT_SNK0_ML3_N_L: length 5.6
  BOTTOM w0.102: U500.44 325.01,60.53 v6(324.7,60.83) 324.25,61.29 322.71,62.82 322.71,63.46 R10025.2
TBT_SNK0_ML3_P: length 50.2
  IN3 w0.076: v1(323.2,65.65) 322.92,65.93 322.92,66.21 322.61,66.51 322.36,66.51 321.98,66.89 321.98,67.83 322.92,68.77 322.92,70.27 325.03,72.38 325.03,74.15 331.3,80.43 331.3,80.68 338.65,88.02 338.65,99.13 342.91,103.39 342.91,104.23 v1(343.06,104.38)
  BOTTOM w0.102: R10024.1 323.37,65.47 v1(323.2,65.65) ; v1(343.06,104.38) 342.96,104.48 342.96,104.92 C8021.1
TBT_SNK0_ML3_P_L: length 5.6
  BOTTOM w0.102: R10024.2 323.04,63.48 323.04,62.96 v6(323.68,62.32) 325.36,60.64 325.36,59.98 325.41,59.93 U500.45
TBT_SNK1_AUX_N: length 97.4
  IN1 w0.076: v1(343.39,29.81) 343.21,29.81 343.08,29.68 343.08,29.29 343.2,29.17 344.63,29.17 345.9,30.44 345.9,31.01 347.14,32.25 349.05,32.25 350.55,33.75 351.43,33.75 356.38,38.7 356.38,42.37 356.71,42.7 356.71,44.72 357.92,45.92 357.92,53.99 358.38,54.45 358.38,56.5 358.68,56.81 358.68,58.62 361.98,61.93 361.98,68.35 360.71,69.62 360.71,86.06 358.48,88.29 358.48,102.14 358.22,102.39 358.22,107.38 v1(358.25,107.41)
  BOTTOM w0.102: v1(343.39,29.81) 343.22,29.81 342.86,30.17 342.86,30.6 343.01,30.75 343.14,30.75 343.45,30.44 R10037.1 ; v1(358.25,107.41) 358.48,107.63 358.48,108.44 357.2,109.72 356.32,109.72 356.24,109.64 C8042.1
TBT_SNK1_AUX_P: length 97.4
  IN1 w0.076: v1(342.63,29.81) 342.63,29.1 343.01,28.72 344.82,28.72 346.36,30.25 346.36,30.82 347.33,31.79 349.24,31.79 350.74,33.29 351.62,33.29 356.84,38.51 356.84,42.18 357.17,42.51 357.17,44.53 358.38,45.73 358.38,53.8 358.83,54.26 358.83,56.31 359.14,56.62 359.14,58.43 362.44,61.74 362.44,68.54 361.17,69.81 361.17,86.25 358.93,88.48 358.93,102.33 358.68,102.58 358.68,107.2 v1(358.88,107.41)
  BOTTOM w0.102: v1(342.63,29.81) 342.53,29.91 342.53,30.33 R10036.1 ; C8040.1 356.26,110.05 357.33,110.05 358.81,108.57 358.81,107.48 v1(358.88,107.41)
TBT_SNK1_AUXN_R: length 4.6
  BOTTOM w0.102: R10037.2 343.16,31.62 343.16,32.84 R542.1 343.29,33.25 343.16,33.37 343.16,33.69 342.57,34.28 U501.57
TBT_SNK1_AUXP_R: length 4.6
  BOTTOM w0.102: R10036.2 342.83,31.62 342.83,32.84 R544.1 342.71,33.25 342.83,33.36 342.83,33.55 342.17,34.21 U501.58
TBT_SNK1_HPD: length 127.9
  TOP w0.114: v3(349.35,110.05) 349.07,109.77 349.07,109.7 348.98,109.61 348.98,109.03 348.72,108.77 348.72,107.33 348.52,107.13 R8002.1
  IN1 w0.076: v1(350.68,34.25) 350.17,34.25 348.71,32.79 346.69,32.79 344.2,30.3 340.89,30.3 339.6,29.02 337.08,29.02 v1(336.65,28.59)
  IN2 w0.089: v1(336.65,28.59) 336.65,29.01 338.13,30.49 338.13,33.09 338.31,33.26 338.31,41.24 337.6,41.95 337.01,41.95 334.54,44.42 334.54,46.32 333.74,47.12 333.74,48.07 333.06,48.75 333.06,51.66 333.48,52.08 333.48,52.69 332.91,53.27 332.91,53.46 332.14,54.22 331.82,54.22 331.37,54.67 331.33,54.67 330.05,55.95 330.05,56.79 329.34,57.5 328.79,57.5 328.33,57.96 328.33,58.7 326.48,60.54 325.67,60.54 323.76,62.46 323.54,62.46 321.16,64.84 321.16,68.06 325.11,72.01 325.11,73.1 326.31,74.3 326.71,74.3 327.31,74.89 327.31,75.3 333.38,81.37 333.38,82.11 336.37,85.09 336.37,89.87 337.9,91.4 337.9,94.22 338.51,94.83 339.28,94.83 339.63,95.17 339.63,99.33 340.72,100.42 340.72,104.94 341.97,106.19 346.74,106.19 349.1,108.55 349.1,109.8 v3(349.35,110.05)
  BOTTOM w0.114: U8001.Y4 v3(349.35,110.05) ; R10039.1 v1(350.68,34.25)
TBT_SNK1_HPD_L: length 9.7
  IN1 w0.076: v1(348.52,34.13) 346.84,34.13 344.33,36.64 v1(344.33,38.32)
  BOTTOM w0.114: v1(344.33,38.32) 344.25,38.24 U501.49 ; v1(348.52,34.13) 348.65,34.25 R10039.2 R10011.2
TBT_SNK1_ML0_N: length 104.4
  IN1 w0.076: v3(348.27,123.87) 348.44,123.69 348.44,123.41 350.09,121.76 350.09,121.31 351.49,119.92 351.49,118.33 351.77,118.05 351.77,113.77 353.38,112.16 353.38,102.54 352.72,101.88 352.72,99.7 352.01,98.99 352.01,81.68 352.97,80.72 352.97,68.41 353.46,67.91 353.46,62.18 351.82,60.54 351.82,47.67 351.36,47.21 346.27,47.21 345.76,46.7 345.76,45.3 344.2,43.74 344.2,39.21 346.62,36.79 347.89,36.79 348.39,36.29 348.39,35.69 348.08,35.37 347.66,35.37 v1(347.5,35.52)
  BOTTOM w0.102: C8029.1 348.3,122.99 348.3,123.83 v3(348.27,123.87) ; R10029.1 346.88,35.28 346.96,35.19 347.45,35.19 347.5,35.25 v1(347.5,35.52)
TBT_SNK1_ML0_N_L: length 3.6
  BOTTOM w0.102: U501.53 344.49,36.64 345.69,35.45 345.98,35.45 346.1,35.57 R10029.2
TBT_SNK1_ML0_P: length 104.4
  IN1 w0.076: v1(347.5,34.76) 347.66,34.91 348.27,34.91 348.85,35.5 348.85,36.48 348.07,37.25 346.8,37.25 344.66,39.4 344.66,43.55 346.22,45.11 346.22,46.51 346.46,46.75 351.55,46.75 352.28,47.48 352.28,60.35 353.92,61.99 353.92,68.1 353.42,68.6 353.42,80.91 352.47,81.87 352.47,98.8 353.18,99.51 353.18,101.69 353.84,102.35 353.84,112.35 352.23,113.96 352.23,118.24 351.95,118.52 351.95,120.11 350.55,121.5 350.55,121.95 348.9,123.6 v3(348.9,123.87)
  BOTTOM w0.102: v3(348.9,123.87) 348.64,123.6 348.64,123.11 C8028.1 ; R10028.1 v1(347.5,34.76)
TBT_SNK1_ML0_P_L: length 3.7
  BOTTOM w0.102: U501.54 343.77,36.24 343.83,36.3 344.37,36.3 345.55,35.12 346.01,35.12 346.1,35.02 R10028.2
TBT_SNK1_ML1_N: length 105.2
  TOP w0.102: C8031.1 349.49,122.87 349.41,122.95 349.41,123.3 349.53,123.42 350.15,123.42 350.29,123.56 350.29,123.74 350.16,123.87 v3(350.04,123.87)
  IN1 w0.076: v1(350.55,37.56) 350.55,37.44 350.74,37.25 350.93,37.25 351.14,37.46 351.14,40.62 356.7,46.18 356.7,54.24 357.23,54.78 357.23,58.9 359.7,61.37 359.7,64.49 360.78,65.57 360.78,68.09 359.62,69.24 359.62,82.59 356.67,85.54 356.67,110.12 357.08,110.53 357.08,112.55 356.72,112.91 356.72,122.18 355.68,123.22 355.68,124.37 355,125.06 350.44,125.06 349.97,124.59 349.97,123.94 v3(350.04,123.87)
  BOTTOM w0.102: v1(350.55,37.56) 350.55,37.4 350.27,37.12 349.71,37.12 349.61,37.23 349.61,37.5 R10031.1
TBT_SNK1_ML1_N_L: length 6.9
  BOTTOM w0.102: R10031.2 349.02,37.4 348.92,37.3 348.57,37.3 v1(348.09,37.78) 348.09,37.43 348.01,37.35 347.66,37.35 347.29,37.72 344.04,37.72 343.92,37.84 U501.50
TBT_SNK1_ML1_P: length 105.2
  TOP w0.102: C8030.1 349.08,122.92 349.08,123.43 v3(349.51,123.87)
  IN1 w0.076: v1(350.55,36.79) 351.12,36.79 351.6,37.27 351.6,40.43 357.16,45.99 357.16,54.05 357.69,54.59 357.69,58.71 360.15,61.18 360.15,64.3 361.23,65.38 361.23,68.28 360.08,69.43 360.08,82.78 357.13,85.73 357.13,109.93 357.54,110.34 357.54,112.74 357.18,113.1 357.18,122.37 356.14,123.41 356.14,124.56 355.19,125.52 350.25,125.52 349.51,124.78 v3(349.51,123.87)
  BOTTOM w0.102: v1(350.55,36.79) 349.93,36.79 R10030.1
TBT_SNK1_ML1_P_L: length 6.9
  BOTTOM w0.102: U501.51 343.85,37.44 343.85,37.44 343.9,37.39 347.15,37.39 347.52,37.02 348.04,37.02 348.11,36.95 v1(348.11,36.51) 348.57,36.97 348.94,36.97 349.02,36.9 R10030.2
TBT_SNK1_ML2_N: length 96.7
  IN1 w0.076: v1(351.31,123.92) 351.14,123.74 351.14,123.2 351.64,122.7 351.64,121.89 352.99,120.54 352.99,119 353.63,118.37 353.63,114.04 354.88,112.78 354.88,101.92 354.44,101.48 354.44,100.73 354.22,100.51 354.22,88.88 354.55,88.55 354.55,68.99 356.09,67.45 356.09,64.11 355.89,63.91 355.89,62.49 353.98,60.58 353.98,57.39 354.49,56.89 354.49,47.32 353.79,46.62 353.41,46.62 351.83,45.05 349.13,45.05 346.95,42.86 346.95,40.2 346.62,39.87 346.62,39.22 346.81,39.02 347.17,39.02 347.17,39.03 347.28,39.03 347.35,39.11 v1(347.35,39.21)
  BOTTOM w0.102: v1(351.31,123.92) 351.09,123.69 351.09,123.22 C8035.1 ; v1(347.35,39.21) 347.35,39.16 347,38.8 346.69,38.8 346.62,38.88 346.62,39.1 R10033.1
TBT_SNK1_ML2_N_L: length 3
  BOTTOM w0.102: R10033.2 345.64,38.9 344.85,38.9 344.64,39.1 344.02,39.1 343.92,39 343.77,39 343.73,39.04 U501.47
TBT_SNK1_ML2_P: length 96.8
  IN1 w0.076: v1(347.37,38.56) 346.62,38.56 346.16,39.03 346.16,40.06 346.49,40.39 346.49,43.05 348.94,45.51 351.64,45.51 353.22,47.08 353.6,47.08 354.03,47.51 354.03,56.7 353.52,57.2 353.52,60.77 355.43,62.68 355.43,64.1 355.63,64.3 355.63,67.26 354.1,68.8 354.1,88.36 353.77,88.69 353.77,100.7 353.98,100.92 353.98,101.66 354.43,102.11 354.43,112.59 353.17,113.85 353.17,118.18 352.53,118.81 352.53,120.35 351.19,121.7 351.19,122.51 350.68,123.02 v1(350.68,123.92)
  BOTTOM w0.102: R10032.1 347,38.47 347.28,38.47 v1(347.37,38.56) ; v1(350.68,123.92) 350.76,123.83 350.76,123.46 C8033.1
TBT_SNK1_ML2_P_L: length 3
  BOTTOM w0.102: U501.48 343.82,38.64 343.85,38.67 344.05,38.67 344.15,38.77 344.51,38.77 344.71,38.57 345.57,38.57 R10032.2
TBT_SNK1_ML3_N: length 95.6
  IN1 w0.076: v1(352.84,123.92) 352.53,123.61 352.53,123.43 352.69,123.28 352.69,122.33 353.89,121.12 354.11,121.12 356.09,119.14 356.09,101.65 355.48,101.04 355.48,97.26 356.09,96.65 356.09,91.45 355.45,90.82 355.45,89.31 355.64,89.12 355.64,85.74 356.5,84.89 356.5,68.52 357.13,67.88 357.99,67.02 357.99,63.53 357.74,63.27 357.74,60.53 356.11,58.91 356.11,46.42 351.52,41.82 350.2,41.82 349.64,42.38 348.49,42.38 348.19,42.08 348.19,41.54 348.38,41.35 348.69,41.35 v1(348.85,41.52)
  BOTTOM w0.102: R10035.1 348.06,41.53 348.06,41.37 348.16,41.26 348.6,41.26 v1(348.85,41.52) ; C8039.1 352.58,123.25 352.58,123.66 v1(352.84,123.92)
TBT_SNK1_ML3_N_L: length 5.2
  BOTTOM w0.102: U501.44 343.73,40.24 343.77,40.2 346.22,40.2 346.64,40.61 346.64,41.07 346.94,41.37 347.33,41.37 347.44,41.48 R10035.2
TBT_SNK1_ML3_P: length 95.6
  IN1 w0.076: v1(348.85,40.88) 348.84,40.9 348.19,40.9 347.73,41.35 347.73,42.27 348.31,42.84 349.83,42.84 350.39,42.28 351.33,42.28 355.66,46.61 355.66,59.1 357.28,60.72 357.28,63.46 357.54,63.72 357.54,66.83 356.67,67.69 356.04,68.33 356.04,84.7 355.19,85.55 355.19,88.93 355,89.12 355,91.01 355.63,91.64 355.63,96.46 355.02,97.07 355.02,101.23 355.63,101.84 355.63,118.95 353.92,120.66 353.7,120.66 352.23,122.14 352.23,123.09 352.08,123.24 v1(352.08,123.92)
  BOTTOM w0.102: C8037.1 352.25,123.43 352.25,123.74 v1(352.08,123.92) ; R10034.1 348.43,40.88 v1(348.85,40.88)
TBT_SNK1_ML3_P_L: length 5.3
  BOTTOM w0.102: R10034.2 347.44,40.97 347.38,41.04 347.07,41.04 346.97,40.93 346.97,40.48 346.36,39.87 343.77,39.87 343.74,39.84 U501.45
TBT_TCK: length 5.6
  TOP w0.076: 341.28,109.69 341.28,110.37 v3(341.59,110.68)
  TOP w0.114: R8016.1 343.49,107.74 TP8001.1 342.93,108.29 342.93,108.55 342.55,108.93 342.04,108.93 341.28,109.69
  BOTTOM w0.114: U8001.W19 v3(341.59,110.68)
TBT_TDI: length 4.8
  TOP w0.114: v3(340.97,110.68) 340.52,110.23 340.52,109.44 340.9,109.06 TP8000.1 341.51,107.18 R8014.1
  BOTTOM w0.114: v3(340.97,110.68) 340.97,110.71 U8001.W20
TBT_TDO: length 5.2
  TOP w0.114: v3(341.62,110.06) 342.4,109.28 343.21,109.28 TP8003.1 343.82,108.68 343.82,108.09 344.51,107.41 R8017.1
  BOTTOM w0.114: U8001.Y19 v3(341.62,110.06)
TBT_TMS: length 4.2
  TOP w0.114: v3(340.96,110.07) 340.96,109.63 341.92,108.68 341.92,108.04 TP8002.1 342.5,107.46 R8015.1
  BOTTOM w0.114: U8001.Y20 340.98,110.07 v3(340.96,110.07)
TBT_TMU_CLK_OUT: length 6.7
  BOTTOM w0.076: U8001.Y1 350.34,110.57 351.14,109.77 351.14,108.78 351.75,108.17 351.75,107.38
  BOTTOM w0.114: R8040.1 353.37,105.75 v1(352.5,106.62) 351.75,107.38
TBT_USB_FORCE_PWR: length 6.7
  TOP w0.076: 349.67,109.82 349.67,110.81 349.49,110.99 349.06,110.99 v3(348.73,111.33)
  TOP w0.114: 349.67,109.82 349.67,109.7 v1(349.41,109.44) 349.41,109.13 348.95,108.68 348.95,106.86 R8035.1
  BOTTOM w0.114: U8001.V5 v3(348.73,111.33)
TBT_WAKE#: length 27.7
  TOP w0.114: 350.49,102.34 350.03,102.8 Q9043.3 ; 350.49,102.34 350.6,102.23 352.36,102.23 353.27,103.14 Q8012.1 356.34,104.87 357.28,104.87 v1(357.66,104.48) 357.79,104.36 R8530.1 ; 350.49,102.34 350.49,101.63 350.48,101.63 350.48,99.04 351.69,97.83 Q8000.1
  BOTTOM w0.076: 351.56,107.53 351.56,108.07 350.97,108.66 350.97,109.72 350.38,110.31 350.01,110.31 U8001.Y2
  BOTTOM w0.114: v1(357.66,104.48) 356.39,104.48 R8010.2 355.12,104.99 354.87,105.25 353.22,105.25 v1(353.02,105.45) 351.56,106.91 351.56,107.53
TBT_XTAL_25_IN: length 3.4
  BOTTOM w0.076: 338.92,118.48 339.25,118.15 340.34,118.15 U8001.D22
  BOTTOM w0.114: 338.92,118.48 338.61,118.48 338.3,118.79 L8000.3
TBT_XTAL_25_OUT: length 3.6
  BOTTOM w0.076: U8001.D23 340.05,117.98 338.87,117.98
  BOTTOM w0.114: 338.87,117.98 338.4,117.98 338.11,118.28 337.24,118.28 336.97,118.55 L8000.2
TBTA_AUX_N: length 3.2
  TOP w0.102: C8026.2 351.6,115.73 351.52,115.81 351.33,115.81 350.93,115.42 349.55,115.42 v3(349.35,115.23)
  BOTTOM w0.114: v3(349.35,115.23) 349.35,115.25 U8001.J4
TBTA_AUX_P: length 3.2
  TOP w0.102: C8024.2 351.6,116.13 351.48,116.02 351.24,116.02 350.85,115.62 v6(350.26,115.62) 349.63,115.62 v3(349.38,115.88)
  BOTTOM w0.114: U8001.H4 v3(349.38,115.88)
TBTA_CA2HD_1_RX_N: length 24.4
  TOP w0.102: CON7100.A10 361.47,133.71 361.31,133.87 360.53,133.87 arc(360.27,133.93) 360.04,134.08 359.97,134.15 359.77,134.35 arc(359.67,134.42) 359.55,134.44 359.28,134.44 arc(359.09,134.4) 358.92,134.29 R17931.1 358.69,134.3 arc(358.52,134.41) 358.33,134.44 358.25,134.44 arc(358.06,134.41) 357.9,134.3 D7112.2 357.5,134.23 arc(357.33,134.34) 357.14,134.38 356.43,134.38 arc(356.24,134.34) 356.08,134.23 349.39,127.54 arc(349.22,127.43) 349.03,127.4 v6(345.85,127.4) 345.17,127.4 arc(345.06,127.37) 344.96,127.31 343.09,125.44 arc(343.03,125.3) 343.01,125.16 343.01,125.03 arc(343.02,124.92) 343.06,124.8 arc(343.13,124.73) 343.23,124.7 arc(343.36,124.67) C8013.1
TBTA_CA2HD_1_RX_P: length 24.4
  TOP w0.102: CON7100.A11 361.5,134.21 361.37,134.08 360.53,134.08 arc(360.35,134.11) 360.19,134.22 360.11,134.3 359.91,134.49 arc(359.75,134.6) 359.55,134.64 359.24,134.64 arc(359.05,134.68) 358.88,134.79 R17930.1 358.74,134.8 arc(358.57,134.69) 358.38,134.65 358.2,134.65 arc(358.01,134.69) 357.85,134.8 D7110.2 357.42,134.73 arc(357.25,134.62) 357.06,134.58 356.43,134.58 arc(356.16,134.53) 355.93,134.38 v6(350.25,128.69) 349.24,127.69 arc(349.15,127.62) 349.03,127.6 345.17,127.6 arc(344.98,127.56) 344.81,127.45 342.93,125.57 arc(342.84,125.37) 342.81,125.16 342.81,125.06 arc(342.8,125.05) 342.8,125.04 arc(342.79,124.97) 342.77,124.89 arc(342.67,124.75) C8012.1
TBTA_CA2HD_2_RX_N: length 23.4
  TOP w0.102: v3(362.88,130.18) 362.91,130.21 CON7100.B10
  BOTTOM w0.102: C8011.1 343.36,124.96 arc(343.38,125) 343.39,125.04 343.39,125.09 arc(343.42,125.23) 343.5,125.36 343.66,125.51 344.73,126.59 arc(344.9,126.7) 345.09,126.74 v6(346.26,126.74) 349.17,126.74 arc(349.29,126.76) 349.39,126.82 351.94,129.38 arc(352.11,129.49) 352.3,129.53 358.48,129.53 arc(358.68,129.57) 358.84,129.68 D7111.2 359.17,129.54 arc(359.26,129.48) 359.37,129.45 arc(359.48,129.47) 359.57,129.54 R17933.1 359.98,129.63 arc(360.15,129.52) 360.34,129.48 361.62,129.48 arc(361.81,129.52) 361.98,129.63 362.27,129.91 arc(362.4,130.01) 362.56,130.04 362.74,130.04 arc(362.84,130.08) v3(362.88,130.18)
TBTA_CA2HD_2_RX_P: length 23.4
  TOP w0.102: v3(362.88,129.65) 362.94,129.71 CON7100.B11
  BOTTOM w0.102: C8017.1 343.99,124.69 arc(343.71,124.8) 343.59,125.08 343.59,125.09 arc(343.61,125.16) 343.64,125.21 343.8,125.37 344.66,126.23 344.86,126.42 arc(344.97,126.5) 345.1,126.53 arc(345.11,126.53) 345.12,126.53 v6(348.09,126.53) 349.17,126.53 arc(349.37,126.57) 349.53,126.68 352.09,129.24 arc(352.19,129.3) 352.3,129.33 358.25,129.33 arc(358.45,129.29) 358.61,129.18 D7113.2 359.18,129.11 arc(359.26,129.17) 359.34,129.21 359.43,129.25 arc(359.53,129.23) 359.62,129.17 R17932.1 359.98,129.13 arc(360.15,129.24) 360.34,129.28 361.62,129.28 arc(361.89,129.33) 362.12,129.48 362.41,129.77 arc(362.48,129.82) 362.56,129.83 362.69,129.83 arc(362.82,129.78) v3(362.88,129.65)
TBTA_CC1: length 59.2
  TOP w0.114: v1(343.85,93.49) 344.46,93.49 v3(344.48,93.51)
  IN2 w0.457: v3(344.48,93.51) 344.48,93.16 344.65,92.99
  IN2 w0.686: 344.65,92.99 346.6,91.04 v1(346.6,90.72) 347.07,90.72 347.71,91.35 347.71,92.24 348.66,93.19 350.13,93.19 350.55,93.61 350.55,95.46 351.57,96.48 351.57,98.34 352.8,99.57 352.8,102.2 354.57,103.96 354.57,109.04 355.1,109.58 355.1,111.42 356.98,113.3 356.98,121.6 357.92,122.54 357.92,124.81 358.29,125.19 v1(358.55,125.19) ; v1(364.67,132.35) 364.37,132.35 363.79,131.76 363.79,129.38 365.28,127.88 365.28,127.12 364.66,126.5 361.82,126.5 360.38,125.06 v1(360.2,125.06)
  BOTTOM w0.254: v3(344.48,93.51) 344.91,93.09 U8500.K2
  BOTTOM w0.508: C8507.2 347.25,90.07 v1(346.6,90.72)
TBTA_CC2: length 50.3
  TOP w0.457: v3(344.46,94.06) 344.09,94.06 C8512.2
  IN2 w0.457: v3(344.46,94.06) 344.96,94.06
  IN2 w0.686: v1(358.55,125.97) 357.98,125.97 357.14,125.14 357.14,122.86 356.2,121.92 356.2,113.62 354.32,111.74 354.32,109.9 353.79,109.36 353.79,104.28 352.03,102.52 352.03,99.9 350.79,98.66 350.79,97.7 348.8,95.71 348.8,94.54 347.82,93.56 346.8,93.56 346.3,94.06 344.96,94.06 ; v1(360.26,131.46) 360.26,131.48 359.7,132.04 359.06,132.04 358.55,131.54 358.55,130.01 359.7,128.87 359.7,126.58 v1(360.2,126.07)
  BOTTOM w0.254: U8500.H2 344.91,94.06 v3(344.46,94.06)
TBTA_DPSRC_AUX_N: length 32.6
  TOP w0.102: R8575.1 339.4,98.39 v1(339.12,98.39) 338.98,98.39 R8682.1 ; v3(352.58,115.69) 352.46,115.81 352.15,115.81 352.05,115.71 C8026.1
  IN4 w0.076: v1(339.12,98.39) 339.35,98.62 339.76,98.62 340.65,99.5 340.65,105.3 342.84,107.49 344.4,107.49 344.88,107.97 344.88,108.86 345.16,109.15 349.33,109.15 349.86,109.68 349.86,113.98 351.52,115.63 351.87,115.63 352.14,115.9 352.37,115.9 v3(352.58,115.69)
  BOTTOM w0.102: U8500.C11 340.29,96.73 340.12,96.73 339.91,96.94 339.91,98.18 339.47,98.62 339.35,98.62 v1(339.12,98.39)
TBTA_DPSRC_AUX_P: length 32.6
  TOP w0.102: C8024.1 352.05,116.1 352.13,116.02 352.38,116.02 v3(352.58,116.22) ; R8684.1 338.6,98.64 338.74,98.64 v1(339.12,99.02) 339.25,98.9 R8574.1
  IN4 w0.076: v1(339.12,99.02) 339.36,98.78 339.69,98.78 340.48,99.57 340.48,105.37 342.77,107.66 344.33,107.66 344.71,108.04 344.71,108.93 345.09,109.31 349.26,109.31 349.7,109.75 349.7,114.04 351.45,115.8 351.8,115.8 352.07,116.07 352.43,116.07 v3(352.58,116.22)
  BOTTOM w0.102: U8500.B11 340.28,96.93 340.21,96.93 340.11,97.03 340.11,98.26 339.55,98.82 339.33,98.82 v1(339.12,99.02)
TBTA_HD2CA_1_TX_N: length 27.5
  TOP w0.102: v3(362.88,133.79) 362.95,133.71 CON7100.B3
  BOTTOM w0.102: v3(362.88,133.79) 362.8,133.86 arc(362.71,133.93) 362.59,133.95 360.85,133.95 arc(360.57,134) 360.34,134.16 359.78,134.72 arc(359.68,134.79) 359.56,134.81 359.37,134.81 arc(359.19,134.78) 359.04,134.68 D7108.2 358.81,134.53 arc(358.79,134.6) 358.75,134.67 358.71,134.71 arc(358.59,134.79) 358.46,134.81 357.59,134.81 arc(357.4,134.77) 357.24,134.66 353.11,130.54 arc(352.95,130.43) 352.75,130.39 352.29,130.39 arc(352.09,130.35) 351.93,130.24 349.18,127.49 arc(349.01,127.38) 348.82,127.34 344.54,127.34 arc(344.34,127.31) 344.18,127.2 v6(342.54,125.55) 341.96,124.98 arc(341.85,124.81) 341.81,124.62 341.81,124.44 arc(341.87,124.32) 341.99,124.27 C8015.1
TBTA_HD2CA_1_TX_P: length 27.5
  TOP w0.102: CON7100.B2 362.96,134.21 v3(362.85,134.32)
  BOTTOM w0.102: C8009.1 341.56,124.42 arc(341.6,124.48) 341.61,124.55 341.61,124.62 arc(341.67,124.89) 341.82,125.12 v6(343.49,126.79) 344.04,127.34 arc(344.27,127.49) 344.54,127.55 348.82,127.55 arc(348.93,127.57) 349.03,127.64 351.78,130.39 arc(352.01,130.54) 352.29,130.6 352.75,130.6 arc(352.87,130.62) 352.97,130.69 357.09,134.81 arc(357.32,134.96) 357.59,135.02 358.25,135.02 arc(358.45,135.05) 358.61,135.16 D7106.2 359,135.16 arc(359.17,135.05) 359.36,135.02 359.56,135.02 arc(359.76,134.98) 359.92,134.87 360.49,134.3 arc(360.65,134.19) 360.85,134.15 362.59,134.15 arc(362.68,134.17) 362.75,134.22 v3(362.85,134.32)
TBTA_HD2CA_2_TX_N: length 20.1
  TOP w0.102: CON7100.A3 361.58,130.21 arc(361.48,130.19) 361.4,130.14 arc(361.32,130.08) 361.22,130.06 361.15,130.06 arc(360.88,130.01) 360.65,129.85 360.36,129.57 arc(360.26,129.5) 360.15,129.48 359.82,129.48 arc(359.62,129.52) 359.46,129.63 D7115.2 359.16,129.61 arc(358.99,129.5) 358.8,129.47 357.86,129.47 arc(357.75,129.49) 357.65,129.56 357.58,129.63 arc(357.34,129.78) 357.07,129.83 v6(354.69,129.83) 352.85,129.83 arc(352.57,129.78) 352.34,129.63 349.59,126.88 arc(349.49,126.81) 349.38,126.79 346.23,126.79 arc(345.74,126.71) 345.28,126.5 arc(344.99,126.28) 344.73,126.03 arc(344.61,125.82) 344.55,125.59 arc(344.49,125.41) C8022.1
TBTA_HD2CA_2_TX_P: length 20
  TOP w0.102: CON7100.A2 361.63,129.71 arc(361.53,129.73) 361.45,129.78 arc(361.36,129.84) 361.27,129.86 361.15,129.86 arc(360.96,129.82) 360.79,129.71 360.51,129.42 arc(360.34,129.31) 360.15,129.28 359.94,129.28 arc(359.75,129.24) 359.59,129.13 D7117.2 359.06,129.11 arc(358.89,129.22) 358.7,129.26 357.86,129.26 arc(357.67,129.3) 357.5,129.41 357.43,129.48 arc(357.27,129.59) 357.07,129.63 352.85,129.63 arc(352.65,129.59) 352.49,129.48 349.74,126.73 arc(349.57,126.62) 349.38,126.58 v6(348.11,126.58) 346.23,126.58 arc(345.8,126.52) 345.4,126.33 345.37,126.31 arc(345.12,126.12) 344.89,125.9 arc(344.8,125.74) 344.76,125.57 arc(344.84,125.35) C8020.1
TBTA_HPD: length 37.3
  IN1 w0.076: v1(343.06,90.64) 342.68,91.02 341.13,91.02 340.25,91.9 340.25,99.06 341.41,100.22 341.41,104.85 344.1,107.55 348.25,107.55 350.59,109.88 350.59,111.79 v3(350.93,112.13)
  BOTTOM w0.076: U8500.K7 342.17,92.83 342.17,91.28 v1(341.92,91.02) ; v3(350.93,112.13) 350.91,112.16 350.01,112.16 U8001.T2
  BOTTOM w0.114: v1(341.92,91.02) 341.92,90.02 R8557.1 R8501.2 343.19,90.51 v1(343.06,90.64)
TBTA_I2C_INT#: length 26.4
  TOP w0.114: R8008.2 350.83,113.22 v1(350.17,113.88) 349.37,113.88 v3(349.35,113.9)
  IN3 w0.089: v3(344.35,95.13) 344.5,95.13 344.94,95.57 344.94,96.28 346.59,97.94 346.59,98.8 349.13,101.34 349.28,101.34 350.26,101.34 350.48,101.56 350.48,105.27 350.04,105.7 350.04,106.16 350.62,106.74 350.62,108.89 350.42,109.09 350.42,113.38 349.9,113.9 v3(349.35,113.9)
  BOTTOM w0.076: U8500.F2 344.89,95.13 v3(344.35,95.13)
  BOTTOM w0.114: U8001.M4 349.35,113.95 v3(349.35,113.9)
TBTA_RX1_N: length 3
  TOP w0.102: C8013.2 343.24,123.88 343.16,123.8 arc(343.12,123.75) 343.11,123.69 343.11,123.57 arc(343.1,123.53) 343.08,123.5 342.89,123.31 arc(342.86,123.29) 342.82,123.28 341.63,123.28 arc(341.53,123.26) 341.44,123.2 341.4,123.16 arc(341.37,123.12) 341.36,123.07 341.36,122.98 341.46,122.87 R8049.1
TBTA_RX1_P: length 3
  TOP w0.102: R8048.1 341.06,122.87 arc(341.1,122.88) 341.13,122.9 arc(341.15,122.93) 341.15,122.96 341.15,123.07 arc(341.18,123.19) 341.25,123.3 341.29,123.34 arc(341.45,123.45) 341.63,123.48 342.78,123.48 342.91,123.61 342.91,123.71 arc(342.89,123.79) 342.85,123.85 342.84,123.86 arc(342.79,123.88) 342.74,123.88 C8012.2
TBTA_RX1N_R: length 4
  TOP w0.102: v3(341.36,121.63) 341.32,121.67 arc(341.29,121.71) 341.28,121.76 341.28,121.93 arc(341.3,122.03) 341.36,122.11 R8049.2
  BOTTOM w0.076: v3(341.36,121.63) 341.27,121.55 arc(341.21,121.45) 341.19,121.34 341.19,120.94 arc(341.16,120.79) 341.07,120.66 341.05,120.63 arc(340.98,120.53) 340.95,120.4 340.95,119.82 arc(340.96,119.77) 340.99,119.73 341.18,119.54 arc(341.23,119.46) 341.24,119.38 341.24,119.27 arc(341.21,119.19) 341.13,119.15 arc(341.05,119.19) 341.02,119.27 U8001.A21
TBTA_RX1P_R: length 4
  TOP w0.102: v3(340.82,121.63) 341,121.81 arc(341.06,121.89) 341.08,121.99 341.08,122.14 arc(341.06,122.24) 341,122.32 R8048.2
  BOTTOM w0.076: v3(340.82,121.63) 340.93,121.52 arc(341.01,121.41) 341.03,121.27 341.03,120.94 arc(341.02,120.85) 340.96,120.76 340.94,120.74 arc(340.84,120.59) 340.8,120.4 340.8,119.12 arc(340.81,119.07) 340.84,119.03 U8001.B21
TBTA_RX2_N: length 1.1
  BOTTOM w0.102: R8053.1 343.43,123.37 arc(343.46,123.41) 343.47,123.46 343.47,123.53 arc(343.35,123.8) C8011.2
TBTA_RX2_P: length 1.1
  BOTTOM w0.102: R8052.1 343.71,123.37 arc(343.68,123.41) 343.67,123.46 343.67,123.5 arc(343.79,123.79) C8017.2
TBTA_RX2N_R: length 4.1
  BOTTOM w0.076: U8001.B15 343.6,119.03 arc(343.57,119.07) 343.56,119.12 v5(343.56,120.97) 343.56,122.19 arc(343.52,122.38) 343.41,122.55 343.35,122.61 arc(343.28,122.66) R8053.2
TBTA_RX2P_R: length 4.1
  BOTTOM w0.076: R8052.2 343.86,122.59 arc(343.75,122.42) 343.71,122.23 343.71,119.81 arc(343.72,119.76) 343.75,119.72 343.96,119.51 arc(343.99,119.47) 344,119.42 344,119.2 arc(343.97,119.12) 343.89,119.09 arc(343.81,119.12) 343.78,119.2 U8001.A15
TBTA_SBU1: length 47.2
  IN4 w0.076: v1(345.09,102.07) 345.08,102.06 345.08,100.92 344.96,100.8 344.96,97.55 345.4,97.12 348.18,97.12 351.1,100.03 351.1,101.14 354.83,104.88 354.83,111.97 356.2,113.34 356.2,117.5 357.79,119.09 357.79,123.28 359.32,124.8 359.32,126.2 360.08,126.96 v1(360.75,126.96)
  BOTTOM w0.114: v1(345.09,102.07) 345.62,102.07 346.49,101.21 R8533.2 ; v1(360.75,126.96) D7114.2 360.01,127.28 359.7,127.6 R7176.2
TBTA_SBU1_L: length 8.2
  TOP w0.114: CON7100.B8 364.23,131.21 v3(364.65,131.64)
  IN4 w0.076: v1(360.75,127.98) 360.75,129.7 362.27,131.23 364.25,131.23 v3(364.65,131.64)
  BOTTOM w0.114: v1(360.75,127.98) 360.64,127.88 R7176.1
TBTA_SBU1_R: length 3.7
  BOTTOM w0.114: R8533.1 346.49,99.65 345.69,98.85 345.28,98.85 344.71,98.28 344.71,97.97 344.43,97.69 U8500.A3
TBTA_SBU2: length 48.6
  TOP w0.114: v1(360.25,132.59) 360.14,132.71 R7175.2
  IN4 w0.076: v1(345.47,101.56) 345.85,101.18 345.85,97.92 346.5,97.27 348.12,97.27 350.95,100.1 350.95,101.21 354.68,104.94 354.68,112.03 356.05,113.4 356.05,117.57 357.64,119.15 357.64,128.57 359.82,130.75 359.82,132.16 v1(360.25,132.59)
  BOTTOM w0.114: D7116.2 360.25,132.64 v1(360.25,132.59) ; R8534.2 v1(345.47,101.56)
TBTA_SBU2_L: length 2.5
  TOP w0.114: R7175.1 360.27,133.16 360.59,132.84 361.39,132.84 361.52,132.71 CON7100.A8
TBTA_SBU2_R: length 4.2
  BOTTOM w0.114: R8534.1 345.73,100.16 345.9,100 345.9,99.41 345.6,99.11 345.17,99.11 344.47,98.4 344.13,98.4 343.93,98.21 U8500.A4
TBTA_TX1_N: length 0.9
  BOTTOM w0.102: R8051.1 341.93,123.37 arc(341.9,123.41) 341.89,123.46 341.89,123.49 arc(341.9,123.53) 341.93,123.58 C8015.2
TBTA_TX1_P: length 0.9
  BOTTOM w0.102: C8009.2 341.65,123.58 arc(341.68,123.53) 341.69,123.49 341.69,123.46 arc(341.68,123.41) 341.65,123.37 R8050.1
TBTA_TX1N_R: length 4.1
  BOTTOM w0.076: R8051.2 342.02,122.52 arc(341.91,122.36) 341.87,122.17 v5(341.87,120.77) 341.87,119.8 arc(341.88,119.75) 341.91,119.71 342.13,119.48 arc(342.15,119.44) 342.16,119.39 342.16,119.14 arc(342.16,119.09) 342.14,119.05 U8001.B19
TBTA_TX1P_R: length 4.1
  BOTTOM w0.076: U8001.A19 341.94,119.19 arc(341.91,119.11) 341.83,119.08 arc(341.75,119.11) 341.72,119.19 341.72,122.31 arc(341.69,122.45) 341.61,122.57 341.54,122.64 arc(341.5,122.67) 341.46,122.67 R8050.2
TBTA_TX2_N: length 3.4
  TOP w0.102: R8055.1 343.03,122.87 343.08,122.93 343.08,123 arc(343.11,123.15) 343.2,123.28 343.26,123.34 arc(343.39,123.43) 343.56,123.46 344.03,123.46 arc(344.13,123.48) 344.22,123.54 344.5,123.82 344.51,123.82 arc(344.58,123.94) 344.61,124.07 344.61,124.58 arc(344.53,124.76) C8022.2
TBTA_TX2_P: length 3.4
  TOP w0.102: R8054.1 343.34,122.87 343.29,122.93 343.29,123 arc(343.3,123.07) 343.34,123.13 343.4,123.19 arc(343.47,123.24) 343.56,123.26 344.03,123.26 arc(344.21,123.29) 344.37,123.4 344.43,123.46 344.65,123.68 344.65,123.68 arc(344.77,123.86) 344.81,124.07 344.81,124.58 arc(344.89,124.76) C8020.2
TBTA_TX2N_R: length 3.9
  TOP w0.102: R8055.2 342.81,122.12 arc(342.79,122.02) 342.73,121.94 v3(342.42,121.63)
  BOTTOM w0.076: U8001.B17 342.68,119.03 arc(342.65,119.07) 342.64,119.12 342.64,121.27 arc(342.61,121.4) 342.54,121.52 v3(342.42,121.63)
TBTA_TX2P_R: length 3.9
  TOP w0.102: v3(342.96,121.63) 342.96,121.72 arc(342.97,121.8) 343.02,121.88 R8054.2
  BOTTOM w0.076: v3(342.96,121.63) 342.92,121.6 arc(342.83,121.45) 342.79,121.27 342.79,119.82 arc(342.8,119.77) 342.83,119.73 343.05,119.51 arc(343.07,119.47) 343.08,119.42 343.08,119.33 arc(343.05,119.25) 342.97,119.22 arc(342.89,119.25) 342.86,119.33 U8001.A17
TBTA_VBUS_L: length 56.7
  TOP w0.254: v3(360.64,133.3) v3(361.18,133.3) 361.27,133.21 CON7100.A9 362.8,133.21 v3(362.87,133.14) 362.94,133.21 CON7100.B4 ; v3(360.44,130.77) v3(361,130.77) 361.06,130.71 CON7100.A4 362.76,130.71 v3(362.9,130.85) 363.04,130.71 CON7100.B9
  IN1 w0.508: v1(358.81,126.68) 359.44,126.05 359.44,124.8 359.82,124.42 360.84,124.42 v1(360.97,124.55)
  IN2 w0.508: v1(358.3,127.22) 357.28,127.22 356.46,126.39 356.46,123.15 355.52,122.21 355.52,113.91 353.64,112.03 353.64,110.18 352.8,109.34 352.8,104.26 350.68,102.14 350.68,100.42 349.66,99.4 349.66,98.26 348.65,97.25 347.1,97.25 v3(345.93,96.08)
  BOTTOM w0.254: v3(345.93,96.08) 345.88,96.08 345.87,96.09 U8500.D1
  BOTTOM w0.381: R7101.2 360.59,124.17 v1(360.97,124.55)
  BOTTOM w0.508: v4(343.9,137.3) 343.24,137.3 342.93,137.61 342.93,138.52 342.17,139.28 PQ10002.1 341.41,139.28 341.02,139.67 PR10000.2 ; v4(343.9,136.57) 343.9,135.07 343.53,134.7 PR26013.2
  vias: v1(346.21,136.72) v1(355.15,140.71) v1(355.15,140.07) v1(355.78,140.71) v1(355.78,140.07) v1(356.52,139.79) v1(357.16,139.66) v1(358.3,128.49) v1(358.3,127.85) v1(364.88,133.59) v3(364.52,129.96) v3(364.88,133.01) v3(365.06,129.96) v4(344.66,137.3) v4(344.63,136.57) v4(345.45,137.43) v4(346.18,137.43)
TBTB_AUX_N: length 3.7
  TOP w0.076: v3(348.73,114.6) 349.05,114.29 349.56,114.29 349.78,114.51 349.79,114.51
  TOP w0.102: 349.79,114.51 350.92,114.51 351.14,114.29 351.37,114.29 C8047.2
  BOTTOM w0.114: v3(348.73,114.6) 348.43,114.9 U8001.L5
TBTB_AUX_P: length 3.7
  TOP w0.102: C8046.2 351.6,114.55 351.54,114.49 351.22,114.49 351.01,114.71 349.83,114.71 349.64,114.9 349.4,114.9 349.28,114.78 349.28,114.65 349.33,114.6 v3(349.35,114.6)
  BOTTOM w0.114: U8001.L4 349.08,114.87 349.08,114.61 349.2,114.5 349.3,114.5 349.35,114.55 v3(349.35,114.6)
TBTB_CA2HD_1_RX_N: length 23.9
  TOP w0.102: CON7101.A10 361.66,117.07 arc(361.52,117.1) 361.41,117.17 arc(361.31,117.24) 361.19,117.26 361.07,117.26 arc(360.87,117.3) 360.71,117.41 360.49,117.63 arc(360.39,117.7) 360.27,117.72 360.21,117.72 arc(360.02,117.68) 359.86,117.57 R17935.1 359.41,117.69 arc(359.3,117.77) 359.17,117.79 arc(359.06,117.77) 358.96,117.71 D7128.2 358.49,117.66 arc(358.32,117.78) 358.12,117.82 arc(357.93,117.86) 357.78,117.96 357.71,118.03 arc(357.6,118.19) 357.56,118.39 v6(357.56,123.13) 357.56,124.06 arc(357.52,124.26) 357.41,124.42 356.23,125.61 arc(356.06,125.72) 355.87,125.76 346.76,125.76 arc(346.65,125.73) 346.55,125.67 346.46,125.58 arc(346.44,125.56) 346.44,125.53 arc(346.44,125.48) 346.44,125.42 arc(346.44,125.37) 346.45,125.32 arc(346.45,125.3) 346.46,125.27 arc(346.48,125.23) 346.5,125.19 arc(346.54,125.17) 346.58,125.15 arc(346.72,125.11) C8034.1

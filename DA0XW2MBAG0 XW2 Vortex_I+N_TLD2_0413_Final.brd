# Allegro board DA0XW2MBAG0 XW2 Vortex_I+N_TLD2_0413_Final.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCORE_VDIFF: length 2.3
  BOTTOM w0.203: PU19000.6 127.49,145.26 127.79,144.95 v1(127.79,144.67) 127.98,144.48 PR19026.1
VCORE_VFB: length 4.2
  BOTTOM w0.203: PR19027.1 127.77,142.07 127.2,142.64 v1(127.2,142.99) PR19026.2 127.2,145.03 127.09,145.15 PU19000.7
VCORE_VORTN: length 3.4
  BOTTOM w0.203: PU19000.9 126.29,145.39 125.59,144.7 125.59,143.99 v1(125.28,143.68) 125.25,143.65 PR19035.1
VCORE_VOSEN: length 3.3
  BOTTOM w0.203: PU19000.8 126.69,145.35 126.32,144.98 v1(126.32,144.57) 126.14,144.39 PR19033.1
VGA_XTALIN: length 13
  BOTTOM w0.114: U2000.H3 222.51,99.67 222.51,99.2 223.01,98.71 223.01,97.43 223.75,96.68 225.04,96.68 227.4,94.33 227.4,94.12 C2183.1 227.62,93.45 227.62,91.66 Y2000.1
VGA_XTALOUT: length 12.7
  BOTTOM w0.114: U2000.H2 222.11,99.3 222.79,98.62 222.79,97.23 223.63,96.39 224.92,96.39 v2(226.74,94.57) 227.1,94.21 227.1,94.06 C2182.1 226.93,93.67 227.33,93.28 227.33,91.64 227.19,91.5 226.64,91.5 226.4,91.75 Y2000.3
VGPU_CORE_SENSE: length 91.8
  IN2 w0.254: v1(216.31,88.58) 216.31,88.15 217.02,87.43 218.37,87.43 219.62,86.19 219.62,83.56 221.82,81.35 221.82,80.16 225.75,76.24 225.75,69.78 227.16,68.37 227.79,68.37 229.37,66.79 229.37,53.45 224.53,48.61 216.9,48.61 215.86,47.56 211.46,47.56 211.11,47.21 211.11,46.45 209.58,44.92 205.74,44.92 205.01,45.65 v1(205.01,45.91)
  IN3 w0.254: v1(216.31,88.58) 216.19,88.7 216.19,89.36 217.66,90.84 217.66,95.09 217.97,95.4 217.97,97.49 218.73,98.25 218.73,100.26 218.98,100.51 v1(219.19,100.51)
  BOTTOM w0.203: v1(219.19,100.51) U2000.L4
  BOTTOM w0.254: v1(205.01,45.91) 205.01,46.51 PR9025.2 ; v1(216.31,88.58) 216.31,88.64 215.88,89.07 215.47,89.07 215.18,88.78 215.18,88.34 216.45,87.08 PR9023.1
VGT_VCCSENSE: length 51.5
  IN1 w0.203: v1(122.97,142.84) 122.79,142.66 122.79,135.14 127.87,130.06 137.99,130.06 139.37,128.69 148.38,128.69 150.23,130.55 150.63,130.55 v1(150.83,130.74) 151.03,130.55 152.22,130.55 154.44,128.33 157.83,128.33 158.82,127.34 v1(159.07,127.34)
  BOTTOM w0.203: PR19040.1 150.83,130.74 v1(150.83,130.74) ; v1(122.97,142.84) 122.84,142.97 122.84,143.5 PR19042.2 ; U9001.AH38 159.14,127.34 v1(159.07,127.34)
VGT_VSSSENSE: length 52.1
  IN1 w0.203: v1(122.33,142.84) 122.51,142.66 122.51,135.03 127.75,129.78 137.88,129.78 139.25,128.41 148.5,128.41 150.35,130.27 150.68,130.27 v1(150.85,130.09) 151.02,130.27 152.11,130.27 154.32,128.05 157.71,128.05 159.07,126.69 v1(159.07,126.69)
  BOTTOM w0.203: v1(159.07,126.69) 159.14,126.69 U9001.AH37 ; PR19044.2 122.52,143.69 122.52,143.03 v1(122.33,142.84) ; PR19046.1 151.02,130.27 v1(150.85,130.09)
VID0_VCCIO: length 7.1
  TOP w0.254: PR17004.1 190.29,153.51 PR17002.1 PR17003.2 188.13,154.02 187.55,153.45 v1(187.55,151.98)
  BOTTOM w0.254: v1(187.55,151.98) 187.55,151.7 186.69,150.84 PU17000.4
VID1_VCCIO: length 7.1
  TOP w0.254: PR17005.1 190.41,154.9 190.29,155.02 PR17000.1 PR17001.2 188.39,155.02 v1(187.56,154.19) 187.15,153.79 187.15,152.41 186.92,152.18 v1(186.92,151.98)
  BOTTOM w0.254: v1(186.92,151.98) 186.92,151.98 186.92,151.67 186.58,151.34 PU17000.3
VMA_CLK0: length 32.5
  TOP w0.114: R2511.2 223.58,143.35 v1(224.38,142.55)
  IN3 w0.081: v1(224.38,142.55) 224.38,142.82 224.49,142.93 224.66,142.93 224.92,142.67 225.46,142.67 225.89,143.1 226.98,143.1 227.6,142.47 227.6,135.74 224.76,132.9 223.03,132.9 218.08,127.96 217.38,127.96 216.73,127.31 216.73,125.94 215.93,125.13 215.93,124.52 216.31,124.14 216.31,123.7 216.19,123.58 216.19,123.25 216.04,123.1 v1(215.86,123.1)
  BOTTOM w0.102: v1(215.86,123.1) 216.25,122.7 U2000.R30
  BOTTOM w0.114: VRAM2501.J12 v1(224.38,142.55)
VMA_CLK0#: length 32.6
  TOP w0.114: R2512.2 223.58,144.15 v1(224.38,143.35)
  IN3 w0.081: v1(216.68,123.1) 216.62,123.1 216.36,123.35 216.36,123.51 216.48,123.63 216.48,124.21 216.1,124.59 216.1,125.06 216.9,125.87 216.9,127.24 217.45,127.78 218.15,127.78 223.1,132.73 224.83,132.73 227.77,135.67 227.77,142.54 227.05,143.27 225.82,143.27 225.39,142.84 224.99,142.84 224.73,143.1 224.63,143.1 v1(224.38,143.35)
  BOTTOM w0.102: U2000.R31 v1(216.68,123.1)
  BOTTOM w0.114: VRAM2501.J11 v1(224.38,143.35)
VMA_CLK1: length 33.8
  TOP w0.114: v1(197.98,142.55) 198.62,143.19 R2509.2
  IN3 w0.081: v1(210.01,123.9) 209.78,123.9 209.58,124.1 209.58,124.48 209.23,124.83 209.23,127.26 202.08,134.41 196.86,134.41 194.83,136.44 194.83,141.87 195.1,142.14 195.88,142.14 196.44,142.69 197.4,142.69 197.6,142.89 197.92,142.89 198.05,142.76 198.05,142.62 v1(197.98,142.55)
  BOTTOM w0.102: v1(210.01,123.9) 210.41,123.5 U2000.AB31
  BOTTOM w0.114: VRAM2500.J12 v1(197.98,142.55)
VMA_CLK1#: length 33.7
  TOP w0.114: R2510.2 198.8,144.17 v1(197.98,143.35)
  IN3 w0.081: v1(209.18,123.88) 209.41,124.11 209.41,124.41 209.06,124.76 209.06,127.19 202.01,134.24 196.79,134.24 194.66,136.37 194.66,141.94 195.03,142.31 195.81,142.31 196.37,142.86 197.33,142.86 197.53,143.06 197.77,143.06 197.98,143.27 v1(197.98,143.35)
  BOTTOM w0.102: v1(209.18,123.88) 209.28,123.88 209.58,123.58 U2000.AC31
  BOTTOM w0.114: VRAM2500.J11 v1(197.98,143.35)
VMA_DQ0: length 17.7
  IN4 w0.089: v1(217.57,135.37) 217.57,134.2 218.68,133.09 218.68,128.44 219.33,127.79 219.33,120.77 v1(219.17,120.61)
  BOTTOM w0.14: U2000.L28 219.19,120.61 v1(219.17,120.61) ; v1(217.57,135.37) 217.76,135.37 218.19,135.8 218.19,136.36 VRAM2501.A4
VMA_DQ1: length 17.1
  IN4 w0.089: v1(218.35,121.42) 218.8,121.87 218.77,121.89 218.77,126.94 217.38,128.33 217.38,133.12 216.57,133.93 216.57,135.69 v1(216.38,135.88)
  BOTTOM w0.14: VRAM2501.A2 216.78,136.27 v1(216.38,135.88) ; v1(218.35,121.42) U2000.M29
VMA_DQ2: length 18.6
  IN4 w0.089: v1(217.98,137.75) 217.98,136.96 218.09,136.85 218.09,134.32 219.1,133.31 219.1,128.7 219.58,128.22 U2000.L29 219.72,121.71 v1(220.27,121.71)
  BOTTOM w0.14: U2000.L29 219.72,121.71 v1(220.27,121.71) ; VRAM2501.B4 218.38,137.35 v1(217.98,137.75)
VMA_DQ3: length 18.7
  IN4 w0.089: v1(218.37,120.58) 219.03,121.24 219.03,127.38 218.22,128.19 218.22,132.91 217.02,134.11 217.02,136.84 v1(217.15,136.96)
  BOTTOM w0.14: v1(218.37,120.58) 218.78,120.99 U2000.M28 ; VRAM2501.B2 217.15,136.98 v1(217.15,136.96)
VMA_DQ4: length 21.3
  IN4 w0.089: v1(217.98,139.35) 217.58,138.95 216.78,138.95 216.73,139 216.06,139 215.56,138.51 215.08,138.51 214.91,138.35 214.91,133.67 216.06,132.53 216.06,127.54 216.42,127.18 216.42,125.78 216.2,125.56 216.2,124.59 216.67,124.12 216.67,123.74 217.35,123.06 v1(217.51,123.06)
  BOTTOM w0.14: U2000.N31 217.51,123.07 v1(217.51,123.06) ; VRAM2501.E4 v1(217.98,139.35)
VMA_DQ5: length 23.5
  IN4 w0.089: v1(217.18,140.18) 216.94,139.94 216.15,139.94 215.6,139.39 215.06,139.39 214.47,138.79 214.47,133.49 215.63,132.32 215.63,127.36 215.99,127 215.99,126.01 215.73,125.74 215.73,124.62 216.26,124.08 216.26,122.92 216.43,122.75 216.44,122.75 216.51,122.68 216.89,122.68 216.98,122.6 217.1,122.48 217.1,121.83 v1(217.48,121.45)
  BOTTOM w0.14: v1(217.18,140.18) 217.18,140.15 VRAM2501.E2 ; U2000.P29 v1(217.48,121.45)
VMA_DQ6: length 24.4
  IN4 w0.089: v1(217.98,140.15) 217.36,140.77 216.91,140.77 216.58,140.43 215.21,140.43 214.02,139.24 214.02,130.76 215.21,129.57 215.21,124.42 215.44,124.19 215.44,122.91 216.1,122.25 v1(216.67,122.25)
  BOTTOM w0.14: v1(216.67,122.25) 216.67,122.24 U2000.R29 ; VRAM2501.F4 v1(217.98,140.15)
VMA_DQ7: length 26.3
  IN4 w0.089: v1(216.36,140.97) 216.17,141.16 215.98,141.16 215.82,141.32 214.83,141.32 213.57,140.05 213.57,130.44 214.79,129.22 214.79,124.3 214.59,124.11 214.59,122.09 214.7,121.98 214.7,121.35 215.04,121.01 216.26,121.01 v1(216.68,121.42)
  BOTTOM w0.14: U2000.P28 217.08,121.02 v1(216.68,121.42) ; VRAM2501.F2 v1(216.36,140.97)
VMA_DQ8: length 17.2
  IN4 w0.089: v1(220.86,121.42) 220.86,122.44 221.29,122.87 221.29,127.68 223.72,130.11 223.72,134.44 223.48,134.68 v1(223.48,135.95)
  BOTTOM w0.14: v1(223.48,135.95) 223.48,136.05 VRAM2501.A11 ; U2000.J28 v1(220.86,121.42)
VMA_DQ9: length 16.8
  IN4 w0.089: v1(222.5,122.27) 222.51,122.45 222.51,122.5 222.1,122.91 222.1,126.58 225.96,130.44 v1(225.96,136.07)
  BOTTOM w0.14: v1(225.96,136.07) 225.58,136.45 VRAM2501.A13 ; v1(222.5,122.27) U2000.H29
VMA_DQ10: length 17.2
  IN4 w0.089: v1(221.64,122.28) 221.58,122.34 221.58,127.33 224.17,129.92 224.17,134.68 223.91,134.93 223.91,136.58 v1(223.59,136.91)
  BOTTOM w0.14: U2000.J29 221.28,121.89 221.64,122.25 v1(221.64,122.28) ; v1(223.59,136.91) 223.59,136.96 VRAM2501.B11
VMA_DQ11: length 18.7
  IN4 w0.089: v1(225.99,136.94) 225.49,136.43 225.49,130.6 221.86,126.98 221.86,122.74 222.08,122.53 222.08,121.85 v1(222.51,121.42)
  BOTTOM w0.14: U2000.H28 222.5,121.42 v1(222.51,121.42) ; VRAM2501.B13 v1(225.99,136.94)
VMA_DQ12: length 22.9
  IN4 w0.089: v1(224.38,139.35) 224.76,138.97 226.29,138.97 226.76,138.5 227.4,138.5 227.98,137.93 227.98,130.41 225.39,127.82 225.39,127.33 224.61,126.55 224.61,125.29 224.44,125.13 224.08,124.76 224.08,124.45 223.77,124.14 223.77,122.69 v1(223.36,122.27)
  BOTTOM w0.14: VRAM2501.E11 v1(224.38,139.35) ; U2000.G29 v1(223.36,122.27)
VMA_DQ13: length 21.9
  IN4 w0.089: v1(225.01,124.68) 225.01,124.83 226.04,125.87 226.77,125.87 227.6,126.7 227.6,127.07 227.36,127.31 227.36,128.52 228.84,130 228.84,138.9 227.44,140.29 226.1,140.29 v1(225.96,140.15)
  BOTTOM w0.14: v1(225.96,140.15) 225.96,140.13 VRAM2501.E13 ; U2000.E31 225.01,123.93 v1(225.01,124.68)
VMA_DQ14: length 22.7
  IN4 w0.089: v1(224.38,140.15) 225.12,139.41 227.49,139.41 228.41,138.49 228.41,130.21 226.59,128.39 226.59,126.86 226.03,126.3 225.24,126.3 225.03,126.08 225.03,125.32 224.33,124.62 224.33,124.05 v1(224.18,123.9)
  BOTTOM w0.14: VRAM2501.F11 v1(224.38,140.15) ; U2000.E32 v1(224.18,123.9)
VMA_DQ15: length 24.3
  IN4 w0.089: v1(224.18,123.1) 224.18,123.26 225.43,124.51 225.43,124.9 225.96,125.43 226.93,125.43 228.07,126.57 228.07,127.33 227.86,127.54 227.86,128.37 229.27,129.77 229.27,139.22 227.32,141.18 226.23,141.18 v1(225.97,140.93)
  BOTTOM w0.14: U2000.F30 v1(224.18,123.1) ; VRAM2501.F13 225.96,140.93 v1(225.97,140.93)
VMA_DQ16: length 29.9
  IN1 w0.089: v1(224.38,148.95) 225.63,150.2 226.67,150.2 228.72,148.15 228.72,139.78 228.3,139.36 228.3,135.55 227.6,134.86 227.6,126.73 227.28,126.41 v1(226.73,126.41)
  BOTTOM w0.14: U2000.C34 226.28,125.9 226.73,126.35 v1(226.73,126.41) ; VRAM2501.U11 v1(224.38,148.95)
VMA_DQ17: length 28.3
  IN1 w0.089: v1(225.98,148.95) 226.19,149.16 227.09,149.16 228.29,147.97 228.29,139.94 227.87,139.52 227.87,135.73 226.58,134.44 226.58,126.9 225.95,126.27 225.95,125.48 225.84,125.37 v1(225.84,124.73)
  BOTTOM w0.14: U2000.D32 225.84,124.71 v1(225.84,124.73) ; VRAM2501.U13 v1(225.98,148.95)
VMA_DQ18: length 31.9
  IN1 w0.089: v1(223.58,148.95) 225.26,150.63 226.85,150.63 229.15,148.33 229.15,139.52 228.73,139.1 228.73,135.37 228.31,134.95 v1(228.31,127.77)
  BOTTOM w0.14: v1(228.31,127.77) 228.31,126.64 227.74,126.07 227.74,125.76 U2000.B33 ; VRAM2501.T11 v1(223.58,148.95)
VMA_DQ19: length 26.2
  IN1 w0.089: v1(225.98,148.15) 226.1,148.27 227.14,148.27 227.86,147.55 227.86,140.12 227.44,139.7 227.44,135.91 226.14,134.61 226.14,127.1 v1(226.04,127)
  BOTTOM w0.14: v1(226.04,127) 226.04,126.33 225.88,126.18 225.88,125.5 U2000.C33 ; VRAM2501.T13 v1(225.98,148.15)
VMA_DQ20: length 26.2
  IN1 w0.089: v1(223.36,124.7) 223.36,124.84 222.19,126.01 222.19,127.52 221.4,128.31 221.4,133.38 220.79,133.99 220.79,145.31 222.08,146.6 v1(222.66,146.6)
  BOTTOM w0.14: v1(223.36,124.7) 223.38,124.7 U2000.F33 ; v1(222.66,146.6) 222.71,146.55 223.5,146.55 223.9,146.15 VRAM2501.N11
VMA_DQ21: length 26.6
  IN1 w0.089: v1(224.19,125.5) 224.19,126.47 223.57,127.08 223.57,127.67 224.58,128.68 224.58,132.21 222.14,134.65 222.14,143.05 223.37,144.28 224.35,144.28 225,144.92 v1(225.96,144.92)
  BOTTOM w0.14: v1(224.19,125.5) 224.19,124.71 U2000.F32 ; v1(225.96,144.92) 225.96,145.77 VRAM2501.N13
VMA_DQ22: length 23.3
  IN1 w0.089: v1(223.27,126.53) 223.14,126.66 223.14,127.83 224.14,128.84 224.14,132.01 221.69,134.46 221.69,143.24 223.41,144.96 v1(223.59,144.96)
  BOTTOM w0.14: VRAM2501.M11 v1(223.59,144.96) ; v1(223.27,126.53) 223.27,126.39 222.08,125.21 U2000.H33
VMA_DQ23: length 30
  IN1 w0.089: v1(224.34,145.75) 223.64,145.75 223.25,146.14 222.25,146.14 221.24,145.13 221.24,134.23 223.71,131.76 223.71,129 222.68,127.96 222.68,126.38 223.02,126.04 223.49,126.04 223.72,125.81 223.72,125.11 223.78,125.05 223.78,124.5 223.56,124.28 222.88,124.28 v1(222.5,123.9)
  BOTTOM w0.14: v1(222.5,123.9) 222.48,123.9 U2000.H32 ; v1(224.34,145.75) 225.18,145.75 VRAM2501.M13
VMA_DQ24: length 30.9
  IN1 w0.089: v1(217.47,126.95) 217.1,127.31 216.45,127.31 213.03,130.73 213.03,142.86 213.53,143.36 213.53,147.61 214.36,148.44 216.64,148.44 216.88,148.68 217.48,148.68 217.61,148.55 218.4,148.55 v1(218.79,148.94)
  BOTTOM w0.14: v1(217.47,126.95) 217.38,126.95 216.98,126.55 216.98,126 U2000.P34 ; VRAM2501.U4 v1(218.79,148.94)
VMA_DQ25: length 33.5
  IN1 w0.089: v1(216.68,124.7) 215.83,124.7 211.68,128.86 211.68,143.44 212.17,143.93 212.17,148.34 214.56,150.73 215.97,150.73 v1(216.78,149.92)
  BOTTOM w0.14: v1(216.78,149.92) VRAM2501.U2 ; U2000.P32 v1(216.68,124.7)
VMA_DQ26: length 36.1
  IN1 w0.089: v1(217.98,149) 217.81,149.16 216.88,149.16 215.77,150.28 214.75,150.28 212.63,148.17 212.63,143.74 212.13,143.23 212.13,129.04 215.78,125.39 217.62,125.39 217.92,125.09 217.92,124.32 v1(217.51,123.9)
  BOTTOM w0.14: v1(217.51,123.9) 217.48,123.9 U2000.P31 ; v1(217.98,149) 217.98,148.95 VRAM2501.T4
VMA_DQ27: length 30.3
  IN1 w0.089: v1(216.38,148.95) 215.99,148.95 215.59,149.35 215.59,149.35 214.45,149.35 213.08,147.99 213.08,143.55 212.58,143.04 212.58,130.52 216.42,126.68 217.08,126.68 v1(217.45,126.31)
  BOTTOM w0.14: U2000.P33 217.48,125.5 217.48,126.28 v1(217.45,126.31) ; VRAM2501.T2 v1(216.38,148.95)
VMA_DQ28: length 25.9
  IN1 w0.089: v1(217.96,145.73) 217.96,144.95 216.64,143.63 216.64,142.92 215.88,142.15 215.88,135.48 216.31,135.05 216.31,131.36 v1(220.03,127.64)
  BOTTOM w0.14: U2000.L31 219.18,123.9 219.18,126.8 v1(220.03,127.64) ; VRAM2501.N4 v1(217.96,145.73)
VMA_DQ29: length 23.6
  IN1 w0.089: v1(216.38,145.7) 215.96,145.28 215.96,142.95 215.51,142.51 215.22,142.51 214.83,142.11 214.83,135.9 215.83,134.89 215.83,131.07 219.73,127.18 v1(220,126.9)
  BOTTOM w0.14: v1(216.38,145.7) 216.78,146.1 VRAM2501.N2 ; v1(220,126.9) 219.58,126.47 U2000.L34
VMA_DQ30: length 24.1
  IN1 w0.089: v1(218.78,144.95) 219.29,144.44 219.88,144.44 220.34,143.98 220.34,133.81 220.95,133.2 220.95,129.81 v1(220.05,128.91)
  BOTTOM w0.14: U2000.L32 219.98,124.7 220.64,124.7 220.88,124.94 220.88,126.42 220.59,126.72 220.59,128.38 v1(220.05,128.91) ; VRAM2501.M4 v1(218.78,144.95)
VMA_DQ31: length 26.3
  IN1 w0.089: v1(220,125.5) 219.43,126.07 219.43,126.64 218.81,127.26 218.81,127.47 215.41,130.86 215.41,134.68 214.38,135.71 214.38,142.3 214.88,142.81 214.88,145.43 215.15,145.69 215.65,145.69 216.12,146.15 216.73,146.15 v1(217.16,145.73)
  BOTTOM w0.14: v1(220,125.5) 219.98,125.5 U2000.L33 ; VRAM2501.M2 v1(217.16,145.73)
VMA_DQ32: length 18.5
  IN4 w0.089: v1(205.81,120.65) 206.53,121.37 206.53,124.76 206.45,124.85 206.45,128.4 207.13,129.08 207.13,132.07 204.38,134.82 v1(204.38,135.12)
  BOTTOM w0.14: U2000.AG28 205.93,120.65 v1(205.81,120.65) ; v1(204.38,135.12) 203.87,135.63 203.87,136.44 VRAM2500.U4
VMA_DQ33: length 17.7
  IN4 w0.089: v1(205.33,136.04) 205.33,135.55 208.03,132.85 208.03,127.4 207.93,127.3 207.93,126.22 207.64,125.93 207.31,125.93 207.08,125.7 U2000.AF29 v1(207.51,121.42)
  BOTTOM w0.14: U2000.AF29 v1(207.51,121.42) ; v1(205.33,136.04) 205.58,136.28 VRAM2500.U2
VMA_DQ34: length 18.5
  IN4 w0.089: v1(204.39,136.92) 203.78,136.31 203.78,134.79 206.6,131.97 206.6,129.33 206.16,128.89 206.16,124.84 206.26,124.75 206.26,121.83 v1(205.86,121.42)
  BOTTOM w0.14: v1(204.39,136.92) 204.39,136.94 VRAM2500.T4 ; v1(205.86,121.42) U2000.AG29
VMA_DQ35: length 19.5
  IN4 w0.089: v1(207.51,120.6) 206.83,121.27 206.83,126.93 207.58,127.68 207.58,132.26 205.07,134.77 v1(205.07,135.1)
  BOTTOM w0.14: v1(205.07,135.1) 205.98,136.01 205.98,136.95 VRAM2500.T2 ; v1(207.51,120.6) 207.48,120.6 U2000.AF28
VMA_DQ36: length 20.2
  IN4 w0.089: v1(209.18,123.08) 209.62,123.52 209.62,127.72 209.38,127.95 209.38,133.45 206.74,136.09 206.74,137.72 205.51,138.96 204.77,138.96 v1(204.36,139.37)
  BOTTOM w0.14: v1(209.18,123.08) 208.8,122.7 U2000.AD30 ; VRAM2500.N4 v1(204.36,139.37)
VMA_DQ37: length 23
  IN4 w0.089: v1(206.01,139.34) 206.02,139.34 206.02,139.32 206.48,138.87 207.37,138.87 209.8,136.44 209.8,128.17 210.61,127.36 210.61,124.48 210.43,124.3 210.43,122.93 210.2,122.7 209.78,122.7 209.56,122.48 209.56,122.09 209.29,121.82 208.81,121.82 v1(208.37,122.26)
  BOTTOM w0.14: v1(206.01,139.34) 205.99,139.34 VRAM2500.N2 ; U2000.AD29 v1(208.37,122.26)
VMA_DQ38: length 26.8
  IN4 w0.089: v1(204.38,140.15) 205.04,140.81 207.39,140.81 210.64,137.56 210.64,128.52 211.47,127.69 211.47,124.54 211.73,124.28 211.73,123.74 211.23,123.24 211.23,122.78 211.29,122.73 211.29,122.06 211.09,121.86 210.69,121.86 210.22,121.39 v1(210.04,121.39)
  BOTTOM w0.14: U2000.AC29 v1(210.04,121.39) ; VRAM2500.M4 v1(204.38,140.15)
VMA_DQ39: length 24.5
  IN4 w0.089: v1(206,140.17) 206.34,139.82 207.32,139.82 210.22,136.93 210.22,128.34 211.03,127.53 211.03,127.35 211.03,127.34 211.03,124.37 211.3,124.11 211.3,123.75 210.79,123.24 210.79,122.84 210.41,122.46 210.41,122.1 210.14,121.83 209.84,121.83 209.58,121.58 209.58,121 v1(209.18,120.6)
  BOTTOM w0.14: VRAM2500.M2 205.62,140.55 v1(206,140.17) ; v1(209.18,120.6) U2000.AD28
VMA_DQ40: length 17.6
  IN4 w0.089: v1(198.88,136.03) 198.88,134.81 203.03,130.66 203.03,129.65 203.89,128.79 203.89,126.65 204.6,125.94 204.6,124.87 204.6,124.29 204.98,123.9 v1(204.98,122.27)
  BOTTOM w0.14: VRAM2500.U11 198.88,136.05 v1(198.88,136.03) ; v1(204.98,122.27) 204.95,122.27 U2000.AJ29
VMA_DQ41: length 19
  IN4 w0.089: v1(197.19,135.97) 197.19,135.22 202.17,130.25 202.17,129.29 203.29,128.17 203.29,126.13 203.95,125.47 203.95,123.49 203.77,123.31 203.77,122.91 204.11,122.57 v1(204.11,121.38)
  BOTTOM w0.14: U2000.AK29 v1(204.11,121.38) ; VRAM2500.U13 197.19,136.14 v1(197.19,135.97)
VMA_DQ42: length 17.5
  IN4 w0.089: v1(197.98,136.95) 198.42,136.51 198.42,134.63 202.6,130.46 202.6,129.47 203.57,128.5 203.57,126.36 204.2,125.73 v1(204.2,123.11)
  BOTTOM w0.14: v1(204.2,123.11) 204.58,122.73 U2000.AJ30 ; VRAM2500.T11 v1(197.98,136.95)
VMA_DQ43: length 20.4
  IN4 w0.089: v1(203.28,121.37) 203.74,121.84 203.74,122.46 203.44,122.77 203.44,123.24 202.96,123.72 202.96,125.6 202.69,125.87 202.36,125.87 202.11,126.12 202.11,127.14 201.26,127.99 201.26,129.88 196.07,135.08 v1(196.07,135.9)
  BOTTOM w0.14: v1(196.07,135.9) 196.38,136.22 196.38,136.95 VRAM2500.T13 ; U2000.AK28 203.68,120.98 v1(203.28,121.37)
VMA_DQ44: length 24
  IN4 w0.089: v1(197.98,139.35) 197.59,138.96 196.06,138.96 195.68,138.58 195.02,138.58 194.88,138.44 194.88,134.99 200.42,129.45 200.42,126 201.05,125.37 201.05,124.71 201.83,123.93 201.83,123.53 202.13,123.23 202.13,122.54 v1(202.47,122.19)
  BOTTOM w0.14: U2000.AM29 v1(202.47,122.19) ; VRAM2500.N11 v1(197.98,139.35)
VMA_DQ45: length 22.6
  IN4 w0.089: v1(201.71,123.03) 201.5,123.24 201.5,123.85 201.03,124.33 200.78,124.33 200.47,124.64 200.47,124.91 200.19,125.19 199.79,125.19 199.58,125.4 199.58,129.66 194.43,134.8 194.43,138.9 195,139.46 196.27,139.46 v1(196.36,139.37)
  BOTTOM w0.14: VRAM2500.N13 196.74,139.75 v1(196.36,139.37) ; U2000.AM31 202.08,123.4 v1(201.71,123.03)
VMA_DQ46: length 28.4
  IN4 w0.089: v1(197.98,140.19) 197.62,140.56 196.8,140.56 196.12,141.24 194.89,141.24 193.53,139.88 193.53,134.43 198.71,129.25 198.71,124.44 199.71,123.44 200.15,123.44 200.48,123.11 200.48,122.02 200.91,121.6 v1(200.91,121.37)
  BOTTOM w0.14: v1(197.98,140.19) 198.02,140.19 VRAM2500.M11 ; U2000.AN29 201.28,121.75 v1(200.91,121.37)
VMA_DQ47: length 24.9
  IN4 w0.089: v1(201.69,122.19) 201.3,122.59 201.3,123.27 201.12,123.45 200.73,123.45 200.35,123.83 200.35,124.07 200.12,124.3 199.83,124.3 199.15,124.99 199.15,129.45 193.98,134.62 193.98,139.52 194.83,140.37 196.13,140.37 v1(196.37,140.14)
  BOTTOM w0.14: v1(196.37,140.14) 196.37,140.14 VRAM2500.M13 ; v1(201.69,122.19) 201.69,122.21 U2000.AM30
VMA_DQ48: length 37.3
  IN1 w0.089: v1(200.06,123) 199.42,123.64 199.42,124.12 199.04,124.49 199.04,130.35 196.2,133.2 195.47,133.2 193.04,135.63 193.04,147.72 193.63,148.32 193.63,148.62 194.05,149.04 194.05,149.41 195.24,150.59 196.37,150.59 v1(198,148.97)
  BOTTOM w0.114: U2000.AN31 200.34,123.45 200.06,123.17 v1(200.06,123)
  BOTTOM w0.14: VRAM2500.A11 v1(198,148.97)
VMA_DQ49: length 33.3
  IN1 w0.089: v1(196.38,149.75) 195.99,150.14 195.4,150.14 194.49,149.23 194.49,148.87 194.07,148.44 194.07,148.14 193.47,147.54 193.47,135.89 195.71,133.65 196.59,133.65 199.51,130.73 199.51,124.62 199.83,124.3 200.42,124.3 v1(200.84,123.88)
  BOTTOM w0.14: v1(200.84,123.88) 201.27,124.3 U2000.AN32 ; VRAM2500.A13 v1(196.38,149.75)
VMA_DQ50: length 39
  IN1 w0.089: v1(198.78,148.95) 196.69,151.04 195.08,151.04 193.62,149.59 193.62,149.22 193.2,148.8 193.2,148.5 192.6,147.9 192.6,135.38 195.24,132.75 195.82,132.75 198.57,130 198.57,123.71 v1(200.09,122.19)
  BOTTOM w0.14: v1(200.09,122.19) 200.09,122.21 U2000.AP30 ; VRAM2500.B11 v1(198.78,148.95)
VMA_DQ51: length 31.6
  IN1 w0.089: v1(196.38,148.95) 196.08,149.25 195.18,149.25 194.92,148.98 194.92,148.69 194.5,148.27 194.5,147.96 193.9,147.36 193.9,136.12 195.92,134.1 196.9,134.1 200.1,130.9 200.1,127.69 199.96,127.56 v1(199.96,127.07)
  BOTTOM w0.14: VRAM2500.B13 v1(196.38,148.95) ; U2000.AP32 200.45,124.33 199.73,124.33 199.5,124.55 199.5,126.62 v1(199.96,127.07)
VMA_DQ52: length 27.9
  IN1 w0.089: v1(198.77,146.58) 197.95,146.58 197.59,146.94 196.83,146.94 196.45,146.57 195.87,145.99 195.87,138.11 196.56,137.42 196.56,135.95 197.06,135.45 197.73,135.45 201.7,131.48 v1(201.7,126.98)
  BOTTOM w0.14: VRAM2500.E11 198.38,146.17 198.77,146.56 v1(198.77,146.58) ; U2000.AM33 201.67,125.51 201.67,126.96 v1(201.7,126.98)
VMA_DQ53: length 28.3
  IN1 w0.089: v1(202.52,123.94) 203.59,125.01 203.59,134.66 202.04,136.22 202.04,143.17 201.15,144.06 201.15,144.94 199.88,146.21 199.23,146.21 199.16,146.14 197.58,146.14 v1(197.19,145.75)
  BOTTOM w0.14: v1(202.52,123.94) 202.88,123.57 U2000.AL31 ; v1(197.19,145.75) 196.79,146.15 VRAM2500.E13
VMA_DQ54: length 22.5
  IN1 w0.089: v1(198.78,144.92) 198.78,144.18 201.14,141.82 201.14,135.84 202.56,134.42 v1(202.56,127.68)
  BOTTOM w0.14: VRAM2500.F11 198.38,145.32 v1(198.78,144.92) ; v1(202.56,127.68) 203.28,126.96 203.28,125.85 203.66,125.47 203.66,125.22 U2000.AK33
VMA_DQ55: length 26.1
  IN1 w0.089: v1(202.54,126.3) 203.14,126.9 203.14,134.48 201.59,136.03 201.59,142.01 199.24,144.35 199.24,145.05 198.96,145.33 197.57,145.33 v1(197.17,144.93)
  BOTTOM w0.14: v1(197.17,144.93) 197.17,144.96 VRAM2500.F13 ; U2000.AK32 203.33,124.75 203.33,125.3 202.54,126.09 v1(202.54,126.3)
VMA_DQ56: length 28.3
  IN1 w0.089: v1(204.38,148.95) 204.88,148.45 205.44,148.45 205.61,148.62 206.48,148.62 206.72,148.39 206.98,148.13 208.2,148.13 209.47,146.86 209.47,128.12 v1(208.35,127)
  BOTTOM w0.14: U2000.AD34 208.83,125.95 208.83,126.52 v1(208.35,127) ; VRAM2500.A4 v1(204.38,148.95)
VMA_DQ57: length 31.4
  IN1 w0.089: v1(205.94,150) 206.4,149.55 208.36,149.55 210.38,147.53 210.38,127.76 209.26,126.64 209.26,125.6 208.79,125.14 208.79,124.49 208.34,124.03 v1(208.34,123.88)
  BOTTOM w0.14: VRAM2500.A2 205.58,149.64 v1(205.94,150) ; U2000.AD32 208.36,123.88 v1(208.34,123.88)
VMA_DQ58: length 37.3
  IN1 w0.089: v1(209.14,122.26) 208.76,122.65 208.76,124.03 209.21,124.49 209.21,124.95 209.71,125.45 210.08,125.45 210.88,126.25 210.88,147.68 207.99,150.57 204.74,150.57 203.58,149.41 v1(203.58,148.95)
  BOTTOM w0.14: VRAM2500.B4 v1(203.58,148.95) ; U2000.AC30 v1(209.14,122.26)
VMA_DQ59: length 29.1
  IN1 w0.089: v1(205.18,148.98) 205.28,149.08 207.48,149.08 207.8,148.76 208.41,148.76 209.91,147.26 209.91,127.92 208.83,126.85 208.83,125.98 v1(208.36,125.5)
  BOTTOM w0.14: v1(208.36,125.5) 208.38,125.5 U2000.AD33 ; VRAM2500.B2 205.58,148.58 v1(205.18,148.98)
VMA_DQ60: length 29
  IN1 w0.089: v1(207.51,122.27) 207.01,122.77 207.01,125.19 206.44,125.77 206.44,127.2 206.02,127.62 206.02,128.7 206.48,129.16 206.48,142.8 203.8,145.48 203.8,145.97 v1(204.38,146.55)
  BOTTOM w0.14: U2000.AF31 206.69,123.11 206.69,122.53 206.95,122.27 v1(207.51,122.27) ; VRAM2500.E4 v1(204.38,146.55)
VMA_DQ61: length 23.5
  IN1 w0.089: v1(206.9,128.27) 207.38,128.74 207.38,134.52 208.18,135.32 208.18,143.9 207.74,144.34 206.82,144.34 206.49,144.66 206.49,145.2 205.94,145.75 v1(205.15,145.75)
  BOTTOM w0.14: VRAM2500.E2 205.55,146.15 v1(205.15,145.75) ; U2000.AG34 206.28,127.65 v1(206.9,128.27)
VMA_DQ62: length 23.9
  IN1 w0.089: v1(205.97,129.31) 205.97,135.29 205.69,135.57 204.08,135.57 202.98,136.68 202.98,144.35 v1(203.58,144.95)
  BOTTOM w0.14: v1(205.97,129.31) 205.83,129.17 205.83,124.75 U2000.AG32 ; VRAM2500.F4 v1(203.58,144.95)
VMA_DQ63: length 23.3
  IN1 w0.089: v1(205.13,144.95) 206.18,143.91 207.56,143.91 207.75,143.72 207.75,135.5 206.91,134.66 206.91,128.91 206.46,128.46 206.46,128.07 v1(206.9,127.62)
  BOTTOM w0.14: v1(205.13,144.95) 205.53,145.35 VRAM2500.F2 ; v1(206.9,127.62) 206.68,127.4 206.68,125.5 U2000.AG33
VMA_WCK01: length 18.8
  IN4 w0.081: v1(218.78,138.55) 218.78,138.86 218.91,138.99 219.13,138.99 219.53,138.59 219.53,133.94 219.94,133.54 219.94,129.66 220.46,129.14 220.46,123.74 220.31,123.59 220.1,123.59 220.01,123.68 v1(220.01,123.9)
  BOTTOM w0.114: v1(220.01,123.9) 220.01,123.56 220.1,123.46 220.39,123.46 U2000.K31 ; v1(218.78,138.55) 218.78,138.8 218.63,138.95 VRAM2501.D4
VMA_WCK01#: length 18.8
  IN4 w0.081: v1(220,123.05) 220,123.35 220.07,123.42 220.38,123.42 220.63,123.67 220.63,129.21 220.11,129.73 220.11,133.61 219.7,134.01 219.7,138.66 219.2,139.16 218.97,139.16 v1(218.78,139.35)
  BOTTOM w0.114: U2000.L30 219.66,122.7 v1(220,123.05) ; VRAM2501.D5 v1(218.78,139.35)
VMA_WCK23: length 24.3
  IN4 w0.081: v1(218.78,146.55) 219.24,146.09 220.21,146.09 220.58,145.72 220.58,134.23 221.12,133.68 221.12,130 221.51,129.61 221.79,129.61 v1(222.03,129.37)
  BOTTOM w0.114: VRAM2501.P4 v1(218.78,146.55) ; v1(222.03,129.37) 221.85,129.55 221.6,129.55 221.53,129.47 221.53,128.2 221.79,127.93 221.79,125.99 221.88,125.9 U2000.H34
VMA_WCK23#: length 24.3
  IN4 w0.081: v1(219.58,146.55) 219.58,146.35 219.67,146.26 220.28,146.26 220.75,145.79 220.75,134.3 221.29,133.76 221.29,130.07 221.58,129.78 221.92,129.78 222.03,129.89 v1(222.03,130.13)
  BOTTOM w0.114: U2000.J34 221.48,125.9 221.57,126 221.57,127.84 221.31,128.11 221.31,129.56 221.52,129.76 221.87,129.76 222.03,129.93 v1(222.03,130.13) ; VRAM2501.P5 v1(219.58,146.55)
VMA_WCK45: length 19.3
  IN4 w0.081: v1(203.58,139.3) 203.41,139.13 203.08,139.13 202.77,138.82 202.77,134.28 205.19,131.86 205.19,128.3 205.6,127.9 205.6,124.59 205.38,124.37 205.38,123.79 205.86,123.32 v1(205.86,123.1)
  BOTTOM w0.114: v1(205.86,123.1) 205.88,123.1 U2000.AG30 ; VRAM2500.P4 203.93,138.95 v1(203.58,139.3)
VMA_WCK45#: length 19.3
  IN4 w0.081: v1(205.86,123.9) 205.61,123.9 205.55,123.96 205.55,124.3 205.77,124.52 205.77,127.97 205.36,128.38 205.36,131.93 202.94,134.35 202.94,138.75 203.15,138.96 203.42,138.96 203.58,138.8 v1(203.58,138.6)
  BOTTOM w0.114: v1(203.58,138.6) 203.3,138.6 203.18,138.72 VRAM2500.P5 ; U2000.AG31 206.45,123.5 206.56,123.62 206.56,123.74 206.41,123.9 v1(205.86,123.9)
VMA_WCK67: length 26.3
  IN4 w0.081: v1(205.01,126.3) 204.8,126.51 204.63,126.51 204.34,126.81 204.34,131.32 201.91,133.74 201.91,142.89 201.1,143.7 201.1,146.06 202.01,146.97 203.16,146.97 v1(203.58,146.55)
  BOTTOM w0.114: U2000.AJ34 204.44,126.04 204.44,126.42 204.54,126.52 204.78,126.52 v1(205.01,126.3) ; VRAM2500.D4 v1(203.58,146.55)
VMA_WCK67#: length 26.3
  IN4 w0.081: v1(205.01,127.03) 205.01,126.82 204.87,126.68 204.7,126.68 204.51,126.88 204.51,131.39 202.08,133.81 202.08,142.96 201.27,143.77 201.27,145.99 202.08,146.79 202.61,146.79 202.78,146.63 v1(202.78,146.55)
  BOTTOM w0.114: U2000.AK34 203.98,125.7 204.13,125.7 204.23,125.8 204.23,126.51 204.45,126.74 204.71,126.74 v1(205.01,127.03) ; VRAM2500.D5 202.85,146.95 202.78,146.88 v1(202.78,146.55)
VMB_CLK0: length 30.5
  TOP w0.114: v1(244.53,100.94) 245.1,101.51 245.1,102.19 R2520.2
  IN3 w0.081: v1(244.53,100.94) 244.57,100.98 244.76,100.98 244.89,100.85 244.89,100.72 244.29,100.12 244.29,98.36 243.81,97.88 236.89,97.88 232.05,102.72 232.05,103.53 228.41,107.17 226.05,107.17 225.53,107.69 225.53,107.98 225.63,108.08 225.83,108.08 v1(225.88,108.03)
  BOTTOM w0.102: U2000.D12 225.48,107.63 v1(225.88,108.03)
  BOTTOM w0.114: VRAM2503.J12 v1(244.53,100.94)
VMB_CLK0#: length 30.5
  TOP w0.114: R2519.2 245.32,102.17 245.32,100.95 v1(245.33,100.94)
  IN3 w0.081: v1(225.08,108.03) 225.28,108.03 225.36,107.94 225.36,107.62 225.98,107 228.34,107 231.88,103.46 231.88,102.65 236.82,97.71 243.88,97.71 244.46,98.29 244.46,100.05 245.06,100.65 245.06,100.67 v1(245.33,100.94)
  BOTTOM w0.102: v1(225.08,108.03) 224.68,107.63 U2000.E12
  BOTTOM w0.114: VRAM2503.J11 v1(245.33,100.94)
VMB_CLK1: length 36.3
  TOP w0.114: v1(244.53,125.82) 244.61,125.82 245.2,125.23 R2515.2
  IN3 w0.081: v1(244.53,125.82) 244.82,125.82 244.94,125.94 244.94,126.16 244.48,126.62 243.48,126.62 242.91,127.18 242.91,127.6 241.56,128.95 238.69,128.95 238.13,128.39 238.13,127.68 232.67,122.21 232.67,116.49 230.64,114.47 223.98,114.47 223.85,114.33 223.85,114.08 224.06,113.88 v1(224.26,113.88)
  BOTTOM w0.102: U2000.E20 v1(224.26,113.88)
  BOTTOM w0.114: VRAM2502.J12 v1(244.53,125.82)
VMB_CLK1#: length 36.5
  TOP w0.114: v1(245.33,125.82) 245.33,125.46 246.02,124.77 R2514.2
  IN3 w0.081: v1(223.4,113.88) 223.68,114.15 223.68,114.4 223.91,114.64 230.57,114.64 232.5,116.57 232.5,122.29 237.96,127.75 237.96,128.46 238.62,129.12 241.63,129.12 243.08,127.67 243.08,127.25 243.55,126.79 244.55,126.79 245.11,126.23 245.11,126.03 v1(245.33,125.82)
  BOTTOM w0.114: VRAM2502.J11 v1(245.33,125.82) ; U2000.F20 v1(223.4,113.88)
VMB_DQ0: length 18.5
  IN4 w0.089: v1(222.58,105.53) 223.03,105.08 223.65,105.08 223.83,104.9 223.83,104.5 224.03,104.3 229.48,104.3 231.06,105.88 236.83,105.88 v1(238.01,107.07)
  BOTTOM w0.14: VRAM2503.A4 238.14,106.94 v1(238.01,107.07) ; v1(222.58,105.53) 222.58,105.5 U2000.G9
VMB_DQ1: length 16.4
  IN4 w0.089: v1(225.08,105.49) 225.45,105.12 228.54,105.12 229.93,106.52 236.87,106.52 237.95,107.6 238.39,107.6 v1(238.95,108.16)
  BOTTOM w0.14: v1(238.95,108.16) 238.56,108.54 VRAM2503.A2 ; v1(225.08,105.49) 225.08,105.46 224.72,105.1 U2000.E9
VMB_DQ2: length 19.2
  IN4 w0.089: v1(222.6,104.7) 223.43,103.87 229.66,103.87 231.16,105.37 237.01,105.37 238.45,106.81 238.45,106.82 v1(238.95,107.31)
  BOTTOM w0.14: v1(238.95,107.31) 238.96,107.31 VRAM2503.B4 ; v1(222.6,104.7) 222.6,104.68 U2000.G8
VMB_DQ3: length 19
  IN4 w0.089: v1(223.43,105.49) 223.44,105.5 223.73,105.5 224.13,105.91 228.54,105.91 229.62,106.99 236.48,106.99 238.17,108.68 239.18,108.68 v1(239.74,108.13)
  BOTTOM w0.14: v1(239.74,108.13) 239.33,108.54 VRAM2503.B2 ; v1(223.43,105.49) 223.43,105.5 U2000.F9
VMB_DQ4: length 22
  IN4 w0.089: v1(241.33,107.34) 240.94,107.73 240.94,109.28 240.75,109.47 240.45,109.77 240.45,110.25 240.3,110.4 235.77,110.4 233.74,108.37 228.51,108.37 227.74,107.6 225.34,107.6 225.33,107.61 224.88,107.61 224.48,107.2 v1(224.26,107.2)
  BOTTOM w0.14: v1(224.26,107.2) 224.23,107.2 U2000.F11 ; VRAM2503.E4 v1(241.33,107.34)
VMB_DQ5: length 24.3
  IN4 w0.089: v1(222.59,107.2) 223.41,107.2 223.83,107.63 224.4,107.63 224.66,107.88 224.66,108.2 224.89,108.44 226.03,108.44 226.05,108.45 227.93,108.45 228.3,108.82 233.6,108.82 235.63,110.85 240.77,110.85 241.38,110.24 241.38,109.47 241.39,109.47 241.39,108.91 v1(242.16,108.14)
  BOTTOM w0.14: v1(222.59,107.2) 222.98,106.81 U2000.G11 ; VRAM2503.E2 241.76,108.54 v1(242.16,108.14)
VMB_DQ6: length 25.7
  IN4 w0.089: v1(242.13,107.34) 242.75,107.96 242.75,108.41 242.29,108.87 242.29,110.67 241.66,111.3 235.49,111.3 233.96,109.78 228.66,109.78 227.71,108.82 226.49,108.82 225.91,109.41 224.63,109.41 224.45,109.22 224.45,108.42 224.15,108.12 v1(224.15,108.06)
  BOTTOM w0.14: VRAM2503.F4 242.13,107.34 v1(242.13,107.34) ; U2000.F12 224.15,107.92 v1(224.15,108.06)
VMB_DQ7: length 26.8
  IN4 w0.089: v1(242.95,108.96) 243.19,109.2 243.19,110.41 241.84,111.75 235.34,111.75 233.82,110.23 228.48,110.23 227.53,109.28 226.52,109.28 225.69,110.11 224.04,110.11 223.83,109.89 223.83,109.53 223.59,109.3 223.23,109.3 222.84,108.91 222.84,108.59 v1(223.41,108.03)
  BOTTOM w0.14: U2000.G12 v1(223.41,108.03) ; VRAM2503.F2 v1(242.95,108.96)
VMB_DQ8: length 16.5
  IN4 w0.089: v1(238.15,101.76) 237.03,101.76 236.72,102.07 228.1,102.07 227.99,102.17 227.56,102.61 223.83,102.61 v1(223.41,103.03)
  BOTTOM w0.14: v1(238.15,101.76) 238.53,101.37 VRAM2503.A11 ; U2000.G6 v1(223.41,103.03)
VMB_DQ9: length 16.2
  IN4 w0.089: v1(237.26,99.28) 235.83,100.71 230.15,100.71 229.84,101.02 227.39,101.02 227.3,101.11 225.5,101.11 225.29,100.9 224.8,100.9 224.41,101.3 v1(224.18,101.3)
  BOTTOM w0.14: v1(237.26,99.28) 237.78,99.8 238.47,99.8 VRAM2503.A13 ; U2000.F5 v1(224.18,101.3)
VMB_DQ10: length 15.5
  IN4 w0.089: v1(225.08,102.2) 227.43,102.2 228,101.63 236.56,101.63 237.23,100.96 v1(238.93,100.96)
  BOTTOM w0.14: U2000.E6 v1(225.08,102.2) ; v1(238.93,100.96) 239.3,101.34 VRAM2503.B11
VMB_DQ11: length 17
  IN4 w0.089: v1(237.99,99.34) 237.58,99.76 237.37,99.76 236,101.13 230.71,101.13 230.54,101.3 227.59,101.3 227.14,101.75 224.63,101.75 v1(224.26,102.13)
  BOTTOM w0.14: VRAM2503.B13 238.93,99.34 v1(237.99,99.34) ; v1(224.26,102.13) 224.25,102.13 U2000.F6
VMB_DQ12: length 23.7
  IN4 w0.089: v1(223.35,101.3) 223.77,100.88 224.6,100.06 224.6,99.53 224.85,99.28 225.27,99.28 225.38,99.39 226.02,99.39 226.95,98.46 235.72,98.46 236.66,97.52 239.83,97.52 240.32,98.01 240.32,98.43 240.74,98.85 240.88,98.85 241.18,99.15 241.18,100.79 v1(241.33,100.94)
  BOTTOM w0.14: v1(223.35,101.3) 223.38,101.3 U2000.F4 ; VRAM2503.E11 v1(241.33,100.94)
VMB_DQ13: length 27.2
  IN4 w0.089: v1(242.11,100.16) 243.16,99.11 243.16,98.2 241.22,96.26 236.08,96.26 235.54,96.79 226.41,96.79 225.91,97.29 224.38,97.29 223.75,97.92 223.75,100.11 v1(223.36,100.5)
  BOTTOM w0.14: U2000.G4 223.33,100.5 v1(223.36,100.5) ; v1(242.11,100.16) 242.11,100.12 VRAM2503.E13
VMB_DQ14: length 22.6
  IN4 w0.089: v1(242.13,100.94) 241.6,100.41 241.6,98.86 241.38,98.64 241.38,98.22 240.26,97.1 236.42,97.1 235.89,97.63 227.95,97.63 227.44,98.14 226.49,98.14 226.18,98.45 225.49,98.45 v1(225.05,98)
  BOTTOM w0.14: v1(225.05,98) 225.05,98.83 U2000.E2 ; VRAM2503.F11 v1(242.13,100.94)
VMB_DQ15: length 23.4
  IN4 w0.089: v1(224.18,99.7) 224.18,98.08 224.78,97.48 226.3,97.48 226.55,97.73 227.1,97.73 227.62,97.21 235.72,97.21 236.25,96.68 240.75,96.68 242.23,98.15 242.23,99.26 v1(242.15,99.34)
  BOTTOM w0.14: U2000.F3 v1(224.18,99.7) ; v1(242.15,99.34) 242.53,99.72 VRAM2503.F13
VMB_DQ16: length 30.1
  IN1 w0.089: v1(250.93,100.94) 250.54,100.55 249.96,100.55 249.72,100.31 249.72,99.45 249.64,99.37 249.64,97.69 249.33,97.39 248.66,97.39 248.24,96.96 237.48,96.96 236.79,97.65 229.44,97.65 v1(229.05,98.03)
  BOTTOM w0.14: U2000.C2 226.68,98.9 226.68,98.34 226.92,98.11 227.5,98.11 228.12,97.48 228.5,97.48 v1(229.05,98.03) ; VRAM2503.U11 v1(250.93,100.94)
VMB_DQ17: length 33.4
  IN1 w0.089: v1(225.02,100.48) 226.43,99.08 226.43,97.83 226.17,97.58 226.17,97.16 226.57,96.76 227.11,96.76 227.33,96.98 228.36,96.98 228.6,96.75 236.51,96.75 237.16,96.1 248.64,96.1 249.01,96.46 249.81,96.46 251.44,98.1 251.44,98.85 250.97,99.32 v1(250.91,99.32)
  BOTTOM w0.14: VRAM2503.U13 v1(250.91,99.32) ; U2000.D4 225.44,100.9 v1(225.02,100.48)
VMB_DQ18: length 37.8
  IN1 w0.089: v1(250.95,102.67) 251.49,102.13 251.49,99.39 251.86,99.02 251.86,97.92 249.95,96.01 249.15,96.01 248.8,95.66 237,95.66 236.37,96.29 226.4,96.29 225.79,96.9 225.5,97.2 225.5,98.27 225.86,98.63 v1(225.86,98.9)
  BOTTOM w0.14: v1(250.95,102.67) 250.95,101.76 250.53,101.34 VRAM2503.T11 ; U2000.D3 225.86,99.67 v1(225.86,98.9)
VMB_DQ19: length 28.4
  IN1 w0.089: v1(226.72,97.31) 226.84,97.43 228.55,97.43 228.76,97.22 236.63,97.22 237.32,96.53 248.44,96.53 248.82,96.91 249.49,96.91 250.65,98.06 250.65,98.87 v1(250.18,99.34)
  BOTTOM w0.14: v1(250.18,99.34) 250.53,99.69 VRAM2503.T13 ; v1(226.72,97.31) 226.43,97.6 226.43,98.16 226.28,98.31 U2000.C1
VMB_DQ20: length 27.5
  IN1 w0.089: v1(228.38,98.98) 227.93,99.42 227.93,101.06 228.19,101.31 234.85,101.31 236.38,102.83 244.92,102.83 245.52,102.23 248,102.23 248.26,101.96 248.26,101.63 247.7,101.06 v1(247.7,100.94)
  BOTTOM w0.14: v1(228.38,98.98) 228.38,99.35 228.03,99.7 227.69,99.7 227.29,100.1 U2000.B3 ; VRAM2503.N11 248.09,101.34 v1(247.7,100.94)
VMB_DQ21: length 29.1
  IN1 w0.089: v1(226.64,100.53) 228.22,102.1 234.25,102.1 235.77,103.63 248.25,103.63 248.95,102.93 248.95,102.28 248.75,102.08 248.75,101.13 248.14,100.52 248.14,99.7 v1(247.76,99.33)
  BOTTOM w0.14: v1(226.64,100.53) 226.64,100.59 U2000.C4 ; v1(247.76,99.33) 248.13,99.69 VRAM2503.N13
VMB_DQ22: length 22.7
  IN1 w0.089: v1(229.02,100.55) 235.37,100.55 237.06,102.25 244.9,102.25 245.39,101.76 v1(247.75,101.76)
  BOTTOM w0.14: v1(229.02,100.55) 229.02,100.62 228.34,101.3 227.83,101.3 227.33,101.8 U2000.B5 ; VRAM2503.M11 v1(247.75,101.76)
VMB_DQ23: length 24.1
  IN1 w0.089: v1(247.72,100.13) 247.32,99.73 247.32,99.05 247.13,98.85 239.57,98.85 238.63,99.79 234.86,99.79 234.58,100.06 228.89,100.06 v1(228.38,100.56)
  BOTTOM w0.14: v1(247.72,100.13) 247.33,99.74 VRAM2503.M13 ; U2000.C5 226.68,101.4 227.19,101.4 227.64,100.95 228,100.95 v1(228.38,100.56)
VMB_DQ24: length 31.1
  IN1 w0.089: v1(228.25,106.38) 228.52,106.38 229.52,107.38 230.2,107.38 235.43,112.61 248.76,112.61 250.42,110.95 250.42,108.68 250.85,108.25 250.85,106.67 v1(250.95,106.56)
  BOTTOM w0.14: v1(250.95,106.56) 251.33,106.94 VRAM2503.U4 ; v1(228.25,106.38) 228.25,106.43 U2000.A11
VMB_DQ25: length 33.6
  IN1 w0.089: v1(251.95,108.85) 252.21,109.11 252.21,110.43 249.13,113.51 235.06,113.51 229.83,108.28 229.14,108.28 227.99,107.12 226.63,107.12 v1(225.88,106.37)
  BOTTOM w0.14: U2000.C11 225.88,106.4 v1(225.88,106.37) ; VRAM2503.U2 251.64,108.54 v1(251.95,108.85)
VMB_DQ26: length 37.4
  IN1 w0.089: v1(225.08,107.2) 225.98,107.2 226.29,107.5 227.73,107.5 228.96,108.73 229.64,108.73 234.87,113.96 249.32,113.96 252.65,110.63 252.65,108.21 v1(251.78,107.35)
  BOTTOM w0.14: VRAM2503.T4 250.94,107.35 v1(251.78,107.35) ; U2000.D11 v1(225.08,107.2)
VMB_DQ27: length 30.7
  IN1 w0.089: v1(227.48,106.37) 227.91,106.8 228.3,106.8 229.33,107.83 230.01,107.83 235.24,113.06 248.95,113.06 251.33,110.67 251.33,109.71 250.93,109.31 v1(250.93,108.94)
  BOTTOM w0.14: v1(227.48,106.37) 227.48,106.4 U2000.B11 ; VRAM2503.T2 v1(250.93,108.94)
VMB_DQ28: length 27.1
  IN1 w0.089: v1(229.27,104.68) 230.68,104.68 234.39,108.39 235.36,108.39 237.34,110.36 245.04,110.36 245.64,109.76 245.64,109.43 v1(247.71,107.36)
  BOTTOM w0.14: VRAM2503.N4 v1(247.71,107.36) ; v1(229.27,104.68) 228.49,103.9 225.88,103.9 U2000.D8
VMB_DQ29: length 24.3
  IN1 w0.089: v1(228.51,104.71) 228.92,105.11 230.48,105.11 236.18,110.81 246.64,110.81 247.52,109.93 247.52,109.15 v1(247.73,108.94)
  BOTTOM w0.14: v1(228.51,104.71) 228.1,104.3 U2000.A8 ; VRAM2503.N2 v1(247.73,108.94)
VMB_DQ30: length 25.5
  IN1 w0.089: v1(246.93,106.54) 246.83,106.64 246.83,107.6 244.97,109.46 237.14,109.46 235.62,107.94 234.57,107.94 230.84,104.2 227.18,104.2 v1(226.68,104.7)
  BOTTOM w0.14: VRAM2503.M4 v1(246.93,106.54) ; U2000.C8 v1(226.68,104.7)
VMB_DQ31: length 27.5
  IN1 w0.089: v1(227.48,104.7) 227.83,104.7 228.47,105.34 229.07,105.34 229.6,105.87 230.6,105.87 235.99,111.26 247.37,111.26 248.41,110.22 248.41,108.86 248.05,108.5 v1(247.71,108.16)
  BOTTOM w0.14: U2000.B8 v1(227.48,104.7) ; VRAM2503.M2 v1(247.71,108.16)
VMB_DQ32: length 17.4
  IN4 w0.089: v1(237.97,120.18) 234.51,120.18 231.99,117.67 230.95,117.67 230.6,117.32 226.65,117.32 226.58,117.39 224.04,117.39 v1(223.4,118.02)
  BOTTOM w0.14: VRAM2502.U4 238.16,120.18 v1(237.97,120.18) ; v1(223.4,118.02) U2000.F24
VMB_DQ33: length 17.1
  IN4 w0.089: v1(237.71,118.76) 234.27,118.76 232.33,116.83 226.8,116.83 226.78,116.81 226.4,116.81 226.23,116.98 223.99,116.98 v1(223.38,116.37)
  BOTTOM w0.14: v1(237.71,118.76) 237.98,118.76 VRAM2502.U2 ; v1(223.38,116.37) 223.38,116.4 U2000.G23
VMB_DQ34: length 18.1
  IN4 w0.089: v1(224.26,118.02) 224.66,117.62 230.29,117.62 230.76,118.08 231.81,118.08 234.39,120.66 238.25,120.66 238.5,120.4 238.5,120 238.93,119.57 v1(238.93,119.44)
  BOTTOM w0.14: U2000.E24 v1(224.26,118.02) ; v1(238.93,119.44) 239.31,119.81 VRAM2502.T4
VMB_DQ35: length 20.4
  IN4 w0.089: v1(222.58,116.43) 223.34,117.19 226.38,117.19 226.5,117.06 230.96,117.06 231.14,117.25 232.16,117.25 234.65,119.73 238.17,119.73 238.49,119.42 238.49,119.1 v1(238.95,118.64)
  BOTTOM w0.14: v1(238.95,118.64) 239.33,118.26 VRAM2502.T2 ; v1(222.58,116.43) 222.58,117.2 U2000.G24
VMB_DQ36: length 20.9
  IN4 w0.089: v1(225.88,115.53) 226.76,114.65 231.93,114.65 234.65,117.36 240.74,117.36 241.7,118.33 241.7,119.84 v1(241.34,120.2)
  BOTTOM w0.14: v1(225.88,115.53) 225.88,115.5 U2000.D21 ; v1(241.34,120.2) VRAM2502.N4
VMB_DQ37: length 21.8
  IN4 w0.089: v1(242.18,118.62) 242.18,118.19 240.92,116.94 234.82,116.94 232.08,114.21 229.8,114.21 229.69,114.32 226.33,114.32 226.06,114.59 225.65,115 224.78,115 224.44,115.34 v1(224.26,115.53)
  BOTTOM w0.14: VRAM2502.N2 241.78,118.21 v1(242.18,118.62) ; U2000.E21 v1(224.26,115.53)
VMB_DQ38: length 29.3
  IN4 w0.089: v1(222.58,113.88) 223.09,114.38 224.4,114.38 224.67,114.11 224.67,113.67 224.9,113.45 225.23,113.45 225.48,113.19 225.48,112.85 225.73,112.6 226.1,112.6 226.47,112.97 229.5,112.97 229.79,113.26 232.32,113.26 234.48,115.42 242.08,115.42 242.72,116.06 242.72,118.85 242.54,119.02 242.54,119.84 v1(242.92,120.22)
  BOTTOM w0.14: U2000.G21 222.58,114.7 v1(222.58,113.88) ; v1(242.92,120.22) 242.53,119.83 VRAM2502.M4
VMB_DQ39: length 23.2
  IN4 w0.089: v1(241.55,116.49) 241.03,115.97 234.44,115.97 232.15,113.68 229.6,113.68 229.33,113.41 228.88,113.41 228.88,113.41 226.35,113.41 226.29,113.47 225.71,113.47 225.5,113.68 225.5,114.23 225.08,114.65 224.28,114.65 v1(223.44,115.49)
  BOTTOM w0.14: v1(241.55,116.49) 241.55,116.64 242.13,117.23 242.13,117.57 242.53,117.96 VRAM2502.M2 ; U2000.F21 v1(223.44,115.49)
VMB_DQ40: length 18.5
  IN4 w0.089: v1(237.39,124.99) 233.1,124.99 232.16,124.05 232.16,123.34 229.79,120.97 228.65,120.97 228.46,120.78 228.46,120.77 227.82,120.13 225.71,120.13 225.28,119.7 v1(223.4,119.7)
  BOTTOM w0.14: v1(237.39,124.99) 238.1,124.99 VRAM2502.U11 ; v1(223.4,119.7) 223.01,120.1 U2000.G27
VMB_DQ41: length 17.5
  IN4 w0.089: v1(225.05,120.53) 225.07,120.54 225.51,120.54 227.57,120.54 227.57,120.56 228.5,121.5 228.94,121.5 231.25,123.81 231.25,124.62 233.39,126.75 237.83,126.75 v1(238.08,126.5)
  BOTTOM w0.14: v1(238.08,126.5) 238.08,126.57 VRAM2502.U13 ; v1(225.05,120.53) U2000.D27
VMB_DQ42: length 20.4
  IN4 w0.089: v1(222.58,119.7) 222.99,120.11 225.29,120.11 225.51,120.33 227.67,120.33 228.58,121.24 229.4,121.24 231.71,123.55 231.71,124.26 232.87,125.42 238.54,125.42 v1(238.93,125.82)
  BOTTOM w0.14: U2000.G26 v1(222.58,119.7) ; VRAM2502.T11 v1(238.93,125.82)
VMB_DQ43: length 19.5
  IN4 w0.089: v1(224.26,120.54) 224.43,120.54 224.85,120.96 225.27,120.96 225.48,120.75 227.44,120.76 227.97,121.29 227.97,121.76 229.87,123.66 230.29,123.66 230.8,124.16 230.8,124.8 233.21,127.21 238.68,127.21 238.87,127.4 238.87,127.4 238.88,127.4 238.88,127.4 238.88,127.41 v1(238.89,127.41)
  BOTTOM w0.14: v1(238.89,127.41) 238.91,127.41 239.31,127.01 VRAM2502.T13 ; U2000.E27 224.68,120.11 v1(224.26,120.54)
VMB_DQ44: length 24
  IN4 w0.089: v1(225.01,122.25) 225.31,122.25 225.68,122.62 226.85,122.62 228.21,123.98 228.21,124.62 228.58,124.99 229.04,124.99 233.45,129.4 240.59,129.4 240.92,129.07 240.92,128.13 240.96,128.1 240.96,127 240.92,126.97 240.92,126.22 v1(241.33,125.82)
  BOTTOM w0.14: VRAM2502.N11 v1(241.33,125.82) ; v1(225.01,122.25) 225.01,122.13 U2000.E29
VMB_DQ45: length 27.1
  IN4 w0.089: v1(224.26,122.27) 224.66,122.68 225.28,122.68 225.46,122.86 225.46,123.22 225.69,123.45 226.03,123.45 226.27,123.69 226.27,124.04 226.52,124.29 226.87,124.29 227.16,124.58 227.16,124.89 229.02,126.75 229.25,126.75 233.14,130.64 241.12,130.64 242.75,129.01 242.75,127.22 v1(242.14,126.61)
  BOTTOM w0.14: v1(242.14,126.61) 241.73,127.01 VRAM2502.N13 ; U2000.F29 v1(224.26,122.27)
VMB_DQ46: length 28.2
  IN4 w0.089: v1(242.13,125.81) 243.24,126.92 243.24,127.66 243.65,128.07 243.65,128.84 241.4,131.1 232.95,131.1 226.96,125.11 226.49,125.11 226.27,124.89 226.27,124.54 226.05,124.32 225.7,124.32 225.43,124.05 225.43,123.7 225.04,123.31 v1(225.04,123.12)
  BOTTOM w0.14: VRAM2502.M11 v1(242.13,125.81) ; v1(225.04,123.12) 225.04,123.12 224.68,122.76 U2000.E30
VMB_DQ47: length 22.3
  IN4 w0.089: v1(242.17,127.41) 241.83,127.75 241.83,128.93 240.91,129.85 233.22,129.85 230.14,126.76 230.14,126.54 228.89,125.29 228.31,125.29 227.1,124.09 227.1,123.68 226.85,123.43 226.46,123.43 226.07,123.04 v1(225.9,123.04)
  BOTTOM w0.14: VRAM2502.M13 242.53,127.06 v1(242.17,127.41) ; U2000.D30 225.9,123.02 v1(225.9,123.04)
VMB_DQ48: length 28.2
  IN1 w0.089: v1(228.74,124.56) 229.12,124.18 230.08,124.18 234.72,128.81 238.07,128.81 238.64,129.39 247.91,129.39 248.43,128.87 248.43,128.21 248.92,127.72 248.92,127.18 249.43,126.67 250.07,126.67 v1(250.92,125.82)
  BOTTOM w0.14: v1(250.92,125.82) 251.33,125.42 VRAM2502.A11 ; U2000.A32 228.48,124.3 v1(228.74,124.56)
VMB_DQ49: length 30.7
  IN1 w0.089: v1(226.68,123.87) 227.24,124.43 227.24,124.92 232.46,130.14 237.27,130.14 237.92,130.8 248.84,130.8 250.66,128.98 250.66,127.67 v1(250.94,127.38)
  BOTTOM w0.14: U2000.C31 226.68,123.85 v1(226.68,123.87) ; VRAM2502.A13 250.96,127.38 v1(250.94,127.38)
VMB_DQ50: length 33.9
  IN1 w0.089: v1(226.68,124.7) 226.68,124.96 232.3,130.58 237.09,130.58 237.74,131.23 249.11,131.23 251.55,128.79 251.55,125.64 v1(250.93,125.01)
  BOTTOM w0.14: U2000.C32 v1(226.68,124.7) ; VRAM2502.B11 v1(250.93,125.01)
VMB_DQ51: length 28.8
  IN1 w0.089: v1(250.15,127.4) 250.22,127.47 250.22,128.81 248.66,130.37 238.13,130.37 237.45,129.69 232.7,129.69 v1(229.22,126.22)
  BOTTOM w0.14: v1(250.15,127.4) 250.15,127.39 VRAM2502.B13 ; U2000.B32 227.48,124.7 228.17,124.7 228.5,125.03 229.01,125.03 229.22,125.24 v1(229.22,126.22)
VMB_DQ52: length 27.4
  IN1 w0.089: v1(225.88,122.2) 226.65,122.2 227.24,122.79 229.88,122.79 234.4,127.31 237.65,127.31 238.2,127.86 247.14,127.86 248.14,126.86 248.14,126.23 v1(248.54,125.84)
  BOTTOM w0.14: VRAM2502.E11 248.16,125.42 248.54,125.8 v1(248.54,125.84) ; U2000.D29 v1(225.88,122.2)
VMB_DQ53: length 22.8
  IN1 w0.089: v1(228.77,121.95) 230.38,121.95 231.17,122.74 235.44,122.74 236.43,123.73 244.84,123.73 246.47,125.35 246.47,126.01 247.05,126.6 v1(247.71,126.6)
  BOTTOM w0.14: VRAM2502.E13 v1(247.71,126.6) ; v1(228.77,121.95) 228.03,121.95 U2000.A29
VMB_DQ54: length 23.3
  IN1 w0.089: v1(226.66,121.39) 226.66,121.34 227.09,120.92 228.21,120.92 228.63,121.34 230.53,121.34 231.5,122.31 235.66,122.31 236.65,123.29 245.21,123.29 v1(246.93,125.01)
  BOTTOM w0.14: U2000.C29 226.28,121.75 226.64,121.39 v1(226.66,121.39) ; VRAM2502.F11 v1(246.93,125.01)
VMB_DQ55: length 23.3
  IN1 w0.089: v1(227.48,122.2) 227.65,122.37 230.16,122.37 230.97,123.17 235.14,123.17 236.13,124.16 243.79,124.16 244.24,124.61 245.11,124.61 246.04,125.53 246.04,126.38 246.93,127.27 v1(246.93,127.42)
  BOTTOM w0.14: v1(227.48,122.2) U2000.B29 ; VRAM2502.F13 v1(246.93,127.42)
VMB_DQ56: length 28.5
  IN1 w0.089: v1(250.95,119.41) 251.46,118.91 251.46,118.29 249.85,116.69 249.85,116.01 249.37,115.53 232.44,115.53 231.83,114.92 228.88,114.92 v1(228.28,115.53)
  BOTTOM w0.14: v1(228.28,115.53) 227.76,115.53 227.33,115.1 U2000.B21 ; v1(250.95,119.41) 251.33,119.79 VRAM2502.A4
VMB_DQ57: length 28.9
  IN1 w0.089: v1(226.72,116.37) 228.63,114.46 232.13,114.46 232.78,115.11 249.74,115.11 v1(251.84,117.2)
  BOTTOM w0.14: v1(226.72,116.37) 226.7,116.37 U2000.C23 ; v1(251.84,117.2) 251.84,117.71 VRAM2502.A2
VMB_DQ58: length 34
  IN1 w0.089: v1(250.93,120.22) 251.36,120.65 251.36,121.57 250.32,122.61 237.09,122.61 235.05,120.56 v1(229.56,120.56)
  BOTTOM w0.14: VRAM2502.B4 250.93,120.21 v1(250.93,120.22) ; v1(229.56,120.56) 229.56,119.94 231.16,118.34 231.16,116.19 229.98,115.01 227.97,115.01 U2000.A21
VMB_DQ59: length 26.4
  IN1 w0.089: v1(230.02,116.26) 230.45,115.83 231.55,115.83 232.77,117.05 245.35,117.05 245.56,116.84 247.6,116.84 248.99,118.22 249.75,118.22 v1(250.14,118.6)
  BOTTOM w0.102: 228.82,115.95 227.66,115.95 227.29,115.58 226.76,115.58 U2000.C21
  BOTTOM w0.14: 228.82,115.95 229.71,115.95 v1(230.02,116.26) ; VRAM2502.B2 250.52,118.21 v1(250.14,118.6)
VMB_DQ60: length 25
  IN1 w0.089: v1(248.53,119.42) 248.3,119.65 246.84,119.65 246.54,119.95 246.54,120.46 245.33,121.67 237.42,121.67 235.48,119.73 229.1,119.73 v1(227.55,118.18)
  BOTTOM w0.14: v1(227.55,118.18) 227.55,118.07 U2000.B24 ; VRAM2502.E4 v1(248.53,119.42)
VMB_DQ61: length 23.3
  IN1 w0.089: v1(230.72,116.42) 231.55,116.42 232.62,117.49 245.6,117.49 245.83,117.27 247.23,117.27 v1(247.74,117.78)
  BOTTOM w0.14: v1(247.74,117.78) 248.13,118.17 VRAM2502.E2 ; U2000.C24 226.68,117.2 229.94,117.2 v1(230.72,116.42)
VMB_DQ62: length 24.8
  IN1 w0.089: v1(246.98,120.21) 247.41,120.65 247.41,121.53 246.84,122.1 237.24,122.1 235.29,120.15 229,120.15 v1(228.74,120.4)
  BOTTOM w0.102: 228.19,118.98 228.12,118.91 227.64,118.91 227.25,119.3 U2000.B26
  BOTTOM w0.14: 228.19,118.98 228.74,119.53 v1(228.74,120.4) ; VRAM2502.F4 247.33,119.86 v1(246.98,120.21)
VMB_DQ63: length 21.9
  IN1 w0.089: v1(246.92,117.79) 246.74,117.97 230.44,117.97 v1(230.25,118.16)
  BOTTOM w0.14: v1(230.25,118.16) 229.75,118.66 227.54,118.66 227.27,118.93 226.65,118.93 U2000.C26 ; VRAM2502.F2 247.33,118.19 v1(246.92,117.79)
VMB_WCK01: length 20.8
  IN1 w0.081: v1(241.33,106.54) 241.07,106.28 241.07,105.49 240.54,104.96 233.03,104.96 231.51,103.44 225.01,103.44 224.55,103.9 224.55,104.41 224.43,104.53 v1(224.26,104.7)
  BOTTOM w0.114: VRAM2503.D4 v1(241.33,106.54) ; v1(224.26,104.7) 224.23,104.7 U2000.F8
